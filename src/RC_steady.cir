.title spice solver
Vg GND 0 318.15
I_0_0_0 GND Node0_0_0 0.0006510677083333324A
R_0_0_0_1 Node0_0_0 Node0_0_1 15400.000000000013
R_0_0_0_2 Node0_0_0 Node0_1_0 15400.000000000007
R_0_0_0_3 Node0_0_0 Node1_0_0 0.9856000000000009
I_0_0_1 GND Node0_0_1 0.0006510677083333324A
R_0_0_1_1 Node0_0_1 Node0_0_2 15400.000000000013
R_0_0_1_2 Node0_0_1 Node0_1_1 15400.000000000007
R_0_0_1_3 Node0_0_1 Node1_0_1 0.9856000000000009
I_0_0_2 GND Node0_0_2 0.0006510677083333324A
R_0_0_2_1 Node0_0_2 Node0_0_3 15400.000000000013
R_0_0_2_2 Node0_0_2 Node0_1_2 15400.000000000007
R_0_0_2_3 Node0_0_2 Node1_0_2 0.9856000000000009
I_0_0_3 GND Node0_0_3 0.0006510677083333324A
R_0_0_3_1 Node0_0_3 Node0_0_4 15400.000000000013
R_0_0_3_2 Node0_0_3 Node0_1_3 15400.000000000007
R_0_0_3_3 Node0_0_3 Node1_0_3 0.9856000000000009
I_0_0_4 GND Node0_0_4 0.0006510677083333324A
R_0_0_4_1 Node0_0_4 Node0_0_5 15400.000000000013
R_0_0_4_2 Node0_0_4 Node0_1_4 15400.000000000007
R_0_0_4_3 Node0_0_4 Node1_0_4 0.9856000000000009
I_0_0_5 GND Node0_0_5 0.0006510677083333324A
R_0_0_5_1 Node0_0_5 Node0_0_6 15400.000000000013
R_0_0_5_2 Node0_0_5 Node0_1_5 15400.000000000007
R_0_0_5_3 Node0_0_5 Node1_0_5 0.9856000000000009
I_0_0_6 GND Node0_0_6 0.0006510677083333324A
R_0_0_6_1 Node0_0_6 Node0_0_7 15400.000000000013
R_0_0_6_2 Node0_0_6 Node0_1_6 15400.000000000007
R_0_0_6_3 Node0_0_6 Node1_0_6 0.9856000000000009
I_0_0_7 GND Node0_0_7 0.0006510677083333324A
R_0_0_7_1 Node0_0_7 Node0_0_8 15400.000000000013
R_0_0_7_2 Node0_0_7 Node0_1_7 15400.000000000007
R_0_0_7_3 Node0_0_7 Node1_0_7 0.9856000000000009
I_0_0_8 GND Node0_0_8 0.0006510677083333324A
R_0_0_8_1 Node0_0_8 Node0_0_9 15400.000000000013
R_0_0_8_2 Node0_0_8 Node0_1_8 15400.000000000007
R_0_0_8_3 Node0_0_8 Node1_0_8 0.9856000000000009
I_0_0_9 GND Node0_0_9 0.0006510677083333324A
R_0_0_9_1 Node0_0_9 Node0_0_10 15400.000000000013
R_0_0_9_2 Node0_0_9 Node0_1_9 15400.000000000007
R_0_0_9_3 Node0_0_9 Node1_0_9 0.9856000000000009
I_0_0_10 GND Node0_0_10 0.0006510677083333324A
R_0_0_10_1 Node0_0_10 Node0_0_11 15400.000000000013
R_0_0_10_2 Node0_0_10 Node0_1_10 15400.000000000007
R_0_0_10_3 Node0_0_10 Node1_0_10 0.9856000000000009
I_0_0_11 GND Node0_0_11 0.0006510677083333324A
R_0_0_11_1 Node0_0_11 Node0_0_12 15400.000000000013
R_0_0_11_2 Node0_0_11 Node0_1_11 15400.000000000007
R_0_0_11_3 Node0_0_11 Node1_0_11 0.9856000000000009
I_0_0_12 GND Node0_0_12 0.0006510677083333324A
R_0_0_12_1 Node0_0_12 Node0_0_13 15400.000000000013
R_0_0_12_2 Node0_0_12 Node0_1_12 15400.000000000007
R_0_0_12_3 Node0_0_12 Node1_0_12 0.9856000000000009
I_0_0_13 GND Node0_0_13 0.0006510677083333324A
R_0_0_13_1 Node0_0_13 Node0_0_14 15400.000000000013
R_0_0_13_2 Node0_0_13 Node0_1_13 15400.000000000007
R_0_0_13_3 Node0_0_13 Node1_0_13 0.9856000000000009
I_0_0_14 GND Node0_0_14 0.0006510677083333324A
R_0_0_14_1 Node0_0_14 Node0_0_15 15400.000000000007
R_0_0_14_2 Node0_0_14 Node0_1_14 15400.000000000007
R_0_0_14_3 Node0_0_14 Node1_0_14 0.9856000000000009
I_0_0_15 GND Node0_0_15 0.0006510677083333328A
R_0_0_15_2 Node0_0_15 Node0_1_15 15399.999999999993
R_0_0_15_3 Node0_0_15 Node1_0_15 0.9856000000000001
I_0_1_0 GND Node0_1_0 0.0006510677083333328A
R_0_1_0_1 Node0_1_0 Node0_1_1 15400.0
R_0_1_0_2 Node0_1_0 Node0_2_0 15400.0
R_0_1_0_3 Node0_1_0 Node1_1_0 0.9856000000000001
I_0_1_1 GND Node0_1_1 0.0006510677083333328A
R_0_1_1_1 Node0_1_1 Node0_1_2 15400.0
R_0_1_1_2 Node0_1_1 Node0_2_1 15400.0
R_0_1_1_3 Node0_1_1 Node1_1_1 0.9856000000000001
I_0_1_2 GND Node0_1_2 0.0006510677083333328A
R_0_1_2_1 Node0_1_2 Node0_1_3 15400.0
R_0_1_2_2 Node0_1_2 Node0_2_2 15400.0
R_0_1_2_3 Node0_1_2 Node1_1_2 0.9856000000000001
I_0_1_3 GND Node0_1_3 0.0006510677083333328A
R_0_1_3_1 Node0_1_3 Node0_1_4 15400.0
R_0_1_3_2 Node0_1_3 Node0_2_3 15400.0
R_0_1_3_3 Node0_1_3 Node1_1_3 0.9856000000000001
I_0_1_4 GND Node0_1_4 0.0006510677083333328A
R_0_1_4_1 Node0_1_4 Node0_1_5 15400.0
R_0_1_4_2 Node0_1_4 Node0_2_4 15400.0
R_0_1_4_3 Node0_1_4 Node1_1_4 0.9856000000000001
I_0_1_5 GND Node0_1_5 0.0006510677083333328A
R_0_1_5_1 Node0_1_5 Node0_1_6 15400.0
R_0_1_5_2 Node0_1_5 Node0_2_5 15400.0
R_0_1_5_3 Node0_1_5 Node1_1_5 0.9856000000000001
I_0_1_6 GND Node0_1_6 0.0006510677083333328A
R_0_1_6_1 Node0_1_6 Node0_1_7 15400.0
R_0_1_6_2 Node0_1_6 Node0_2_6 15400.0
R_0_1_6_3 Node0_1_6 Node1_1_6 0.9856000000000001
I_0_1_7 GND Node0_1_7 0.0006510677083333328A
R_0_1_7_1 Node0_1_7 Node0_1_8 15400.0
R_0_1_7_2 Node0_1_7 Node0_2_7 15400.0
R_0_1_7_3 Node0_1_7 Node1_1_7 0.9856000000000001
I_0_1_8 GND Node0_1_8 0.0006510677083333328A
R_0_1_8_1 Node0_1_8 Node0_1_9 15400.0
R_0_1_8_2 Node0_1_8 Node0_2_8 15400.0
R_0_1_8_3 Node0_1_8 Node1_1_8 0.9856000000000001
I_0_1_9 GND Node0_1_9 0.0006510677083333328A
R_0_1_9_1 Node0_1_9 Node0_1_10 15400.0
R_0_1_9_2 Node0_1_9 Node0_2_9 15400.0
R_0_1_9_3 Node0_1_9 Node1_1_9 0.9856000000000001
I_0_1_10 GND Node0_1_10 0.0006510677083333328A
R_0_1_10_1 Node0_1_10 Node0_1_11 15400.0
R_0_1_10_2 Node0_1_10 Node0_2_10 15400.0
R_0_1_10_3 Node0_1_10 Node1_1_10 0.9856000000000001
I_0_1_11 GND Node0_1_11 0.0006510677083333328A
R_0_1_11_1 Node0_1_11 Node0_1_12 15400.0
R_0_1_11_2 Node0_1_11 Node0_2_11 15400.0
R_0_1_11_3 Node0_1_11 Node1_1_11 0.9856000000000001
I_0_1_12 GND Node0_1_12 0.0006510677083333328A
R_0_1_12_1 Node0_1_12 Node0_1_13 15400.0
R_0_1_12_2 Node0_1_12 Node0_2_12 15400.0
R_0_1_12_3 Node0_1_12 Node1_1_12 0.9856000000000001
I_0_1_13 GND Node0_1_13 0.0006510677083333328A
R_0_1_13_1 Node0_1_13 Node0_1_14 15400.0
R_0_1_13_2 Node0_1_13 Node0_2_13 15400.0
R_0_1_13_3 Node0_1_13 Node1_1_13 0.9856000000000001
I_0_1_14 GND Node0_1_14 0.0006510677083333328A
R_0_1_14_1 Node0_1_14 Node0_1_15 15399.999999999993
R_0_1_14_2 Node0_1_14 Node0_2_14 15400.0
R_0_1_14_3 Node0_1_14 Node1_1_14 0.9856000000000001
I_0_1_15 GND Node0_1_15 0.0006510677083333333A
R_0_1_15_2 Node0_1_15 Node0_2_15 15399.999999999987
R_0_1_15_3 Node0_1_15 Node1_1_15 0.9855999999999993
I_0_2_0 GND Node0_2_0 0.0006510677083333328A
R_0_2_0_1 Node0_2_0 Node0_2_1 15400.0
R_0_2_0_2 Node0_2_0 Node0_3_0 15400.0
R_0_2_0_3 Node0_2_0 Node1_2_0 0.9856000000000001
I_0_2_1 GND Node0_2_1 0.0006510677083333328A
R_0_2_1_1 Node0_2_1 Node0_2_2 15400.0
R_0_2_1_2 Node0_2_1 Node0_3_1 15400.0
R_0_2_1_3 Node0_2_1 Node1_2_1 0.9856000000000001
I_0_2_2 GND Node0_2_2 0.0006510677083333328A
R_0_2_2_1 Node0_2_2 Node0_2_3 15400.0
R_0_2_2_2 Node0_2_2 Node0_3_2 15400.0
R_0_2_2_3 Node0_2_2 Node1_2_2 0.9856000000000001
I_0_2_3 GND Node0_2_3 0.0006510677083333328A
R_0_2_3_1 Node0_2_3 Node0_2_4 15400.0
R_0_2_3_2 Node0_2_3 Node0_3_3 15400.0
R_0_2_3_3 Node0_2_3 Node1_2_3 0.9856000000000001
I_0_2_4 GND Node0_2_4 0.0006510677083333328A
R_0_2_4_1 Node0_2_4 Node0_2_5 15400.0
R_0_2_4_2 Node0_2_4 Node0_3_4 15400.0
R_0_2_4_3 Node0_2_4 Node1_2_4 0.9856000000000001
I_0_2_5 GND Node0_2_5 0.0006510677083333328A
R_0_2_5_1 Node0_2_5 Node0_2_6 15400.0
R_0_2_5_2 Node0_2_5 Node0_3_5 15400.0
R_0_2_5_3 Node0_2_5 Node1_2_5 0.9856000000000001
I_0_2_6 GND Node0_2_6 0.0006510677083333328A
R_0_2_6_1 Node0_2_6 Node0_2_7 15400.0
R_0_2_6_2 Node0_2_6 Node0_3_6 15400.0
R_0_2_6_3 Node0_2_6 Node1_2_6 0.9856000000000001
I_0_2_7 GND Node0_2_7 0.0006510677083333328A
R_0_2_7_1 Node0_2_7 Node0_2_8 15400.0
R_0_2_7_2 Node0_2_7 Node0_3_7 15400.0
R_0_2_7_3 Node0_2_7 Node1_2_7 0.9856000000000001
I_0_2_8 GND Node0_2_8 0.0006510677083333328A
R_0_2_8_1 Node0_2_8 Node0_2_9 15400.0
R_0_2_8_2 Node0_2_8 Node0_3_8 15400.0
R_0_2_8_3 Node0_2_8 Node1_2_8 0.9856000000000001
I_0_2_9 GND Node0_2_9 0.0006510677083333328A
R_0_2_9_1 Node0_2_9 Node0_2_10 15400.0
R_0_2_9_2 Node0_2_9 Node0_3_9 15400.0
R_0_2_9_3 Node0_2_9 Node1_2_9 0.9856000000000001
I_0_2_10 GND Node0_2_10 0.0006510677083333328A
R_0_2_10_1 Node0_2_10 Node0_2_11 15400.0
R_0_2_10_2 Node0_2_10 Node0_3_10 15400.0
R_0_2_10_3 Node0_2_10 Node1_2_10 0.9856000000000001
I_0_2_11 GND Node0_2_11 0.0006510677083333328A
R_0_2_11_1 Node0_2_11 Node0_2_12 15400.0
R_0_2_11_2 Node0_2_11 Node0_3_11 15400.0
R_0_2_11_3 Node0_2_11 Node1_2_11 0.9856000000000001
I_0_2_12 GND Node0_2_12 0.0006510677083333328A
R_0_2_12_1 Node0_2_12 Node0_2_13 15400.0
R_0_2_12_2 Node0_2_12 Node0_3_12 15400.0
R_0_2_12_3 Node0_2_12 Node1_2_12 0.9856000000000001
I_0_2_13 GND Node0_2_13 0.0006510677083333328A
R_0_2_13_1 Node0_2_13 Node0_2_14 15400.0
R_0_2_13_2 Node0_2_13 Node0_3_13 15400.0
R_0_2_13_3 Node0_2_13 Node1_2_13 0.9856000000000001
I_0_2_14 GND Node0_2_14 0.0006510677083333328A
R_0_2_14_1 Node0_2_14 Node0_2_15 15399.999999999993
R_0_2_14_2 Node0_2_14 Node0_3_14 15400.0
R_0_2_14_3 Node0_2_14 Node1_2_14 0.9856000000000001
I_0_2_15 GND Node0_2_15 0.0006510677083333333A
R_0_2_15_2 Node0_2_15 Node0_3_15 15399.999999999987
R_0_2_15_3 Node0_2_15 Node1_2_15 0.9855999999999993
I_0_3_0 GND Node0_3_0 0.0006510677083333328A
R_0_3_0_1 Node0_3_0 Node0_3_1 15400.0
R_0_3_0_2 Node0_3_0 Node0_4_0 15400.0
R_0_3_0_3 Node0_3_0 Node1_3_0 0.9856000000000001
I_0_3_1 GND Node0_3_1 0.0006510677083333328A
R_0_3_1_1 Node0_3_1 Node0_3_2 15400.0
R_0_3_1_2 Node0_3_1 Node0_4_1 15400.0
R_0_3_1_3 Node0_3_1 Node1_3_1 0.9856000000000001
I_0_3_2 GND Node0_3_2 0.0006510677083333328A
R_0_3_2_1 Node0_3_2 Node0_3_3 15400.0
R_0_3_2_2 Node0_3_2 Node0_4_2 15400.0
R_0_3_2_3 Node0_3_2 Node1_3_2 0.9856000000000001
I_0_3_3 GND Node0_3_3 0.0006510677083333328A
R_0_3_3_1 Node0_3_3 Node0_3_4 15400.0
R_0_3_3_2 Node0_3_3 Node0_4_3 15400.0
R_0_3_3_3 Node0_3_3 Node1_3_3 0.9856000000000001
I_0_3_4 GND Node0_3_4 0.0006510677083333328A
R_0_3_4_1 Node0_3_4 Node0_3_5 15400.0
R_0_3_4_2 Node0_3_4 Node0_4_4 15400.0
R_0_3_4_3 Node0_3_4 Node1_3_4 0.9856000000000001
I_0_3_5 GND Node0_3_5 0.0006510677083333328A
R_0_3_5_1 Node0_3_5 Node0_3_6 15400.0
R_0_3_5_2 Node0_3_5 Node0_4_5 15400.0
R_0_3_5_3 Node0_3_5 Node1_3_5 0.9856000000000001
I_0_3_6 GND Node0_3_6 0.0006510677083333328A
R_0_3_6_1 Node0_3_6 Node0_3_7 15400.0
R_0_3_6_2 Node0_3_6 Node0_4_6 15400.0
R_0_3_6_3 Node0_3_6 Node1_3_6 0.9856000000000001
I_0_3_7 GND Node0_3_7 0.0006510677083333328A
R_0_3_7_1 Node0_3_7 Node0_3_8 15400.0
R_0_3_7_2 Node0_3_7 Node0_4_7 15400.0
R_0_3_7_3 Node0_3_7 Node1_3_7 0.9856000000000001
I_0_3_8 GND Node0_3_8 0.0006510677083333328A
R_0_3_8_1 Node0_3_8 Node0_3_9 15400.0
R_0_3_8_2 Node0_3_8 Node0_4_8 15400.0
R_0_3_8_3 Node0_3_8 Node1_3_8 0.9856000000000001
I_0_3_9 GND Node0_3_9 0.0006510677083333328A
R_0_3_9_1 Node0_3_9 Node0_3_10 15400.0
R_0_3_9_2 Node0_3_9 Node0_4_9 15400.0
R_0_3_9_3 Node0_3_9 Node1_3_9 0.9856000000000001
I_0_3_10 GND Node0_3_10 0.0006510677083333328A
R_0_3_10_1 Node0_3_10 Node0_3_11 15400.0
R_0_3_10_2 Node0_3_10 Node0_4_10 15400.0
R_0_3_10_3 Node0_3_10 Node1_3_10 0.9856000000000001
I_0_3_11 GND Node0_3_11 0.0006510677083333328A
R_0_3_11_1 Node0_3_11 Node0_3_12 15400.0
R_0_3_11_2 Node0_3_11 Node0_4_11 15400.0
R_0_3_11_3 Node0_3_11 Node1_3_11 0.9856000000000001
I_0_3_12 GND Node0_3_12 0.0006510677083333328A
R_0_3_12_1 Node0_3_12 Node0_3_13 15400.0
R_0_3_12_2 Node0_3_12 Node0_4_12 15400.0
R_0_3_12_3 Node0_3_12 Node1_3_12 0.9856000000000001
I_0_3_13 GND Node0_3_13 0.0006510677083333328A
R_0_3_13_1 Node0_3_13 Node0_3_14 15400.0
R_0_3_13_2 Node0_3_13 Node0_4_13 15400.0
R_0_3_13_3 Node0_3_13 Node1_3_13 0.9856000000000001
I_0_3_14 GND Node0_3_14 0.0006510677083333328A
R_0_3_14_1 Node0_3_14 Node0_3_15 15399.999999999993
R_0_3_14_2 Node0_3_14 Node0_4_14 15400.0
R_0_3_14_3 Node0_3_14 Node1_3_14 0.9856000000000001
I_0_3_15 GND Node0_3_15 0.0006510677083333333A
R_0_3_15_2 Node0_3_15 Node0_4_15 15399.999999999987
R_0_3_15_3 Node0_3_15 Node1_3_15 0.9855999999999993
I_0_4_0 GND Node0_4_0 0.0006510677083333328A
R_0_4_0_1 Node0_4_0 Node0_4_1 15400.0
R_0_4_0_2 Node0_4_0 Node0_5_0 15400.0
R_0_4_0_3 Node0_4_0 Node1_4_0 0.9856000000000001
I_0_4_1 GND Node0_4_1 0.0006510677083333328A
R_0_4_1_1 Node0_4_1 Node0_4_2 15400.0
R_0_4_1_2 Node0_4_1 Node0_5_1 15400.0
R_0_4_1_3 Node0_4_1 Node1_4_1 0.9856000000000001
I_0_4_2 GND Node0_4_2 0.0006510677083333328A
R_0_4_2_1 Node0_4_2 Node0_4_3 15400.0
R_0_4_2_2 Node0_4_2 Node0_5_2 15400.0
R_0_4_2_3 Node0_4_2 Node1_4_2 0.9856000000000001
I_0_4_3 GND Node0_4_3 0.0006510677083333328A
R_0_4_3_1 Node0_4_3 Node0_4_4 15400.0
R_0_4_3_2 Node0_4_3 Node0_5_3 15400.0
R_0_4_3_3 Node0_4_3 Node1_4_3 0.9856000000000001
I_0_4_4 GND Node0_4_4 0.0006510677083333328A
R_0_4_4_1 Node0_4_4 Node0_4_5 15400.0
R_0_4_4_2 Node0_4_4 Node0_5_4 15400.0
R_0_4_4_3 Node0_4_4 Node1_4_4 0.9856000000000001
I_0_4_5 GND Node0_4_5 0.0006510677083333328A
R_0_4_5_1 Node0_4_5 Node0_4_6 15400.0
R_0_4_5_2 Node0_4_5 Node0_5_5 15400.0
R_0_4_5_3 Node0_4_5 Node1_4_5 0.9856000000000001
I_0_4_6 GND Node0_4_6 0.0006510677083333328A
R_0_4_6_1 Node0_4_6 Node0_4_7 15400.0
R_0_4_6_2 Node0_4_6 Node0_5_6 15400.0
R_0_4_6_3 Node0_4_6 Node1_4_6 0.9856000000000001
I_0_4_7 GND Node0_4_7 0.0006510677083333328A
R_0_4_7_1 Node0_4_7 Node0_4_8 15400.0
R_0_4_7_2 Node0_4_7 Node0_5_7 15400.0
R_0_4_7_3 Node0_4_7 Node1_4_7 0.9856000000000001
I_0_4_8 GND Node0_4_8 0.0006510677083333328A
R_0_4_8_1 Node0_4_8 Node0_4_9 15400.0
R_0_4_8_2 Node0_4_8 Node0_5_8 15400.0
R_0_4_8_3 Node0_4_8 Node1_4_8 0.9856000000000001
I_0_4_9 GND Node0_4_9 0.0006510677083333328A
R_0_4_9_1 Node0_4_9 Node0_4_10 15400.0
R_0_4_9_2 Node0_4_9 Node0_5_9 15400.0
R_0_4_9_3 Node0_4_9 Node1_4_9 0.9856000000000001
I_0_4_10 GND Node0_4_10 0.0006510677083333328A
R_0_4_10_1 Node0_4_10 Node0_4_11 15400.0
R_0_4_10_2 Node0_4_10 Node0_5_10 15400.0
R_0_4_10_3 Node0_4_10 Node1_4_10 0.9856000000000001
I_0_4_11 GND Node0_4_11 0.0006510677083333328A
R_0_4_11_1 Node0_4_11 Node0_4_12 15400.0
R_0_4_11_2 Node0_4_11 Node0_5_11 15400.0
R_0_4_11_3 Node0_4_11 Node1_4_11 0.9856000000000001
I_0_4_12 GND Node0_4_12 0.0006510677083333328A
R_0_4_12_1 Node0_4_12 Node0_4_13 15400.0
R_0_4_12_2 Node0_4_12 Node0_5_12 15400.0
R_0_4_12_3 Node0_4_12 Node1_4_12 0.9856000000000001
I_0_4_13 GND Node0_4_13 0.0006510677083333328A
R_0_4_13_1 Node0_4_13 Node0_4_14 15400.0
R_0_4_13_2 Node0_4_13 Node0_5_13 15400.0
R_0_4_13_3 Node0_4_13 Node1_4_13 0.9856000000000001
I_0_4_14 GND Node0_4_14 0.0006510677083333328A
R_0_4_14_1 Node0_4_14 Node0_4_15 15399.999999999993
R_0_4_14_2 Node0_4_14 Node0_5_14 15400.0
R_0_4_14_3 Node0_4_14 Node1_4_14 0.9856000000000001
I_0_4_15 GND Node0_4_15 0.0006510677083333333A
R_0_4_15_2 Node0_4_15 Node0_5_15 15399.999999999987
R_0_4_15_3 Node0_4_15 Node1_4_15 0.9855999999999993
I_0_5_0 GND Node0_5_0 0.0006510677083333328A
R_0_5_0_1 Node0_5_0 Node0_5_1 15400.0
R_0_5_0_2 Node0_5_0 Node0_6_0 11200.000000000004
R_0_5_0_3 Node0_5_0 Node1_5_0 0.9856000000000001
I_0_5_1 GND Node0_5_1 0.0006510677083333328A
R_0_5_1_1 Node0_5_1 Node0_5_2 15400.0
R_0_5_1_2 Node0_5_1 Node0_6_1 11200.000000000004
R_0_5_1_3 Node0_5_1 Node1_5_1 0.9856000000000001
I_0_5_2 GND Node0_5_2 0.0006510677083333328A
R_0_5_2_1 Node0_5_2 Node0_5_3 15400.0
R_0_5_2_2 Node0_5_2 Node0_6_2 11200.000000000004
R_0_5_2_3 Node0_5_2 Node1_5_2 0.9856000000000001
I_0_5_3 GND Node0_5_3 0.0006510677083333328A
R_0_5_3_1 Node0_5_3 Node0_5_4 15400.0
R_0_5_3_2 Node0_5_3 Node0_6_3 12176.744186046515
R_0_5_3_3 Node0_5_3 Node1_5_3 0.9856000000000001
I_0_5_4 GND Node0_5_4 0.0006510677083333328A
R_0_5_4_1 Node0_5_4 Node0_5_5 15400.0
R_0_5_4_2 Node0_5_4 Node0_6_4 12512.500000000004
R_0_5_4_3 Node0_5_4 Node1_5_4 0.9856000000000001
I_0_5_5 GND Node0_5_5 0.0006510677083333328A
R_0_5_5_1 Node0_5_5 Node0_5_6 15400.0
R_0_5_5_2 Node0_5_5 Node0_6_5 12512.500000000004
R_0_5_5_3 Node0_5_5 Node1_5_5 0.9856000000000001
I_0_5_6 GND Node0_5_6 0.0006510677083333328A
R_0_5_6_1 Node0_5_6 Node0_5_7 15400.0
R_0_5_6_2 Node0_5_6 Node0_6_6 16449.999999999996
R_0_5_6_3 Node0_5_6 Node1_5_6 0.9856000000000001
I_0_5_7 GND Node0_5_7 0.0006510677083333328A
R_0_5_7_1 Node0_5_7 Node0_5_8 15400.0
R_0_5_7_2 Node0_5_7 Node0_6_7 26949.999999999953
R_0_5_7_3 Node0_5_7 Node1_5_7 0.9856000000000001
I_0_5_8 GND Node0_5_8 0.0006510677083333328A
R_0_5_8_1 Node0_5_8 Node0_5_9 15400.0
R_0_5_8_2 Node0_5_8 Node0_6_8 26949.999999999953
R_0_5_8_3 Node0_5_8 Node1_5_8 0.9856000000000001
I_0_5_9 GND Node0_5_9 0.0006510677083333328A
R_0_5_9_1 Node0_5_9 Node0_5_10 15400.0
R_0_5_9_2 Node0_5_9 Node0_6_9 26949.999999999953
R_0_5_9_3 Node0_5_9 Node1_5_9 0.9856000000000001
I_0_5_10 GND Node0_5_10 0.0006510677083333328A
R_0_5_10_1 Node0_5_10 Node0_5_11 15400.0
R_0_5_10_2 Node0_5_10 Node0_6_10 26949.999999999953
R_0_5_10_3 Node0_5_10 Node1_5_10 0.9856000000000001
I_0_5_11 GND Node0_5_11 0.0006510677083333328A
R_0_5_11_1 Node0_5_11 Node0_5_12 15400.0
R_0_5_11_2 Node0_5_11 Node0_6_11 26949.999999999953
R_0_5_11_3 Node0_5_11 Node1_5_11 0.9856000000000001
I_0_5_12 GND Node0_5_12 0.0006510677083333328A
R_0_5_12_1 Node0_5_12 Node0_5_13 15400.0
R_0_5_12_2 Node0_5_12 Node0_6_12 26949.999999999953
R_0_5_12_3 Node0_5_12 Node1_5_12 0.9856000000000001
I_0_5_13 GND Node0_5_13 0.0006510677083333328A
R_0_5_13_1 Node0_5_13 Node0_5_14 15400.0
R_0_5_13_2 Node0_5_13 Node0_6_13 26949.999999999953
R_0_5_13_3 Node0_5_13 Node1_5_13 0.9856000000000001
I_0_5_14 GND Node0_5_14 0.0006510677083333328A
R_0_5_14_1 Node0_5_14 Node0_5_15 15399.999999999993
R_0_5_14_2 Node0_5_14 Node0_6_14 26949.999999999953
R_0_5_14_3 Node0_5_14 Node1_5_14 0.9856000000000001
I_0_5_15 GND Node0_5_15 0.0006510677083333333A
R_0_5_15_2 Node0_5_15 Node0_6_15 26949.999999999924
R_0_5_15_3 Node0_5_15 Node1_5_15 0.9855999999999993
I_0_6_0 GND Node0_6_0 0.012760473958333313A
R_0_6_0_1 Node0_6_0 Node0_6_1 7000.000000000007
R_0_6_0_2 Node0_6_0 Node0_7_0 6066.66666666667
R_0_6_0_3 Node0_6_0 Node1_6_0 0.44800000000000045
I_0_6_1 GND Node0_6_1 0.012760473958333313A
R_0_6_1_1 Node0_6_1 Node0_6_2 7000.000000000007
R_0_6_1_2 Node0_6_1 Node0_7_1 6066.66666666667
R_0_6_1_3 Node0_6_1 Node1_6_1 0.44800000000000045
I_0_6_2 GND Node0_6_2 0.012760473958333313A
R_0_6_2_1 Node0_6_2 Node0_6_3 7976.744186046519
R_0_6_2_2 Node0_6_2 Node0_7_2 6066.66666666667
R_0_6_2_3 Node0_6_2 Node1_6_2 0.44800000000000045
I_0_6_3 GND Node0_6_3 0.0033854614583333285A
R_0_6_3_1 Node0_6_3 Node0_6_4 9289.244186046519
R_0_6_3_2 Node0_6_3 Node0_7_3 7976.744186046515
R_0_6_3_3 Node0_6_3 Node1_6_3 0.573023255813954
I_0_6_4 GND Node0_6_4 0.0010417083333333333A
R_0_6_4_1 Node0_6_4 Node0_6_5 9625.000000000007
R_0_6_4_2 Node0_6_4 Node0_7_4 8662.500000000004
R_0_6_4_3 Node0_6_4 Node1_6_4 0.6160000000000005
I_0_6_5 GND Node0_6_5 0.0010417083333333333A
R_0_6_5_1 Node0_6_5 Node0_6_6 13562.5
R_0_6_5_2 Node0_6_5 Node0_7_5 8662.500000000004
R_0_6_5_3 Node0_6_5 Node1_6_5 0.6160000000000005
I_0_6_6 GND Node0_6_6 0.0005729395833333334A
R_0_6_6_1 Node0_6_6 Node0_6_7 27999.99999999995
R_0_6_6_2 Node0_6_6 Node0_7_6 18374.999999999993
R_0_6_6_3 Node0_6_6 Node1_6_6 1.1199999999999994
I_0_6_7 GND Node0_6_7 0.0002604270833333342A
R_0_6_7_1 Node0_6_7 Node0_6_8 38499.999999999905
R_0_6_7_2 Node0_6_7 Node0_7_7 19250.000000499953
R_0_6_7_3 Node0_6_7 Node1_6_7 2.4639999999999938
I_0_6_8 GND Node0_6_8 0.0002604270833333342A
R_0_6_8_1 Node0_6_8 Node0_6_9 38499.999999999905
R_0_6_8_2 Node0_6_8 Node0_7_8 19250.000000499953
R_0_6_8_3 Node0_6_8 Node1_6_8 2.4639999999999938
I_0_6_9 GND Node0_6_9 0.0002604270833333342A
R_0_6_9_1 Node0_6_9 Node0_6_10 38499.999999999905
R_0_6_9_2 Node0_6_9 Node0_7_9 19250.000000499953
R_0_6_9_3 Node0_6_9 Node1_6_9 2.4639999999999938
I_0_6_10 GND Node0_6_10 0.0002604270833333342A
R_0_6_10_1 Node0_6_10 Node0_6_11 38499.999999999905
R_0_6_10_2 Node0_6_10 Node0_7_10 19250.000000499953
R_0_6_10_3 Node0_6_10 Node1_6_10 2.4639999999999938
I_0_6_11 GND Node0_6_11 0.0002604270833333342A
R_0_6_11_1 Node0_6_11 Node0_6_12 38499.999999999905
R_0_6_11_2 Node0_6_11 Node0_7_11 19250.000000499953
R_0_6_11_3 Node0_6_11 Node1_6_11 2.4639999999999938
I_0_6_12 GND Node0_6_12 0.0002604270833333342A
R_0_6_12_1 Node0_6_12 Node0_6_13 38499.999999999905
R_0_6_12_2 Node0_6_12 Node0_7_12 19250.000000499953
R_0_6_12_3 Node0_6_12 Node1_6_12 2.4639999999999938
I_0_6_13 GND Node0_6_13 0.0002604270833333342A
R_0_6_13_1 Node0_6_13 Node0_6_14 38499.999999999905
R_0_6_13_2 Node0_6_13 Node0_7_13 19250.000000499953
R_0_6_13_3 Node0_6_13 Node1_6_13 2.4639999999999938
I_0_6_14 GND Node0_6_14 0.0002604270833333342A
R_0_6_14_1 Node0_6_14 Node0_6_15 38499.99999999988
R_0_6_14_2 Node0_6_14 Node0_7_14 19250.000000499953
R_0_6_14_3 Node0_6_14 Node1_6_14 2.4639999999999938
I_0_6_15 GND Node0_6_15 0.0002604270833333344A
R_0_6_15_2 Node0_6_15 Node0_7_15 19250.00000049993
R_0_6_15_3 Node0_6_15 Node1_6_15 2.4639999999999915
I_0_7_0 GND Node0_7_0 0.020833411458333343A
R_0_7_0_1 Node0_7_0 Node0_7_1 5133.333333333333
R_0_7_0_2 Node0_7_0 Node0_8_0 5133.333333333333
R_0_7_0_3 Node0_7_0 Node1_7_0 0.32853333333333334
I_0_7_1 GND Node0_7_1 0.020833411458333343A
R_0_7_1_1 Node0_7_1 Node0_7_2 5133.333333333333
R_0_7_1_2 Node0_7_1 Node0_8_1 5133.333333333333
R_0_7_1_3 Node0_7_1 Node1_7_1 0.32853333333333334
I_0_7_2 GND Node0_7_2 0.020833411458333343A
R_0_7_2_1 Node0_7_2 Node0_7_3 6066.666666666666
R_0_7_2_2 Node0_7_2 Node0_8_2 5133.333333333333
R_0_7_2_3 Node0_7_2 Node1_7_2 0.32853333333333334
I_0_7_3 GND Node0_7_3 0.0052083906250000025A
R_0_7_3_1 Node0_7_3 Node0_7_4 7350.0
R_0_7_3_2 Node0_7_3 Node0_8_3 6999.999999999999
R_0_7_3_3 Node0_7_3 Node1_7_3 0.44800000000000006
I_0_7_4 GND Node0_7_4 0.0013021354166666656A
R_0_7_4_1 Node0_7_4 Node0_7_5 7700.0
R_0_7_4_2 Node0_7_4 Node0_8_4 7700.0
R_0_7_4_3 Node0_7_4 Node1_7_4 0.49280000000000007
I_0_7_5 GND Node0_7_5 0.0013021354166666656A
R_0_7_5_1 Node0_7_5 Node0_7_6 13474.999999999996
R_0_7_5_2 Node0_7_5 Node0_8_5 7700.0
R_0_7_5_3 Node0_7_5 Node1_7_5 0.49280000000000007
I_0_7_6 GND Node0_7_6 0.0005208541666666673A
R_0_7_6_1 Node0_7_6 Node0_7_7 9625.000000499997
R_0_7_6_2 Node0_7_6 Node0_8_6 19249.999999999993
R_0_7_6_3 Node0_7_6 Node1_7_6 1.2319999999999995
R_0_7_7_1 Node0_7_7 Node0_7_8 1e-06
R_0_7_7_2 Node0_7_7 Node0_8_7 1e-06
R_0_7_7_3 Node0_7_7 Node1_7_7 1e-06
R_0_7_8_1 Node0_7_8 Node0_7_9 1e-06
R_0_7_8_2 Node0_7_8 Node0_8_8 1e-06
R_0_7_8_3 Node0_7_8 Node1_7_8 1e-06
R_0_7_9_1 Node0_7_9 Node0_7_10 1e-06
R_0_7_9_2 Node0_7_9 Node0_8_9 1e-06
R_0_7_9_3 Node0_7_9 Node1_7_9 1e-06
R_0_7_10_1 Node0_7_10 Node0_7_11 1e-06
R_0_7_10_2 Node0_7_10 Node0_8_10 1e-06
R_0_7_10_3 Node0_7_10 Node1_7_10 1e-06
R_0_7_11_1 Node0_7_11 Node0_7_12 1e-06
R_0_7_11_2 Node0_7_11 Node0_8_11 1e-06
R_0_7_11_3 Node0_7_11 Node1_7_11 1e-06
R_0_7_12_1 Node0_7_12 Node0_7_13 1e-06
R_0_7_12_2 Node0_7_12 Node0_8_12 1e-06
R_0_7_12_3 Node0_7_12 Node1_7_12 1e-06
R_0_7_13_1 Node0_7_13 Node0_7_14 1e-06
R_0_7_13_2 Node0_7_13 Node0_8_13 1e-06
R_0_7_13_3 Node0_7_13 Node1_7_13 1e-06
R_0_7_14_1 Node0_7_14 Node0_7_15 1e-06
R_0_7_14_2 Node0_7_14 Node0_8_14 1e-06
R_0_7_14_3 Node0_7_14 Node1_7_14 1e-06
R_0_7_15_2 Node0_7_15 Node0_8_15 1e-06
R_0_7_15_3 Node0_7_15 Node1_7_15 1e-06
I_0_8_0 GND Node0_8_0 0.020833411458333343A
R_0_8_0_1 Node0_8_0 Node0_8_1 5133.333333333333
R_0_8_0_2 Node0_8_0 Node0_9_0 6066.666666666668
R_0_8_0_3 Node0_8_0 Node1_8_0 0.32853333333333334
I_0_8_1 GND Node0_8_1 0.020833411458333343A
R_0_8_1_1 Node0_8_1 Node0_8_2 5133.333333333333
R_0_8_1_2 Node0_8_1 Node0_9_1 6066.666666666668
R_0_8_1_3 Node0_8_1 Node1_8_1 0.32853333333333334
I_0_8_2 GND Node0_8_2 0.020833411458333343A
R_0_8_2_1 Node0_8_2 Node0_8_3 6066.666666666666
R_0_8_2_2 Node0_8_2 Node0_9_2 6066.666666666668
R_0_8_2_3 Node0_8_2 Node1_8_2 0.32853333333333334
I_0_8_3 GND Node0_8_3 0.0052083906250000025A
R_0_8_3_1 Node0_8_3 Node0_8_4 7350.0
R_0_8_3_2 Node0_8_3 Node0_9_3 7976.744186046513
R_0_8_3_3 Node0_8_3 Node1_8_3 0.44800000000000006
I_0_8_4 GND Node0_8_4 0.0013021354166666656A
R_0_8_4_1 Node0_8_4 Node0_8_5 7700.0
R_0_8_4_2 Node0_8_4 Node0_9_4 8662.500000000004
R_0_8_4_3 Node0_8_4 Node1_8_4 0.49280000000000007
I_0_8_5 GND Node0_8_5 0.0013021354166666656A
R_0_8_5_1 Node0_8_5 Node0_8_6 13474.999999999996
R_0_8_5_2 Node0_8_5 Node0_9_5 8662.500000000004
R_0_8_5_3 Node0_8_5 Node1_8_5 0.49280000000000007
I_0_8_6 GND Node0_8_6 0.0005208541666666673A
R_0_8_6_1 Node0_8_6 Node0_8_7 9625.000000499997
R_0_8_6_2 Node0_8_6 Node0_9_6 18375.000000000004
R_0_8_6_3 Node0_8_6 Node1_8_6 1.2319999999999995
R_0_8_7_1 Node0_8_7 Node0_8_8 1e-06
R_0_8_7_2 Node0_8_7 Node0_9_7 19250.000000500033
R_0_8_7_3 Node0_8_7 Node1_8_7 1e-06
R_0_8_8_1 Node0_8_8 Node0_8_9 1e-06
R_0_8_8_2 Node0_8_8 Node0_9_8 19250.000000500033
R_0_8_8_3 Node0_8_8 Node1_8_8 1e-06
R_0_8_9_1 Node0_8_9 Node0_8_10 1e-06
R_0_8_9_2 Node0_8_9 Node0_9_9 19250.000000500033
R_0_8_9_3 Node0_8_9 Node1_8_9 1e-06
R_0_8_10_1 Node0_8_10 Node0_8_11 1e-06
R_0_8_10_2 Node0_8_10 Node0_9_10 19250.000000500033
R_0_8_10_3 Node0_8_10 Node1_8_10 1e-06
R_0_8_11_1 Node0_8_11 Node0_8_12 1e-06
R_0_8_11_2 Node0_8_11 Node0_9_11 19250.000000500033
R_0_8_11_3 Node0_8_11 Node1_8_11 1e-06
R_0_8_12_1 Node0_8_12 Node0_8_13 1e-06
R_0_8_12_2 Node0_8_12 Node0_9_12 19250.000000500033
R_0_8_12_3 Node0_8_12 Node1_8_12 1e-06
R_0_8_13_1 Node0_8_13 Node0_8_14 1e-06
R_0_8_13_2 Node0_8_13 Node0_9_13 19250.000000500033
R_0_8_13_3 Node0_8_13 Node1_8_13 1e-06
R_0_8_14_1 Node0_8_14 Node0_8_15 1e-06
R_0_8_14_2 Node0_8_14 Node0_9_14 19250.000000500033
R_0_8_14_3 Node0_8_14 Node1_8_14 1e-06
R_0_8_15_2 Node0_8_15 Node0_9_15 19250.000000500015
R_0_8_15_3 Node0_8_15 Node1_8_15 1e-06
I_0_9_0 GND Node0_9_0 0.012760473958333332A
R_0_9_0_1 Node0_9_0 Node0_9_1 7000.000000000004
R_0_9_0_2 Node0_9_0 Node0_10_0 11200.000000000002
R_0_9_0_3 Node0_9_0 Node1_9_0 0.44800000000000023
I_0_9_1 GND Node0_9_1 0.012760473958333332A
R_0_9_1_1 Node0_9_1 Node0_9_2 7000.000000000004
R_0_9_1_2 Node0_9_1 Node0_10_1 11200.000000000002
R_0_9_1_3 Node0_9_1 Node1_9_1 0.44800000000000023
I_0_9_2 GND Node0_9_2 0.012760473958333332A
R_0_9_2_1 Node0_9_2 Node0_9_3 7976.744186046516
R_0_9_2_2 Node0_9_2 Node0_10_2 11200.000000000002
R_0_9_2_3 Node0_9_2 Node1_9_2 0.44800000000000023
I_0_9_3 GND Node0_9_3 0.003385461458333331A
R_0_9_3_1 Node0_9_3 Node0_9_4 9289.244186046517
R_0_9_3_2 Node0_9_3 Node0_10_3 12176.744186046515
R_0_9_3_3 Node0_9_3 Node1_9_3 0.5730232558139539
I_0_9_4 GND Node0_9_4 0.0010417083333333333A
R_0_9_4_1 Node0_9_4 Node0_9_5 9625.000000000005
R_0_9_4_2 Node0_9_4 Node0_10_4 12512.500000000004
R_0_9_4_3 Node0_9_4 Node1_9_4 0.6160000000000004
I_0_9_5 GND Node0_9_5 0.0010417083333333333A
R_0_9_5_1 Node0_9_5 Node0_9_6 13562.500000000011
R_0_9_5_2 Node0_9_5 Node0_10_5 12512.500000000004
R_0_9_5_3 Node0_9_5 Node1_9_5 0.6160000000000004
I_0_9_6 GND Node0_9_6 0.0005729395833333327A
R_0_9_6_1 Node0_9_6 Node0_9_7 28000.00000000004
R_0_9_6_2 Node0_9_6 Node0_10_6 16450.000000000007
R_0_9_6_3 Node0_9_6 Node1_9_6 1.1200000000000008
I_0_9_7 GND Node0_9_7 0.00026042708333333305A
R_0_9_7_1 Node0_9_7 Node0_9_8 38500.000000000065
R_0_9_7_2 Node0_9_7 Node0_10_7 26950.000000000033
R_0_9_7_3 Node0_9_7 Node1_9_7 2.4640000000000044
I_0_9_8 GND Node0_9_8 0.00026042708333333305A
R_0_9_8_1 Node0_9_8 Node0_9_9 38500.000000000065
R_0_9_8_2 Node0_9_8 Node0_10_8 26950.000000000033
R_0_9_8_3 Node0_9_8 Node1_9_8 2.4640000000000044
I_0_9_9 GND Node0_9_9 0.00026042708333333305A
R_0_9_9_1 Node0_9_9 Node0_9_10 38500.000000000065
R_0_9_9_2 Node0_9_9 Node0_10_9 26950.000000000033
R_0_9_9_3 Node0_9_9 Node1_9_9 2.4640000000000044
I_0_9_10 GND Node0_9_10 0.00026042708333333305A
R_0_9_10_1 Node0_9_10 Node0_9_11 38500.000000000065
R_0_9_10_2 Node0_9_10 Node0_10_10 26950.000000000033
R_0_9_10_3 Node0_9_10 Node1_9_10 2.4640000000000044
I_0_9_11 GND Node0_9_11 0.00026042708333333305A
R_0_9_11_1 Node0_9_11 Node0_9_12 38500.000000000065
R_0_9_11_2 Node0_9_11 Node0_10_11 26950.000000000033
R_0_9_11_3 Node0_9_11 Node1_9_11 2.4640000000000044
I_0_9_12 GND Node0_9_12 0.00026042708333333305A
R_0_9_12_1 Node0_9_12 Node0_9_13 38500.000000000065
R_0_9_12_2 Node0_9_12 Node0_10_12 26950.000000000033
R_0_9_12_3 Node0_9_12 Node1_9_12 2.4640000000000044
I_0_9_13 GND Node0_9_13 0.00026042708333333305A
R_0_9_13_1 Node0_9_13 Node0_9_14 38500.000000000065
R_0_9_13_2 Node0_9_13 Node0_10_13 26950.000000000033
R_0_9_13_3 Node0_9_13 Node1_9_13 2.4640000000000044
I_0_9_14 GND Node0_9_14 0.00026042708333333305A
R_0_9_14_1 Node0_9_14 Node0_9_15 38500.000000000044
R_0_9_14_2 Node0_9_14 Node0_10_14 26950.000000000033
R_0_9_14_3 Node0_9_14 Node1_9_14 2.4640000000000044
I_0_9_15 GND Node0_9_15 0.0002604270833333332A
R_0_9_15_2 Node0_9_15 Node0_10_15 26950.000000000007
R_0_9_15_3 Node0_9_15 Node1_9_15 2.464000000000002
I_0_10_0 GND Node0_10_0 0.0006510677083333328A
R_0_10_0_1 Node0_10_0 Node0_10_1 15400.0
R_0_10_0_2 Node0_10_0 Node0_11_0 15400.0
R_0_10_0_3 Node0_10_0 Node1_10_0 0.9856000000000001
I_0_10_1 GND Node0_10_1 0.0006510677083333328A
R_0_10_1_1 Node0_10_1 Node0_10_2 15400.0
R_0_10_1_2 Node0_10_1 Node0_11_1 15400.0
R_0_10_1_3 Node0_10_1 Node1_10_1 0.9856000000000001
I_0_10_2 GND Node0_10_2 0.0006510677083333328A
R_0_10_2_1 Node0_10_2 Node0_10_3 15400.0
R_0_10_2_2 Node0_10_2 Node0_11_2 15400.0
R_0_10_2_3 Node0_10_2 Node1_10_2 0.9856000000000001
I_0_10_3 GND Node0_10_3 0.0006510677083333328A
R_0_10_3_1 Node0_10_3 Node0_10_4 15400.0
R_0_10_3_2 Node0_10_3 Node0_11_3 15400.0
R_0_10_3_3 Node0_10_3 Node1_10_3 0.9856000000000001
I_0_10_4 GND Node0_10_4 0.0006510677083333328A
R_0_10_4_1 Node0_10_4 Node0_10_5 15400.0
R_0_10_4_2 Node0_10_4 Node0_11_4 15400.0
R_0_10_4_3 Node0_10_4 Node1_10_4 0.9856000000000001
I_0_10_5 GND Node0_10_5 0.0006510677083333328A
R_0_10_5_1 Node0_10_5 Node0_10_6 15400.0
R_0_10_5_2 Node0_10_5 Node0_11_5 15400.0
R_0_10_5_3 Node0_10_5 Node1_10_5 0.9856000000000001
I_0_10_6 GND Node0_10_6 0.0006510677083333328A
R_0_10_6_1 Node0_10_6 Node0_10_7 15400.0
R_0_10_6_2 Node0_10_6 Node0_11_6 15400.0
R_0_10_6_3 Node0_10_6 Node1_10_6 0.9856000000000001
I_0_10_7 GND Node0_10_7 0.0006510677083333328A
R_0_10_7_1 Node0_10_7 Node0_10_8 15400.0
R_0_10_7_2 Node0_10_7 Node0_11_7 15400.0
R_0_10_7_3 Node0_10_7 Node1_10_7 0.9856000000000001
I_0_10_8 GND Node0_10_8 0.0006510677083333328A
R_0_10_8_1 Node0_10_8 Node0_10_9 15400.0
R_0_10_8_2 Node0_10_8 Node0_11_8 15400.0
R_0_10_8_3 Node0_10_8 Node1_10_8 0.9856000000000001
I_0_10_9 GND Node0_10_9 0.0006510677083333328A
R_0_10_9_1 Node0_10_9 Node0_10_10 15400.0
R_0_10_9_2 Node0_10_9 Node0_11_9 15400.0
R_0_10_9_3 Node0_10_9 Node1_10_9 0.9856000000000001
I_0_10_10 GND Node0_10_10 0.0006510677083333328A
R_0_10_10_1 Node0_10_10 Node0_10_11 15400.0
R_0_10_10_2 Node0_10_10 Node0_11_10 15400.0
R_0_10_10_3 Node0_10_10 Node1_10_10 0.9856000000000001
I_0_10_11 GND Node0_10_11 0.0006510677083333328A
R_0_10_11_1 Node0_10_11 Node0_10_12 15400.0
R_0_10_11_2 Node0_10_11 Node0_11_11 15400.0
R_0_10_11_3 Node0_10_11 Node1_10_11 0.9856000000000001
I_0_10_12 GND Node0_10_12 0.0006510677083333328A
R_0_10_12_1 Node0_10_12 Node0_10_13 15400.0
R_0_10_12_2 Node0_10_12 Node0_11_12 15400.0
R_0_10_12_3 Node0_10_12 Node1_10_12 0.9856000000000001
I_0_10_13 GND Node0_10_13 0.0006510677083333328A
R_0_10_13_1 Node0_10_13 Node0_10_14 15400.0
R_0_10_13_2 Node0_10_13 Node0_11_13 15400.0
R_0_10_13_3 Node0_10_13 Node1_10_13 0.9856000000000001
I_0_10_14 GND Node0_10_14 0.0006510677083333328A
R_0_10_14_1 Node0_10_14 Node0_10_15 15399.999999999993
R_0_10_14_2 Node0_10_14 Node0_11_14 15400.0
R_0_10_14_3 Node0_10_14 Node1_10_14 0.9856000000000001
I_0_10_15 GND Node0_10_15 0.0006510677083333333A
R_0_10_15_2 Node0_10_15 Node0_11_15 15399.999999999987
R_0_10_15_3 Node0_10_15 Node1_10_15 0.9855999999999993
I_0_11_0 GND Node0_11_0 0.0006510677083333328A
R_0_11_0_1 Node0_11_0 Node0_11_1 15400.0
R_0_11_0_2 Node0_11_0 Node0_12_0 15400.0
R_0_11_0_3 Node0_11_0 Node1_11_0 0.9856000000000001
I_0_11_1 GND Node0_11_1 0.0006510677083333328A
R_0_11_1_1 Node0_11_1 Node0_11_2 15400.0
R_0_11_1_2 Node0_11_1 Node0_12_1 15400.0
R_0_11_1_3 Node0_11_1 Node1_11_1 0.9856000000000001
I_0_11_2 GND Node0_11_2 0.0006510677083333328A
R_0_11_2_1 Node0_11_2 Node0_11_3 15400.0
R_0_11_2_2 Node0_11_2 Node0_12_2 15400.0
R_0_11_2_3 Node0_11_2 Node1_11_2 0.9856000000000001
I_0_11_3 GND Node0_11_3 0.0006510677083333328A
R_0_11_3_1 Node0_11_3 Node0_11_4 15400.0
R_0_11_3_2 Node0_11_3 Node0_12_3 15400.0
R_0_11_3_3 Node0_11_3 Node1_11_3 0.9856000000000001
I_0_11_4 GND Node0_11_4 0.0006510677083333328A
R_0_11_4_1 Node0_11_4 Node0_11_5 15400.0
R_0_11_4_2 Node0_11_4 Node0_12_4 15400.0
R_0_11_4_3 Node0_11_4 Node1_11_4 0.9856000000000001
I_0_11_5 GND Node0_11_5 0.0006510677083333328A
R_0_11_5_1 Node0_11_5 Node0_11_6 15400.0
R_0_11_5_2 Node0_11_5 Node0_12_5 15400.0
R_0_11_5_3 Node0_11_5 Node1_11_5 0.9856000000000001
I_0_11_6 GND Node0_11_6 0.0006510677083333328A
R_0_11_6_1 Node0_11_6 Node0_11_7 15400.0
R_0_11_6_2 Node0_11_6 Node0_12_6 15400.0
R_0_11_6_3 Node0_11_6 Node1_11_6 0.9856000000000001
I_0_11_7 GND Node0_11_7 0.0006510677083333328A
R_0_11_7_1 Node0_11_7 Node0_11_8 15400.0
R_0_11_7_2 Node0_11_7 Node0_12_7 15400.0
R_0_11_7_3 Node0_11_7 Node1_11_7 0.9856000000000001
I_0_11_8 GND Node0_11_8 0.0006510677083333328A
R_0_11_8_1 Node0_11_8 Node0_11_9 15400.0
R_0_11_8_2 Node0_11_8 Node0_12_8 15400.0
R_0_11_8_3 Node0_11_8 Node1_11_8 0.9856000000000001
I_0_11_9 GND Node0_11_9 0.0006510677083333328A
R_0_11_9_1 Node0_11_9 Node0_11_10 15400.0
R_0_11_9_2 Node0_11_9 Node0_12_9 15400.0
R_0_11_9_3 Node0_11_9 Node1_11_9 0.9856000000000001
I_0_11_10 GND Node0_11_10 0.0006510677083333328A
R_0_11_10_1 Node0_11_10 Node0_11_11 15400.0
R_0_11_10_2 Node0_11_10 Node0_12_10 15400.0
R_0_11_10_3 Node0_11_10 Node1_11_10 0.9856000000000001
I_0_11_11 GND Node0_11_11 0.0006510677083333328A
R_0_11_11_1 Node0_11_11 Node0_11_12 15400.0
R_0_11_11_2 Node0_11_11 Node0_12_11 15400.0
R_0_11_11_3 Node0_11_11 Node1_11_11 0.9856000000000001
I_0_11_12 GND Node0_11_12 0.0006510677083333328A
R_0_11_12_1 Node0_11_12 Node0_11_13 15400.0
R_0_11_12_2 Node0_11_12 Node0_12_12 15400.0
R_0_11_12_3 Node0_11_12 Node1_11_12 0.9856000000000001
I_0_11_13 GND Node0_11_13 0.0006510677083333328A
R_0_11_13_1 Node0_11_13 Node0_11_14 15400.0
R_0_11_13_2 Node0_11_13 Node0_12_13 15400.0
R_0_11_13_3 Node0_11_13 Node1_11_13 0.9856000000000001
I_0_11_14 GND Node0_11_14 0.0006510677083333328A
R_0_11_14_1 Node0_11_14 Node0_11_15 15399.999999999993
R_0_11_14_2 Node0_11_14 Node0_12_14 15400.0
R_0_11_14_3 Node0_11_14 Node1_11_14 0.9856000000000001
I_0_11_15 GND Node0_11_15 0.0006510677083333333A
R_0_11_15_2 Node0_11_15 Node0_12_15 15399.999999999987
R_0_11_15_3 Node0_11_15 Node1_11_15 0.9855999999999993
I_0_12_0 GND Node0_12_0 0.0006510677083333328A
R_0_12_0_1 Node0_12_0 Node0_12_1 15400.0
R_0_12_0_2 Node0_12_0 Node0_13_0 15400.0
R_0_12_0_3 Node0_12_0 Node1_12_0 0.9856000000000001
I_0_12_1 GND Node0_12_1 0.0006510677083333328A
R_0_12_1_1 Node0_12_1 Node0_12_2 15400.0
R_0_12_1_2 Node0_12_1 Node0_13_1 15400.0
R_0_12_1_3 Node0_12_1 Node1_12_1 0.9856000000000001
I_0_12_2 GND Node0_12_2 0.0006510677083333328A
R_0_12_2_1 Node0_12_2 Node0_12_3 15400.0
R_0_12_2_2 Node0_12_2 Node0_13_2 15400.0
R_0_12_2_3 Node0_12_2 Node1_12_2 0.9856000000000001
I_0_12_3 GND Node0_12_3 0.0006510677083333328A
R_0_12_3_1 Node0_12_3 Node0_12_4 15400.0
R_0_12_3_2 Node0_12_3 Node0_13_3 15400.0
R_0_12_3_3 Node0_12_3 Node1_12_3 0.9856000000000001
I_0_12_4 GND Node0_12_4 0.0006510677083333328A
R_0_12_4_1 Node0_12_4 Node0_12_5 15400.0
R_0_12_4_2 Node0_12_4 Node0_13_4 15400.0
R_0_12_4_3 Node0_12_4 Node1_12_4 0.9856000000000001
I_0_12_5 GND Node0_12_5 0.0006510677083333328A
R_0_12_5_1 Node0_12_5 Node0_12_6 15400.0
R_0_12_5_2 Node0_12_5 Node0_13_5 15400.0
R_0_12_5_3 Node0_12_5 Node1_12_5 0.9856000000000001
I_0_12_6 GND Node0_12_6 0.0006510677083333328A
R_0_12_6_1 Node0_12_6 Node0_12_7 15400.0
R_0_12_6_2 Node0_12_6 Node0_13_6 15400.0
R_0_12_6_3 Node0_12_6 Node1_12_6 0.9856000000000001
I_0_12_7 GND Node0_12_7 0.0006510677083333328A
R_0_12_7_1 Node0_12_7 Node0_12_8 15400.0
R_0_12_7_2 Node0_12_7 Node0_13_7 15400.0
R_0_12_7_3 Node0_12_7 Node1_12_7 0.9856000000000001
I_0_12_8 GND Node0_12_8 0.0006510677083333328A
R_0_12_8_1 Node0_12_8 Node0_12_9 15400.0
R_0_12_8_2 Node0_12_8 Node0_13_8 15400.0
R_0_12_8_3 Node0_12_8 Node1_12_8 0.9856000000000001
I_0_12_9 GND Node0_12_9 0.0006510677083333328A
R_0_12_9_1 Node0_12_9 Node0_12_10 15400.0
R_0_12_9_2 Node0_12_9 Node0_13_9 15400.0
R_0_12_9_3 Node0_12_9 Node1_12_9 0.9856000000000001
I_0_12_10 GND Node0_12_10 0.0006510677083333328A
R_0_12_10_1 Node0_12_10 Node0_12_11 15400.0
R_0_12_10_2 Node0_12_10 Node0_13_10 15400.0
R_0_12_10_3 Node0_12_10 Node1_12_10 0.9856000000000001
I_0_12_11 GND Node0_12_11 0.0006510677083333328A
R_0_12_11_1 Node0_12_11 Node0_12_12 15400.0
R_0_12_11_2 Node0_12_11 Node0_13_11 15400.0
R_0_12_11_3 Node0_12_11 Node1_12_11 0.9856000000000001
I_0_12_12 GND Node0_12_12 0.0006510677083333328A
R_0_12_12_1 Node0_12_12 Node0_12_13 15400.0
R_0_12_12_2 Node0_12_12 Node0_13_12 15400.0
R_0_12_12_3 Node0_12_12 Node1_12_12 0.9856000000000001
I_0_12_13 GND Node0_12_13 0.0006510677083333328A
R_0_12_13_1 Node0_12_13 Node0_12_14 15400.0
R_0_12_13_2 Node0_12_13 Node0_13_13 15400.0
R_0_12_13_3 Node0_12_13 Node1_12_13 0.9856000000000001
I_0_12_14 GND Node0_12_14 0.0006510677083333328A
R_0_12_14_1 Node0_12_14 Node0_12_15 15399.999999999993
R_0_12_14_2 Node0_12_14 Node0_13_14 15400.0
R_0_12_14_3 Node0_12_14 Node1_12_14 0.9856000000000001
I_0_12_15 GND Node0_12_15 0.0006510677083333333A
R_0_12_15_2 Node0_12_15 Node0_13_15 15399.999999999987
R_0_12_15_3 Node0_12_15 Node1_12_15 0.9855999999999993
I_0_13_0 GND Node0_13_0 0.0006510677083333328A
R_0_13_0_1 Node0_13_0 Node0_13_1 15400.0
R_0_13_0_2 Node0_13_0 Node0_14_0 15400.0
R_0_13_0_3 Node0_13_0 Node1_13_0 0.9856000000000001
I_0_13_1 GND Node0_13_1 0.0006510677083333328A
R_0_13_1_1 Node0_13_1 Node0_13_2 15400.0
R_0_13_1_2 Node0_13_1 Node0_14_1 15400.0
R_0_13_1_3 Node0_13_1 Node1_13_1 0.9856000000000001
I_0_13_2 GND Node0_13_2 0.0006510677083333328A
R_0_13_2_1 Node0_13_2 Node0_13_3 15400.0
R_0_13_2_2 Node0_13_2 Node0_14_2 15400.0
R_0_13_2_3 Node0_13_2 Node1_13_2 0.9856000000000001
I_0_13_3 GND Node0_13_3 0.0006510677083333328A
R_0_13_3_1 Node0_13_3 Node0_13_4 15400.0
R_0_13_3_2 Node0_13_3 Node0_14_3 15400.0
R_0_13_3_3 Node0_13_3 Node1_13_3 0.9856000000000001
I_0_13_4 GND Node0_13_4 0.0006510677083333328A
R_0_13_4_1 Node0_13_4 Node0_13_5 15400.0
R_0_13_4_2 Node0_13_4 Node0_14_4 15400.0
R_0_13_4_3 Node0_13_4 Node1_13_4 0.9856000000000001
I_0_13_5 GND Node0_13_5 0.0006510677083333328A
R_0_13_5_1 Node0_13_5 Node0_13_6 15400.0
R_0_13_5_2 Node0_13_5 Node0_14_5 15400.0
R_0_13_5_3 Node0_13_5 Node1_13_5 0.9856000000000001
I_0_13_6 GND Node0_13_6 0.0006510677083333328A
R_0_13_6_1 Node0_13_6 Node0_13_7 15400.0
R_0_13_6_2 Node0_13_6 Node0_14_6 15400.0
R_0_13_6_3 Node0_13_6 Node1_13_6 0.9856000000000001
I_0_13_7 GND Node0_13_7 0.0006510677083333328A
R_0_13_7_1 Node0_13_7 Node0_13_8 15400.0
R_0_13_7_2 Node0_13_7 Node0_14_7 15400.0
R_0_13_7_3 Node0_13_7 Node1_13_7 0.9856000000000001
I_0_13_8 GND Node0_13_8 0.0006510677083333328A
R_0_13_8_1 Node0_13_8 Node0_13_9 15400.0
R_0_13_8_2 Node0_13_8 Node0_14_8 15400.0
R_0_13_8_3 Node0_13_8 Node1_13_8 0.9856000000000001
I_0_13_9 GND Node0_13_9 0.0006510677083333328A
R_0_13_9_1 Node0_13_9 Node0_13_10 15400.0
R_0_13_9_2 Node0_13_9 Node0_14_9 15400.0
R_0_13_9_3 Node0_13_9 Node1_13_9 0.9856000000000001
I_0_13_10 GND Node0_13_10 0.0006510677083333328A
R_0_13_10_1 Node0_13_10 Node0_13_11 15400.0
R_0_13_10_2 Node0_13_10 Node0_14_10 15400.0
R_0_13_10_3 Node0_13_10 Node1_13_10 0.9856000000000001
I_0_13_11 GND Node0_13_11 0.0006510677083333328A
R_0_13_11_1 Node0_13_11 Node0_13_12 15400.0
R_0_13_11_2 Node0_13_11 Node0_14_11 15400.0
R_0_13_11_3 Node0_13_11 Node1_13_11 0.9856000000000001
I_0_13_12 GND Node0_13_12 0.0006510677083333328A
R_0_13_12_1 Node0_13_12 Node0_13_13 15400.0
R_0_13_12_2 Node0_13_12 Node0_14_12 15400.0
R_0_13_12_3 Node0_13_12 Node1_13_12 0.9856000000000001
I_0_13_13 GND Node0_13_13 0.0006510677083333328A
R_0_13_13_1 Node0_13_13 Node0_13_14 15400.0
R_0_13_13_2 Node0_13_13 Node0_14_13 15400.0
R_0_13_13_3 Node0_13_13 Node1_13_13 0.9856000000000001
I_0_13_14 GND Node0_13_14 0.0006510677083333328A
R_0_13_14_1 Node0_13_14 Node0_13_15 15399.999999999993
R_0_13_14_2 Node0_13_14 Node0_14_14 15400.0
R_0_13_14_3 Node0_13_14 Node1_13_14 0.9856000000000001
I_0_13_15 GND Node0_13_15 0.0006510677083333333A
R_0_13_15_2 Node0_13_15 Node0_14_15 15399.999999999987
R_0_13_15_3 Node0_13_15 Node1_13_15 0.9855999999999993
I_0_14_0 GND Node0_14_0 0.0006510677083333328A
R_0_14_0_1 Node0_14_0 Node0_14_1 15400.0
R_0_14_0_2 Node0_14_0 Node0_15_0 15400.0
R_0_14_0_3 Node0_14_0 Node1_14_0 0.9856000000000001
I_0_14_1 GND Node0_14_1 0.0006510677083333328A
R_0_14_1_1 Node0_14_1 Node0_14_2 15400.0
R_0_14_1_2 Node0_14_1 Node0_15_1 15400.0
R_0_14_1_3 Node0_14_1 Node1_14_1 0.9856000000000001
I_0_14_2 GND Node0_14_2 0.0006510677083333328A
R_0_14_2_1 Node0_14_2 Node0_14_3 15400.0
R_0_14_2_2 Node0_14_2 Node0_15_2 15400.0
R_0_14_2_3 Node0_14_2 Node1_14_2 0.9856000000000001
I_0_14_3 GND Node0_14_3 0.0006510677083333328A
R_0_14_3_1 Node0_14_3 Node0_14_4 15400.0
R_0_14_3_2 Node0_14_3 Node0_15_3 15400.0
R_0_14_3_3 Node0_14_3 Node1_14_3 0.9856000000000001
I_0_14_4 GND Node0_14_4 0.0006510677083333328A
R_0_14_4_1 Node0_14_4 Node0_14_5 15400.0
R_0_14_4_2 Node0_14_4 Node0_15_4 15400.0
R_0_14_4_3 Node0_14_4 Node1_14_4 0.9856000000000001
I_0_14_5 GND Node0_14_5 0.0006510677083333328A
R_0_14_5_1 Node0_14_5 Node0_14_6 15400.0
R_0_14_5_2 Node0_14_5 Node0_15_5 15400.0
R_0_14_5_3 Node0_14_5 Node1_14_5 0.9856000000000001
I_0_14_6 GND Node0_14_6 0.0006510677083333328A
R_0_14_6_1 Node0_14_6 Node0_14_7 15400.0
R_0_14_6_2 Node0_14_6 Node0_15_6 15400.0
R_0_14_6_3 Node0_14_6 Node1_14_6 0.9856000000000001
I_0_14_7 GND Node0_14_7 0.0006510677083333328A
R_0_14_7_1 Node0_14_7 Node0_14_8 15400.0
R_0_14_7_2 Node0_14_7 Node0_15_7 15400.0
R_0_14_7_3 Node0_14_7 Node1_14_7 0.9856000000000001
I_0_14_8 GND Node0_14_8 0.0006510677083333328A
R_0_14_8_1 Node0_14_8 Node0_14_9 15400.0
R_0_14_8_2 Node0_14_8 Node0_15_8 15400.0
R_0_14_8_3 Node0_14_8 Node1_14_8 0.9856000000000001
I_0_14_9 GND Node0_14_9 0.0006510677083333328A
R_0_14_9_1 Node0_14_9 Node0_14_10 15400.0
R_0_14_9_2 Node0_14_9 Node0_15_9 15400.0
R_0_14_9_3 Node0_14_9 Node1_14_9 0.9856000000000001
I_0_14_10 GND Node0_14_10 0.0006510677083333328A
R_0_14_10_1 Node0_14_10 Node0_14_11 15400.0
R_0_14_10_2 Node0_14_10 Node0_15_10 15400.0
R_0_14_10_3 Node0_14_10 Node1_14_10 0.9856000000000001
I_0_14_11 GND Node0_14_11 0.0006510677083333328A
R_0_14_11_1 Node0_14_11 Node0_14_12 15400.0
R_0_14_11_2 Node0_14_11 Node0_15_11 15400.0
R_0_14_11_3 Node0_14_11 Node1_14_11 0.9856000000000001
I_0_14_12 GND Node0_14_12 0.0006510677083333328A
R_0_14_12_1 Node0_14_12 Node0_14_13 15400.0
R_0_14_12_2 Node0_14_12 Node0_15_12 15400.0
R_0_14_12_3 Node0_14_12 Node1_14_12 0.9856000000000001
I_0_14_13 GND Node0_14_13 0.0006510677083333328A
R_0_14_13_1 Node0_14_13 Node0_14_14 15400.0
R_0_14_13_2 Node0_14_13 Node0_15_13 15400.0
R_0_14_13_3 Node0_14_13 Node1_14_13 0.9856000000000001
I_0_14_14 GND Node0_14_14 0.0006510677083333328A
R_0_14_14_1 Node0_14_14 Node0_14_15 15399.999999999993
R_0_14_14_2 Node0_14_14 Node0_15_14 15400.0
R_0_14_14_3 Node0_14_14 Node1_14_14 0.9856000000000001
I_0_14_15 GND Node0_14_15 0.0006510677083333333A
R_0_14_15_2 Node0_14_15 Node0_15_15 15399.999999999985
R_0_14_15_3 Node0_14_15 Node1_14_15 0.9855999999999993
I_0_15_0 GND Node0_15_0 0.0006510677083333328A
R_0_15_0_1 Node0_15_0 Node0_15_1 15400.0
R_0_15_0_3 Node0_15_0 Node1_15_0 0.9856000000000001
I_0_15_1 GND Node0_15_1 0.0006510677083333328A
R_0_15_1_1 Node0_15_1 Node0_15_2 15400.0
R_0_15_1_3 Node0_15_1 Node1_15_1 0.9856000000000001
I_0_15_2 GND Node0_15_2 0.0006510677083333328A
R_0_15_2_1 Node0_15_2 Node0_15_3 15400.0
R_0_15_2_3 Node0_15_2 Node1_15_2 0.9856000000000001
I_0_15_3 GND Node0_15_3 0.0006510677083333328A
R_0_15_3_1 Node0_15_3 Node0_15_4 15400.0
R_0_15_3_3 Node0_15_3 Node1_15_3 0.9856000000000001
I_0_15_4 GND Node0_15_4 0.0006510677083333328A
R_0_15_4_1 Node0_15_4 Node0_15_5 15400.0
R_0_15_4_3 Node0_15_4 Node1_15_4 0.9856000000000001
I_0_15_5 GND Node0_15_5 0.0006510677083333328A
R_0_15_5_1 Node0_15_5 Node0_15_6 15400.0
R_0_15_5_3 Node0_15_5 Node1_15_5 0.9856000000000001
I_0_15_6 GND Node0_15_6 0.0006510677083333328A
R_0_15_6_1 Node0_15_6 Node0_15_7 15400.0
R_0_15_6_3 Node0_15_6 Node1_15_6 0.9856000000000001
I_0_15_7 GND Node0_15_7 0.0006510677083333328A
R_0_15_7_1 Node0_15_7 Node0_15_8 15400.0
R_0_15_7_3 Node0_15_7 Node1_15_7 0.9856000000000001
I_0_15_8 GND Node0_15_8 0.0006510677083333328A
R_0_15_8_1 Node0_15_8 Node0_15_9 15400.0
R_0_15_8_3 Node0_15_8 Node1_15_8 0.9856000000000001
I_0_15_9 GND Node0_15_9 0.0006510677083333328A
R_0_15_9_1 Node0_15_9 Node0_15_10 15400.0
R_0_15_9_3 Node0_15_9 Node1_15_9 0.9856000000000001
I_0_15_10 GND Node0_15_10 0.0006510677083333328A
R_0_15_10_1 Node0_15_10 Node0_15_11 15400.0
R_0_15_10_3 Node0_15_10 Node1_15_10 0.9856000000000001
I_0_15_11 GND Node0_15_11 0.0006510677083333328A
R_0_15_11_1 Node0_15_11 Node0_15_12 15400.0
R_0_15_11_3 Node0_15_11 Node1_15_11 0.9856000000000001
I_0_15_12 GND Node0_15_12 0.0006510677083333328A
R_0_15_12_1 Node0_15_12 Node0_15_13 15400.0
R_0_15_12_3 Node0_15_12 Node1_15_12 0.9856000000000001
I_0_15_13 GND Node0_15_13 0.0006510677083333328A
R_0_15_13_1 Node0_15_13 Node0_15_14 15400.0
R_0_15_13_3 Node0_15_13 Node1_15_13 0.9856000000000001
I_0_15_14 GND Node0_15_14 0.0006510677083333328A
R_0_15_14_1 Node0_15_14 Node0_15_15 15399.999999999993
R_0_15_14_3 Node0_15_14 Node1_15_14 0.9856000000000001
I_0_15_15 GND Node0_15_15 0.0006510677083333336A
R_0_15_15_3 Node0_15_15 Node1_15_15 0.985599999999999
R_1_0_0_1 Node1_0_0 Node1_0_1 2499999.9999999995
R_1_0_0_2 Node1_0_0 Node1_1_0 2499999.9999999995
R_1_0_0_3 Node1_0_0 GND 2560.0
R_1_0_1_1 Node1_0_1 Node1_0_2 2499999.9999999995
R_1_0_1_2 Node1_0_1 Node1_1_1 2499999.9999999995
R_1_0_1_3 Node1_0_1 GND 2560.0
R_1_0_2_1 Node1_0_2 Node1_0_3 2499999.9999999995
R_1_0_2_2 Node1_0_2 Node1_1_2 2499999.9999999995
R_1_0_2_3 Node1_0_2 GND 2560.0
R_1_0_3_1 Node1_0_3 Node1_0_4 2499999.9999999995
R_1_0_3_2 Node1_0_3 Node1_1_3 2499999.9999999995
R_1_0_3_3 Node1_0_3 GND 2560.0
R_1_0_4_1 Node1_0_4 Node1_0_5 2499999.9999999995
R_1_0_4_2 Node1_0_4 Node1_1_4 2499999.9999999995
R_1_0_4_3 Node1_0_4 GND 2560.0
R_1_0_5_1 Node1_0_5 Node1_0_6 2499999.9999999995
R_1_0_5_2 Node1_0_5 Node1_1_5 2499999.9999999995
R_1_0_5_3 Node1_0_5 GND 2560.0
R_1_0_6_1 Node1_0_6 Node1_0_7 2499999.9999999995
R_1_0_6_2 Node1_0_6 Node1_1_6 2499999.9999999995
R_1_0_6_3 Node1_0_6 GND 2560.0
R_1_0_7_1 Node1_0_7 Node1_0_8 2499999.9999999995
R_1_0_7_2 Node1_0_7 Node1_1_7 2499999.9999999995
R_1_0_7_3 Node1_0_7 GND 2560.0
R_1_0_8_1 Node1_0_8 Node1_0_9 2499999.9999999995
R_1_0_8_2 Node1_0_8 Node1_1_8 2499999.9999999995
R_1_0_8_3 Node1_0_8 GND 2560.0
R_1_0_9_1 Node1_0_9 Node1_0_10 2499999.9999999995
R_1_0_9_2 Node1_0_9 Node1_1_9 2499999.9999999995
R_1_0_9_3 Node1_0_9 GND 2560.0
R_1_0_10_1 Node1_0_10 Node1_0_11 2499999.9999999995
R_1_0_10_2 Node1_0_10 Node1_1_10 2499999.9999999995
R_1_0_10_3 Node1_0_10 GND 2560.0
R_1_0_11_1 Node1_0_11 Node1_0_12 2499999.9999999995
R_1_0_11_2 Node1_0_11 Node1_1_11 2499999.9999999995
R_1_0_11_3 Node1_0_11 GND 2560.0
R_1_0_12_1 Node1_0_12 Node1_0_13 2499999.9999999995
R_1_0_12_2 Node1_0_12 Node1_1_12 2499999.9999999995
R_1_0_12_3 Node1_0_12 GND 2560.0
R_1_0_13_1 Node1_0_13 Node1_0_14 2499999.9999999995
R_1_0_13_2 Node1_0_13 Node1_1_13 2499999.9999999995
R_1_0_13_3 Node1_0_13 GND 2560.0
R_1_0_14_1 Node1_0_14 Node1_0_15 2499999.9999999995
R_1_0_14_2 Node1_0_14 Node1_1_14 2499999.9999999995
R_1_0_14_3 Node1_0_14 GND 2560.0
R_1_0_15_2 Node1_0_15 Node1_1_15 2499999.9999999995
R_1_0_15_3 Node1_0_15 GND 2560.0
R_1_1_0_1 Node1_1_0 Node1_1_1 2499999.9999999995
R_1_1_0_2 Node1_1_0 Node1_2_0 2499999.9999999995
R_1_1_0_3 Node1_1_0 GND 2560.0
R_1_1_1_1 Node1_1_1 Node1_1_2 2499999.9999999995
R_1_1_1_2 Node1_1_1 Node1_2_1 2499999.9999999995
R_1_1_1_3 Node1_1_1 GND 2560.0
R_1_1_2_1 Node1_1_2 Node1_1_3 2499999.9999999995
R_1_1_2_2 Node1_1_2 Node1_2_2 2499999.9999999995
R_1_1_2_3 Node1_1_2 GND 2560.0
R_1_1_3_1 Node1_1_3 Node1_1_4 2499999.9999999995
R_1_1_3_2 Node1_1_3 Node1_2_3 2499999.9999999995
R_1_1_3_3 Node1_1_3 GND 2560.0
R_1_1_4_1 Node1_1_4 Node1_1_5 2499999.9999999995
R_1_1_4_2 Node1_1_4 Node1_2_4 2499999.9999999995
R_1_1_4_3 Node1_1_4 GND 2560.0
R_1_1_5_1 Node1_1_5 Node1_1_6 2499999.9999999995
R_1_1_5_2 Node1_1_5 Node1_2_5 2499999.9999999995
R_1_1_5_3 Node1_1_5 GND 2560.0
R_1_1_6_1 Node1_1_6 Node1_1_7 2499999.9999999995
R_1_1_6_2 Node1_1_6 Node1_2_6 2499999.9999999995
R_1_1_6_3 Node1_1_6 GND 2560.0
R_1_1_7_1 Node1_1_7 Node1_1_8 2499999.9999999995
R_1_1_7_2 Node1_1_7 Node1_2_7 2499999.9999999995
R_1_1_7_3 Node1_1_7 GND 2560.0
R_1_1_8_1 Node1_1_8 Node1_1_9 2499999.9999999995
R_1_1_8_2 Node1_1_8 Node1_2_8 2499999.9999999995
R_1_1_8_3 Node1_1_8 GND 2560.0
R_1_1_9_1 Node1_1_9 Node1_1_10 2499999.9999999995
R_1_1_9_2 Node1_1_9 Node1_2_9 2499999.9999999995
R_1_1_9_3 Node1_1_9 GND 2560.0
R_1_1_10_1 Node1_1_10 Node1_1_11 2499999.9999999995
R_1_1_10_2 Node1_1_10 Node1_2_10 2499999.9999999995
R_1_1_10_3 Node1_1_10 GND 2560.0
R_1_1_11_1 Node1_1_11 Node1_1_12 2499999.9999999995
R_1_1_11_2 Node1_1_11 Node1_2_11 2499999.9999999995
R_1_1_11_3 Node1_1_11 GND 2560.0
R_1_1_12_1 Node1_1_12 Node1_1_13 2499999.9999999995
R_1_1_12_2 Node1_1_12 Node1_2_12 2499999.9999999995
R_1_1_12_3 Node1_1_12 GND 2560.0
R_1_1_13_1 Node1_1_13 Node1_1_14 2499999.9999999995
R_1_1_13_2 Node1_1_13 Node1_2_13 2499999.9999999995
R_1_1_13_3 Node1_1_13 GND 2560.0
R_1_1_14_1 Node1_1_14 Node1_1_15 2499999.9999999995
R_1_1_14_2 Node1_1_14 Node1_2_14 2499999.9999999995
R_1_1_14_3 Node1_1_14 GND 2560.0
R_1_1_15_2 Node1_1_15 Node1_2_15 2499999.9999999995
R_1_1_15_3 Node1_1_15 GND 2560.0
R_1_2_0_1 Node1_2_0 Node1_2_1 2499999.9999999995
R_1_2_0_2 Node1_2_0 Node1_3_0 2499999.9999999995
R_1_2_0_3 Node1_2_0 GND 2560.0
R_1_2_1_1 Node1_2_1 Node1_2_2 2499999.9999999995
R_1_2_1_2 Node1_2_1 Node1_3_1 2499999.9999999995
R_1_2_1_3 Node1_2_1 GND 2560.0
R_1_2_2_1 Node1_2_2 Node1_2_3 2499999.9999999995
R_1_2_2_2 Node1_2_2 Node1_3_2 2499999.9999999995
R_1_2_2_3 Node1_2_2 GND 2560.0
R_1_2_3_1 Node1_2_3 Node1_2_4 2499999.9999999995
R_1_2_3_2 Node1_2_3 Node1_3_3 2499999.9999999995
R_1_2_3_3 Node1_2_3 GND 2560.0
R_1_2_4_1 Node1_2_4 Node1_2_5 2499999.9999999995
R_1_2_4_2 Node1_2_4 Node1_3_4 2499999.9999999995
R_1_2_4_3 Node1_2_4 GND 2560.0
R_1_2_5_1 Node1_2_5 Node1_2_6 2499999.9999999995
R_1_2_5_2 Node1_2_5 Node1_3_5 2499999.9999999995
R_1_2_5_3 Node1_2_5 GND 2560.0
R_1_2_6_1 Node1_2_6 Node1_2_7 2499999.9999999995
R_1_2_6_2 Node1_2_6 Node1_3_6 2499999.9999999995
R_1_2_6_3 Node1_2_6 GND 2560.0
R_1_2_7_1 Node1_2_7 Node1_2_8 2499999.9999999995
R_1_2_7_2 Node1_2_7 Node1_3_7 2499999.9999999995
R_1_2_7_3 Node1_2_7 GND 2560.0
R_1_2_8_1 Node1_2_8 Node1_2_9 2499999.9999999995
R_1_2_8_2 Node1_2_8 Node1_3_8 2499999.9999999995
R_1_2_8_3 Node1_2_8 GND 2560.0
R_1_2_9_1 Node1_2_9 Node1_2_10 2499999.9999999995
R_1_2_9_2 Node1_2_9 Node1_3_9 2499999.9999999995
R_1_2_9_3 Node1_2_9 GND 2560.0
R_1_2_10_1 Node1_2_10 Node1_2_11 2499999.9999999995
R_1_2_10_2 Node1_2_10 Node1_3_10 2499999.9999999995
R_1_2_10_3 Node1_2_10 GND 2560.0
R_1_2_11_1 Node1_2_11 Node1_2_12 2499999.9999999995
R_1_2_11_2 Node1_2_11 Node1_3_11 2499999.9999999995
R_1_2_11_3 Node1_2_11 GND 2560.0
R_1_2_12_1 Node1_2_12 Node1_2_13 2499999.9999999995
R_1_2_12_2 Node1_2_12 Node1_3_12 2499999.9999999995
R_1_2_12_3 Node1_2_12 GND 2560.0
R_1_2_13_1 Node1_2_13 Node1_2_14 2499999.9999999995
R_1_2_13_2 Node1_2_13 Node1_3_13 2499999.9999999995
R_1_2_13_3 Node1_2_13 GND 2560.0
R_1_2_14_1 Node1_2_14 Node1_2_15 2499999.9999999995
R_1_2_14_2 Node1_2_14 Node1_3_14 2499999.9999999995
R_1_2_14_3 Node1_2_14 GND 2560.0
R_1_2_15_2 Node1_2_15 Node1_3_15 2499999.9999999995
R_1_2_15_3 Node1_2_15 GND 2560.0
R_1_3_0_1 Node1_3_0 Node1_3_1 2499999.9999999995
R_1_3_0_2 Node1_3_0 Node1_4_0 2499999.9999999995
R_1_3_0_3 Node1_3_0 GND 2560.0
R_1_3_1_1 Node1_3_1 Node1_3_2 2499999.9999999995
R_1_3_1_2 Node1_3_1 Node1_4_1 2499999.9999999995
R_1_3_1_3 Node1_3_1 GND 2560.0
R_1_3_2_1 Node1_3_2 Node1_3_3 2499999.9999999995
R_1_3_2_2 Node1_3_2 Node1_4_2 2499999.9999999995
R_1_3_2_3 Node1_3_2 GND 2560.0
R_1_3_3_1 Node1_3_3 Node1_3_4 2499999.9999999995
R_1_3_3_2 Node1_3_3 Node1_4_3 2499999.9999999995
R_1_3_3_3 Node1_3_3 GND 2560.0
R_1_3_4_1 Node1_3_4 Node1_3_5 2499999.9999999995
R_1_3_4_2 Node1_3_4 Node1_4_4 2499999.9999999995
R_1_3_4_3 Node1_3_4 GND 2560.0
R_1_3_5_1 Node1_3_5 Node1_3_6 2499999.9999999995
R_1_3_5_2 Node1_3_5 Node1_4_5 2499999.9999999995
R_1_3_5_3 Node1_3_5 GND 2560.0
R_1_3_6_1 Node1_3_6 Node1_3_7 2499999.9999999995
R_1_3_6_2 Node1_3_6 Node1_4_6 2499999.9999999995
R_1_3_6_3 Node1_3_6 GND 2560.0
R_1_3_7_1 Node1_3_7 Node1_3_8 2499999.9999999995
R_1_3_7_2 Node1_3_7 Node1_4_7 2499999.9999999995
R_1_3_7_3 Node1_3_7 GND 2560.0
R_1_3_8_1 Node1_3_8 Node1_3_9 2499999.9999999995
R_1_3_8_2 Node1_3_8 Node1_4_8 2499999.9999999995
R_1_3_8_3 Node1_3_8 GND 2560.0
R_1_3_9_1 Node1_3_9 Node1_3_10 2499999.9999999995
R_1_3_9_2 Node1_3_9 Node1_4_9 2499999.9999999995
R_1_3_9_3 Node1_3_9 GND 2560.0
R_1_3_10_1 Node1_3_10 Node1_3_11 2499999.9999999995
R_1_3_10_2 Node1_3_10 Node1_4_10 2499999.9999999995
R_1_3_10_3 Node1_3_10 GND 2560.0
R_1_3_11_1 Node1_3_11 Node1_3_12 2499999.9999999995
R_1_3_11_2 Node1_3_11 Node1_4_11 2499999.9999999995
R_1_3_11_3 Node1_3_11 GND 2560.0
R_1_3_12_1 Node1_3_12 Node1_3_13 2499999.9999999995
R_1_3_12_2 Node1_3_12 Node1_4_12 2499999.9999999995
R_1_3_12_3 Node1_3_12 GND 2560.0
R_1_3_13_1 Node1_3_13 Node1_3_14 2499999.9999999995
R_1_3_13_2 Node1_3_13 Node1_4_13 2499999.9999999995
R_1_3_13_3 Node1_3_13 GND 2560.0
R_1_3_14_1 Node1_3_14 Node1_3_15 2499999.9999999995
R_1_3_14_2 Node1_3_14 Node1_4_14 2499999.9999999995
R_1_3_14_3 Node1_3_14 GND 2560.0
R_1_3_15_2 Node1_3_15 Node1_4_15 2499999.9999999995
R_1_3_15_3 Node1_3_15 GND 2560.0
R_1_4_0_1 Node1_4_0 Node1_4_1 2499999.9999999995
R_1_4_0_2 Node1_4_0 Node1_5_0 2499999.9999999995
R_1_4_0_3 Node1_4_0 GND 2560.0
R_1_4_1_1 Node1_4_1 Node1_4_2 2499999.9999999995
R_1_4_1_2 Node1_4_1 Node1_5_1 2499999.9999999995
R_1_4_1_3 Node1_4_1 GND 2560.0
R_1_4_2_1 Node1_4_2 Node1_4_3 2499999.9999999995
R_1_4_2_2 Node1_4_2 Node1_5_2 2499999.9999999995
R_1_4_2_3 Node1_4_2 GND 2560.0
R_1_4_3_1 Node1_4_3 Node1_4_4 2499999.9999999995
R_1_4_3_2 Node1_4_3 Node1_5_3 2499999.9999999995
R_1_4_3_3 Node1_4_3 GND 2560.0
R_1_4_4_1 Node1_4_4 Node1_4_5 2499999.9999999995
R_1_4_4_2 Node1_4_4 Node1_5_4 2499999.9999999995
R_1_4_4_3 Node1_4_4 GND 2560.0
R_1_4_5_1 Node1_4_5 Node1_4_6 2499999.9999999995
R_1_4_5_2 Node1_4_5 Node1_5_5 2499999.9999999995
R_1_4_5_3 Node1_4_5 GND 2560.0
R_1_4_6_1 Node1_4_6 Node1_4_7 2499999.9999999995
R_1_4_6_2 Node1_4_6 Node1_5_6 2499999.9999999995
R_1_4_6_3 Node1_4_6 GND 2560.0
R_1_4_7_1 Node1_4_7 Node1_4_8 2499999.9999999995
R_1_4_7_2 Node1_4_7 Node1_5_7 2499999.9999999995
R_1_4_7_3 Node1_4_7 GND 2560.0
R_1_4_8_1 Node1_4_8 Node1_4_9 2499999.9999999995
R_1_4_8_2 Node1_4_8 Node1_5_8 2499999.9999999995
R_1_4_8_3 Node1_4_8 GND 2560.0
R_1_4_9_1 Node1_4_9 Node1_4_10 2499999.9999999995
R_1_4_9_2 Node1_4_9 Node1_5_9 2499999.9999999995
R_1_4_9_3 Node1_4_9 GND 2560.0
R_1_4_10_1 Node1_4_10 Node1_4_11 2499999.9999999995
R_1_4_10_2 Node1_4_10 Node1_5_10 2499999.9999999995
R_1_4_10_3 Node1_4_10 GND 2560.0
R_1_4_11_1 Node1_4_11 Node1_4_12 2499999.9999999995
R_1_4_11_2 Node1_4_11 Node1_5_11 2499999.9999999995
R_1_4_11_3 Node1_4_11 GND 2560.0
R_1_4_12_1 Node1_4_12 Node1_4_13 2499999.9999999995
R_1_4_12_2 Node1_4_12 Node1_5_12 2499999.9999999995
R_1_4_12_3 Node1_4_12 GND 2560.0
R_1_4_13_1 Node1_4_13 Node1_4_14 2499999.9999999995
R_1_4_13_2 Node1_4_13 Node1_5_13 2499999.9999999995
R_1_4_13_3 Node1_4_13 GND 2560.0
R_1_4_14_1 Node1_4_14 Node1_4_15 2499999.9999999995
R_1_4_14_2 Node1_4_14 Node1_5_14 2499999.9999999995
R_1_4_14_3 Node1_4_14 GND 2560.0
R_1_4_15_2 Node1_4_15 Node1_5_15 2499999.9999999995
R_1_4_15_3 Node1_4_15 GND 2560.0
R_1_5_0_1 Node1_5_0 Node1_5_1 2499999.9999999995
R_1_5_0_2 Node1_5_0 Node1_6_0 2499999.9999999995
R_1_5_0_3 Node1_5_0 GND 2560.0
R_1_5_1_1 Node1_5_1 Node1_5_2 2499999.9999999995
R_1_5_1_2 Node1_5_1 Node1_6_1 2499999.9999999995
R_1_5_1_3 Node1_5_1 GND 2560.0
R_1_5_2_1 Node1_5_2 Node1_5_3 2499999.9999999995
R_1_5_2_2 Node1_5_2 Node1_6_2 2499999.9999999995
R_1_5_2_3 Node1_5_2 GND 2560.0
R_1_5_3_1 Node1_5_3 Node1_5_4 2499999.9999999995
R_1_5_3_2 Node1_5_3 Node1_6_3 2499999.9999999995
R_1_5_3_3 Node1_5_3 GND 2560.0
R_1_5_4_1 Node1_5_4 Node1_5_5 2499999.9999999995
R_1_5_4_2 Node1_5_4 Node1_6_4 2499999.9999999995
R_1_5_4_3 Node1_5_4 GND 2560.0
R_1_5_5_1 Node1_5_5 Node1_5_6 2499999.9999999995
R_1_5_5_2 Node1_5_5 Node1_6_5 2499999.9999999995
R_1_5_5_3 Node1_5_5 GND 2560.0
R_1_5_6_1 Node1_5_6 Node1_5_7 2499999.9999999995
R_1_5_6_2 Node1_5_6 Node1_6_6 2499999.9999999995
R_1_5_6_3 Node1_5_6 GND 2560.0
R_1_5_7_1 Node1_5_7 Node1_5_8 2499999.9999999995
R_1_5_7_2 Node1_5_7 Node1_6_7 2499999.9999999995
R_1_5_7_3 Node1_5_7 GND 2560.0
R_1_5_8_1 Node1_5_8 Node1_5_9 2499999.9999999995
R_1_5_8_2 Node1_5_8 Node1_6_8 2499999.9999999995
R_1_5_8_3 Node1_5_8 GND 2560.0
R_1_5_9_1 Node1_5_9 Node1_5_10 2499999.9999999995
R_1_5_9_2 Node1_5_9 Node1_6_9 2499999.9999999995
R_1_5_9_3 Node1_5_9 GND 2560.0
R_1_5_10_1 Node1_5_10 Node1_5_11 2499999.9999999995
R_1_5_10_2 Node1_5_10 Node1_6_10 2499999.9999999995
R_1_5_10_3 Node1_5_10 GND 2560.0
R_1_5_11_1 Node1_5_11 Node1_5_12 2499999.9999999995
R_1_5_11_2 Node1_5_11 Node1_6_11 2499999.9999999995
R_1_5_11_3 Node1_5_11 GND 2560.0
R_1_5_12_1 Node1_5_12 Node1_5_13 2499999.9999999995
R_1_5_12_2 Node1_5_12 Node1_6_12 2499999.9999999995
R_1_5_12_3 Node1_5_12 GND 2560.0
R_1_5_13_1 Node1_5_13 Node1_5_14 2499999.9999999995
R_1_5_13_2 Node1_5_13 Node1_6_13 2499999.9999999995
R_1_5_13_3 Node1_5_13 GND 2560.0
R_1_5_14_1 Node1_5_14 Node1_5_15 2499999.9999999995
R_1_5_14_2 Node1_5_14 Node1_6_14 2499999.9999999995
R_1_5_14_3 Node1_5_14 GND 2560.0
R_1_5_15_2 Node1_5_15 Node1_6_15 2499999.9999999995
R_1_5_15_3 Node1_5_15 GND 2560.0
R_1_6_0_1 Node1_6_0 Node1_6_1 2499999.9999999995
R_1_6_0_2 Node1_6_0 Node1_7_0 2499999.9999999995
R_1_6_0_3 Node1_6_0 GND 2560.0
R_1_6_1_1 Node1_6_1 Node1_6_2 2499999.9999999995
R_1_6_1_2 Node1_6_1 Node1_7_1 2499999.9999999995
R_1_6_1_3 Node1_6_1 GND 2560.0
R_1_6_2_1 Node1_6_2 Node1_6_3 2499999.9999999995
R_1_6_2_2 Node1_6_2 Node1_7_2 2499999.9999999995
R_1_6_2_3 Node1_6_2 GND 2560.0
R_1_6_3_1 Node1_6_3 Node1_6_4 2499999.9999999995
R_1_6_3_2 Node1_6_3 Node1_7_3 2499999.9999999995
R_1_6_3_3 Node1_6_3 GND 2560.0
R_1_6_4_1 Node1_6_4 Node1_6_5 2499999.9999999995
R_1_6_4_2 Node1_6_4 Node1_7_4 2499999.9999999995
R_1_6_4_3 Node1_6_4 GND 2560.0
R_1_6_5_1 Node1_6_5 Node1_6_6 2499999.9999999995
R_1_6_5_2 Node1_6_5 Node1_7_5 2499999.9999999995
R_1_6_5_3 Node1_6_5 GND 2560.0
R_1_6_6_1 Node1_6_6 Node1_6_7 2499999.9999999995
R_1_6_6_2 Node1_6_6 Node1_7_6 2499999.9999999995
R_1_6_6_3 Node1_6_6 GND 2560.0
R_1_6_7_1 Node1_6_7 Node1_6_8 2499999.9999999995
R_1_6_7_2 Node1_6_7 Node1_7_7 2499999.9999999995
R_1_6_7_3 Node1_6_7 GND 2560.0
R_1_6_8_1 Node1_6_8 Node1_6_9 2499999.9999999995
R_1_6_8_2 Node1_6_8 Node1_7_8 2499999.9999999995
R_1_6_8_3 Node1_6_8 GND 2560.0
R_1_6_9_1 Node1_6_9 Node1_6_10 2499999.9999999995
R_1_6_9_2 Node1_6_9 Node1_7_9 2499999.9999999995
R_1_6_9_3 Node1_6_9 GND 2560.0
R_1_6_10_1 Node1_6_10 Node1_6_11 2499999.9999999995
R_1_6_10_2 Node1_6_10 Node1_7_10 2499999.9999999995
R_1_6_10_3 Node1_6_10 GND 2560.0
R_1_6_11_1 Node1_6_11 Node1_6_12 2499999.9999999995
R_1_6_11_2 Node1_6_11 Node1_7_11 2499999.9999999995
R_1_6_11_3 Node1_6_11 GND 2560.0
R_1_6_12_1 Node1_6_12 Node1_6_13 2499999.9999999995
R_1_6_12_2 Node1_6_12 Node1_7_12 2499999.9999999995
R_1_6_12_3 Node1_6_12 GND 2560.0
R_1_6_13_1 Node1_6_13 Node1_6_14 2499999.9999999995
R_1_6_13_2 Node1_6_13 Node1_7_13 2499999.9999999995
R_1_6_13_3 Node1_6_13 GND 2560.0
R_1_6_14_1 Node1_6_14 Node1_6_15 2499999.9999999995
R_1_6_14_2 Node1_6_14 Node1_7_14 2499999.9999999995
R_1_6_14_3 Node1_6_14 GND 2560.0
R_1_6_15_2 Node1_6_15 Node1_7_15 2499999.9999999995
R_1_6_15_3 Node1_6_15 GND 2560.0
R_1_7_0_1 Node1_7_0 Node1_7_1 2499999.9999999995
R_1_7_0_2 Node1_7_0 Node1_8_0 2499999.9999999995
R_1_7_0_3 Node1_7_0 GND 2560.0
R_1_7_1_1 Node1_7_1 Node1_7_2 2499999.9999999995
R_1_7_1_2 Node1_7_1 Node1_8_1 2499999.9999999995
R_1_7_1_3 Node1_7_1 GND 2560.0
R_1_7_2_1 Node1_7_2 Node1_7_3 2499999.9999999995
R_1_7_2_2 Node1_7_2 Node1_8_2 2499999.9999999995
R_1_7_2_3 Node1_7_2 GND 2560.0
R_1_7_3_1 Node1_7_3 Node1_7_4 2499999.9999999995
R_1_7_3_2 Node1_7_3 Node1_8_3 2499999.9999999995
R_1_7_3_3 Node1_7_3 GND 2560.0
R_1_7_4_1 Node1_7_4 Node1_7_5 2499999.9999999995
R_1_7_4_2 Node1_7_4 Node1_8_4 2499999.9999999995
R_1_7_4_3 Node1_7_4 GND 2560.0
R_1_7_5_1 Node1_7_5 Node1_7_6 2499999.9999999995
R_1_7_5_2 Node1_7_5 Node1_8_5 2499999.9999999995
R_1_7_5_3 Node1_7_5 GND 2560.0
R_1_7_6_1 Node1_7_6 Node1_7_7 2499999.9999999995
R_1_7_6_2 Node1_7_6 Node1_8_6 2499999.9999999995
R_1_7_6_3 Node1_7_6 GND 2560.0
R_1_7_7_1 Node1_7_7 Node1_7_8 2499999.9999999995
R_1_7_7_2 Node1_7_7 Node1_8_7 2499999.9999999995
R_1_7_7_3 Node1_7_7 GND 2560.0
R_1_7_8_1 Node1_7_8 Node1_7_9 2499999.9999999995
R_1_7_8_2 Node1_7_8 Node1_8_8 2499999.9999999995
R_1_7_8_3 Node1_7_8 GND 2560.0
R_1_7_9_1 Node1_7_9 Node1_7_10 2499999.9999999995
R_1_7_9_2 Node1_7_9 Node1_8_9 2499999.9999999995
R_1_7_9_3 Node1_7_9 GND 2560.0
R_1_7_10_1 Node1_7_10 Node1_7_11 2499999.9999999995
R_1_7_10_2 Node1_7_10 Node1_8_10 2499999.9999999995
R_1_7_10_3 Node1_7_10 GND 2560.0
R_1_7_11_1 Node1_7_11 Node1_7_12 2499999.9999999995
R_1_7_11_2 Node1_7_11 Node1_8_11 2499999.9999999995
R_1_7_11_3 Node1_7_11 GND 2560.0
R_1_7_12_1 Node1_7_12 Node1_7_13 2499999.9999999995
R_1_7_12_2 Node1_7_12 Node1_8_12 2499999.9999999995
R_1_7_12_3 Node1_7_12 GND 2560.0
R_1_7_13_1 Node1_7_13 Node1_7_14 2499999.9999999995
R_1_7_13_2 Node1_7_13 Node1_8_13 2499999.9999999995
R_1_7_13_3 Node1_7_13 GND 2560.0
R_1_7_14_1 Node1_7_14 Node1_7_15 2499999.9999999995
R_1_7_14_2 Node1_7_14 Node1_8_14 2499999.9999999995
R_1_7_14_3 Node1_7_14 GND 2560.0
R_1_7_15_2 Node1_7_15 Node1_8_15 2499999.9999999995
R_1_7_15_3 Node1_7_15 GND 2560.0
R_1_8_0_1 Node1_8_0 Node1_8_1 2499999.9999999995
R_1_8_0_2 Node1_8_0 Node1_9_0 2499999.9999999995
R_1_8_0_3 Node1_8_0 GND 2560.0
R_1_8_1_1 Node1_8_1 Node1_8_2 2499999.9999999995
R_1_8_1_2 Node1_8_1 Node1_9_1 2499999.9999999995
R_1_8_1_3 Node1_8_1 GND 2560.0
R_1_8_2_1 Node1_8_2 Node1_8_3 2499999.9999999995
R_1_8_2_2 Node1_8_2 Node1_9_2 2499999.9999999995
R_1_8_2_3 Node1_8_2 GND 2560.0
R_1_8_3_1 Node1_8_3 Node1_8_4 2499999.9999999995
R_1_8_3_2 Node1_8_3 Node1_9_3 2499999.9999999995
R_1_8_3_3 Node1_8_3 GND 2560.0
R_1_8_4_1 Node1_8_4 Node1_8_5 2499999.9999999995
R_1_8_4_2 Node1_8_4 Node1_9_4 2499999.9999999995
R_1_8_4_3 Node1_8_4 GND 2560.0
R_1_8_5_1 Node1_8_5 Node1_8_6 2499999.9999999995
R_1_8_5_2 Node1_8_5 Node1_9_5 2499999.9999999995
R_1_8_5_3 Node1_8_5 GND 2560.0
R_1_8_6_1 Node1_8_6 Node1_8_7 2499999.9999999995
R_1_8_6_2 Node1_8_6 Node1_9_6 2499999.9999999995
R_1_8_6_3 Node1_8_6 GND 2560.0
R_1_8_7_1 Node1_8_7 Node1_8_8 2499999.9999999995
R_1_8_7_2 Node1_8_7 Node1_9_7 2499999.9999999995
R_1_8_7_3 Node1_8_7 GND 2560.0
R_1_8_8_1 Node1_8_8 Node1_8_9 2499999.9999999995
R_1_8_8_2 Node1_8_8 Node1_9_8 2499999.9999999995
R_1_8_8_3 Node1_8_8 GND 2560.0
R_1_8_9_1 Node1_8_9 Node1_8_10 2499999.9999999995
R_1_8_9_2 Node1_8_9 Node1_9_9 2499999.9999999995
R_1_8_9_3 Node1_8_9 GND 2560.0
R_1_8_10_1 Node1_8_10 Node1_8_11 2499999.9999999995
R_1_8_10_2 Node1_8_10 Node1_9_10 2499999.9999999995
R_1_8_10_3 Node1_8_10 GND 2560.0
R_1_8_11_1 Node1_8_11 Node1_8_12 2499999.9999999995
R_1_8_11_2 Node1_8_11 Node1_9_11 2499999.9999999995
R_1_8_11_3 Node1_8_11 GND 2560.0
R_1_8_12_1 Node1_8_12 Node1_8_13 2499999.9999999995
R_1_8_12_2 Node1_8_12 Node1_9_12 2499999.9999999995
R_1_8_12_3 Node1_8_12 GND 2560.0
R_1_8_13_1 Node1_8_13 Node1_8_14 2499999.9999999995
R_1_8_13_2 Node1_8_13 Node1_9_13 2499999.9999999995
R_1_8_13_3 Node1_8_13 GND 2560.0
R_1_8_14_1 Node1_8_14 Node1_8_15 2499999.9999999995
R_1_8_14_2 Node1_8_14 Node1_9_14 2499999.9999999995
R_1_8_14_3 Node1_8_14 GND 2560.0
R_1_8_15_2 Node1_8_15 Node1_9_15 2499999.9999999995
R_1_8_15_3 Node1_8_15 GND 2560.0
R_1_9_0_1 Node1_9_0 Node1_9_1 2499999.9999999995
R_1_9_0_2 Node1_9_0 Node1_10_0 2499999.9999999995
R_1_9_0_3 Node1_9_0 GND 2560.0
R_1_9_1_1 Node1_9_1 Node1_9_2 2499999.9999999995
R_1_9_1_2 Node1_9_1 Node1_10_1 2499999.9999999995
R_1_9_1_3 Node1_9_1 GND 2560.0
R_1_9_2_1 Node1_9_2 Node1_9_3 2499999.9999999995
R_1_9_2_2 Node1_9_2 Node1_10_2 2499999.9999999995
R_1_9_2_3 Node1_9_2 GND 2560.0
R_1_9_3_1 Node1_9_3 Node1_9_4 2499999.9999999995
R_1_9_3_2 Node1_9_3 Node1_10_3 2499999.9999999995
R_1_9_3_3 Node1_9_3 GND 2560.0
R_1_9_4_1 Node1_9_4 Node1_9_5 2499999.9999999995
R_1_9_4_2 Node1_9_4 Node1_10_4 2499999.9999999995
R_1_9_4_3 Node1_9_4 GND 2560.0
R_1_9_5_1 Node1_9_5 Node1_9_6 2499999.9999999995
R_1_9_5_2 Node1_9_5 Node1_10_5 2499999.9999999995
R_1_9_5_3 Node1_9_5 GND 2560.0
R_1_9_6_1 Node1_9_6 Node1_9_7 2499999.9999999995
R_1_9_6_2 Node1_9_6 Node1_10_6 2499999.9999999995
R_1_9_6_3 Node1_9_6 GND 2560.0
R_1_9_7_1 Node1_9_7 Node1_9_8 2499999.9999999995
R_1_9_7_2 Node1_9_7 Node1_10_7 2499999.9999999995
R_1_9_7_3 Node1_9_7 GND 2560.0
R_1_9_8_1 Node1_9_8 Node1_9_9 2499999.9999999995
R_1_9_8_2 Node1_9_8 Node1_10_8 2499999.9999999995
R_1_9_8_3 Node1_9_8 GND 2560.0
R_1_9_9_1 Node1_9_9 Node1_9_10 2499999.9999999995
R_1_9_9_2 Node1_9_9 Node1_10_9 2499999.9999999995
R_1_9_9_3 Node1_9_9 GND 2560.0
R_1_9_10_1 Node1_9_10 Node1_9_11 2499999.9999999995
R_1_9_10_2 Node1_9_10 Node1_10_10 2499999.9999999995
R_1_9_10_3 Node1_9_10 GND 2560.0
R_1_9_11_1 Node1_9_11 Node1_9_12 2499999.9999999995
R_1_9_11_2 Node1_9_11 Node1_10_11 2499999.9999999995
R_1_9_11_3 Node1_9_11 GND 2560.0
R_1_9_12_1 Node1_9_12 Node1_9_13 2499999.9999999995
R_1_9_12_2 Node1_9_12 Node1_10_12 2499999.9999999995
R_1_9_12_3 Node1_9_12 GND 2560.0
R_1_9_13_1 Node1_9_13 Node1_9_14 2499999.9999999995
R_1_9_13_2 Node1_9_13 Node1_10_13 2499999.9999999995
R_1_9_13_3 Node1_9_13 GND 2560.0
R_1_9_14_1 Node1_9_14 Node1_9_15 2499999.9999999995
R_1_9_14_2 Node1_9_14 Node1_10_14 2499999.9999999995
R_1_9_14_3 Node1_9_14 GND 2560.0
R_1_9_15_2 Node1_9_15 Node1_10_15 2499999.9999999995
R_1_9_15_3 Node1_9_15 GND 2560.0
R_1_10_0_1 Node1_10_0 Node1_10_1 2499999.9999999995
R_1_10_0_2 Node1_10_0 Node1_11_0 2499999.9999999995
R_1_10_0_3 Node1_10_0 GND 2560.0
R_1_10_1_1 Node1_10_1 Node1_10_2 2499999.9999999995
R_1_10_1_2 Node1_10_1 Node1_11_1 2499999.9999999995
R_1_10_1_3 Node1_10_1 GND 2560.0
R_1_10_2_1 Node1_10_2 Node1_10_3 2499999.9999999995
R_1_10_2_2 Node1_10_2 Node1_11_2 2499999.9999999995
R_1_10_2_3 Node1_10_2 GND 2560.0
R_1_10_3_1 Node1_10_3 Node1_10_4 2499999.9999999995
R_1_10_3_2 Node1_10_3 Node1_11_3 2499999.9999999995
R_1_10_3_3 Node1_10_3 GND 2560.0
R_1_10_4_1 Node1_10_4 Node1_10_5 2499999.9999999995
R_1_10_4_2 Node1_10_4 Node1_11_4 2499999.9999999995
R_1_10_4_3 Node1_10_4 GND 2560.0
R_1_10_5_1 Node1_10_5 Node1_10_6 2499999.9999999995
R_1_10_5_2 Node1_10_5 Node1_11_5 2499999.9999999995
R_1_10_5_3 Node1_10_5 GND 2560.0
R_1_10_6_1 Node1_10_6 Node1_10_7 2499999.9999999995
R_1_10_6_2 Node1_10_6 Node1_11_6 2499999.9999999995
R_1_10_6_3 Node1_10_6 GND 2560.0
R_1_10_7_1 Node1_10_7 Node1_10_8 2499999.9999999995
R_1_10_7_2 Node1_10_7 Node1_11_7 2499999.9999999995
R_1_10_7_3 Node1_10_7 GND 2560.0
R_1_10_8_1 Node1_10_8 Node1_10_9 2499999.9999999995
R_1_10_8_2 Node1_10_8 Node1_11_8 2499999.9999999995
R_1_10_8_3 Node1_10_8 GND 2560.0
R_1_10_9_1 Node1_10_9 Node1_10_10 2499999.9999999995
R_1_10_9_2 Node1_10_9 Node1_11_9 2499999.9999999995
R_1_10_9_3 Node1_10_9 GND 2560.0
R_1_10_10_1 Node1_10_10 Node1_10_11 2499999.9999999995
R_1_10_10_2 Node1_10_10 Node1_11_10 2499999.9999999995
R_1_10_10_3 Node1_10_10 GND 2560.0
R_1_10_11_1 Node1_10_11 Node1_10_12 2499999.9999999995
R_1_10_11_2 Node1_10_11 Node1_11_11 2499999.9999999995
R_1_10_11_3 Node1_10_11 GND 2560.0
R_1_10_12_1 Node1_10_12 Node1_10_13 2499999.9999999995
R_1_10_12_2 Node1_10_12 Node1_11_12 2499999.9999999995
R_1_10_12_3 Node1_10_12 GND 2560.0
R_1_10_13_1 Node1_10_13 Node1_10_14 2499999.9999999995
R_1_10_13_2 Node1_10_13 Node1_11_13 2499999.9999999995
R_1_10_13_3 Node1_10_13 GND 2560.0
R_1_10_14_1 Node1_10_14 Node1_10_15 2499999.9999999995
R_1_10_14_2 Node1_10_14 Node1_11_14 2499999.9999999995
R_1_10_14_3 Node1_10_14 GND 2560.0
R_1_10_15_2 Node1_10_15 Node1_11_15 2499999.9999999995
R_1_10_15_3 Node1_10_15 GND 2560.0
R_1_11_0_1 Node1_11_0 Node1_11_1 2499999.9999999995
R_1_11_0_2 Node1_11_0 Node1_12_0 2499999.9999999995
R_1_11_0_3 Node1_11_0 GND 2560.0
R_1_11_1_1 Node1_11_1 Node1_11_2 2499999.9999999995
R_1_11_1_2 Node1_11_1 Node1_12_1 2499999.9999999995
R_1_11_1_3 Node1_11_1 GND 2560.0
R_1_11_2_1 Node1_11_2 Node1_11_3 2499999.9999999995
R_1_11_2_2 Node1_11_2 Node1_12_2 2499999.9999999995
R_1_11_2_3 Node1_11_2 GND 2560.0
R_1_11_3_1 Node1_11_3 Node1_11_4 2499999.9999999995
R_1_11_3_2 Node1_11_3 Node1_12_3 2499999.9999999995
R_1_11_3_3 Node1_11_3 GND 2560.0
R_1_11_4_1 Node1_11_4 Node1_11_5 2499999.9999999995
R_1_11_4_2 Node1_11_4 Node1_12_4 2499999.9999999995
R_1_11_4_3 Node1_11_4 GND 2560.0
R_1_11_5_1 Node1_11_5 Node1_11_6 2499999.9999999995
R_1_11_5_2 Node1_11_5 Node1_12_5 2499999.9999999995
R_1_11_5_3 Node1_11_5 GND 2560.0
R_1_11_6_1 Node1_11_6 Node1_11_7 2499999.9999999995
R_1_11_6_2 Node1_11_6 Node1_12_6 2499999.9999999995
R_1_11_6_3 Node1_11_6 GND 2560.0
R_1_11_7_1 Node1_11_7 Node1_11_8 2499999.9999999995
R_1_11_7_2 Node1_11_7 Node1_12_7 2499999.9999999995
R_1_11_7_3 Node1_11_7 GND 2560.0
R_1_11_8_1 Node1_11_8 Node1_11_9 2499999.9999999995
R_1_11_8_2 Node1_11_8 Node1_12_8 2499999.9999999995
R_1_11_8_3 Node1_11_8 GND 2560.0
R_1_11_9_1 Node1_11_9 Node1_11_10 2499999.9999999995
R_1_11_9_2 Node1_11_9 Node1_12_9 2499999.9999999995
R_1_11_9_3 Node1_11_9 GND 2560.0
R_1_11_10_1 Node1_11_10 Node1_11_11 2499999.9999999995
R_1_11_10_2 Node1_11_10 Node1_12_10 2499999.9999999995
R_1_11_10_3 Node1_11_10 GND 2560.0
R_1_11_11_1 Node1_11_11 Node1_11_12 2499999.9999999995
R_1_11_11_2 Node1_11_11 Node1_12_11 2499999.9999999995
R_1_11_11_3 Node1_11_11 GND 2560.0
R_1_11_12_1 Node1_11_12 Node1_11_13 2499999.9999999995
R_1_11_12_2 Node1_11_12 Node1_12_12 2499999.9999999995
R_1_11_12_3 Node1_11_12 GND 2560.0
R_1_11_13_1 Node1_11_13 Node1_11_14 2499999.9999999995
R_1_11_13_2 Node1_11_13 Node1_12_13 2499999.9999999995
R_1_11_13_3 Node1_11_13 GND 2560.0
R_1_11_14_1 Node1_11_14 Node1_11_15 2499999.9999999995
R_1_11_14_2 Node1_11_14 Node1_12_14 2499999.9999999995
R_1_11_14_3 Node1_11_14 GND 2560.0
R_1_11_15_2 Node1_11_15 Node1_12_15 2499999.9999999995
R_1_11_15_3 Node1_11_15 GND 2560.0
R_1_12_0_1 Node1_12_0 Node1_12_1 2499999.9999999995
R_1_12_0_2 Node1_12_0 Node1_13_0 2499999.9999999995
R_1_12_0_3 Node1_12_0 GND 2560.0
R_1_12_1_1 Node1_12_1 Node1_12_2 2499999.9999999995
R_1_12_1_2 Node1_12_1 Node1_13_1 2499999.9999999995
R_1_12_1_3 Node1_12_1 GND 2560.0
R_1_12_2_1 Node1_12_2 Node1_12_3 2499999.9999999995
R_1_12_2_2 Node1_12_2 Node1_13_2 2499999.9999999995
R_1_12_2_3 Node1_12_2 GND 2560.0
R_1_12_3_1 Node1_12_3 Node1_12_4 2499999.9999999995
R_1_12_3_2 Node1_12_3 Node1_13_3 2499999.9999999995
R_1_12_3_3 Node1_12_3 GND 2560.0
R_1_12_4_1 Node1_12_4 Node1_12_5 2499999.9999999995
R_1_12_4_2 Node1_12_4 Node1_13_4 2499999.9999999995
R_1_12_4_3 Node1_12_4 GND 2560.0
R_1_12_5_1 Node1_12_5 Node1_12_6 2499999.9999999995
R_1_12_5_2 Node1_12_5 Node1_13_5 2499999.9999999995
R_1_12_5_3 Node1_12_5 GND 2560.0
R_1_12_6_1 Node1_12_6 Node1_12_7 2499999.9999999995
R_1_12_6_2 Node1_12_6 Node1_13_6 2499999.9999999995
R_1_12_6_3 Node1_12_6 GND 2560.0
R_1_12_7_1 Node1_12_7 Node1_12_8 2499999.9999999995
R_1_12_7_2 Node1_12_7 Node1_13_7 2499999.9999999995
R_1_12_7_3 Node1_12_7 GND 2560.0
R_1_12_8_1 Node1_12_8 Node1_12_9 2499999.9999999995
R_1_12_8_2 Node1_12_8 Node1_13_8 2499999.9999999995
R_1_12_8_3 Node1_12_8 GND 2560.0
R_1_12_9_1 Node1_12_9 Node1_12_10 2499999.9999999995
R_1_12_9_2 Node1_12_9 Node1_13_9 2499999.9999999995
R_1_12_9_3 Node1_12_9 GND 2560.0
R_1_12_10_1 Node1_12_10 Node1_12_11 2499999.9999999995
R_1_12_10_2 Node1_12_10 Node1_13_10 2499999.9999999995
R_1_12_10_3 Node1_12_10 GND 2560.0
R_1_12_11_1 Node1_12_11 Node1_12_12 2499999.9999999995
R_1_12_11_2 Node1_12_11 Node1_13_11 2499999.9999999995
R_1_12_11_3 Node1_12_11 GND 2560.0
R_1_12_12_1 Node1_12_12 Node1_12_13 2499999.9999999995
R_1_12_12_2 Node1_12_12 Node1_13_12 2499999.9999999995
R_1_12_12_3 Node1_12_12 GND 2560.0
R_1_12_13_1 Node1_12_13 Node1_12_14 2499999.9999999995
R_1_12_13_2 Node1_12_13 Node1_13_13 2499999.9999999995
R_1_12_13_3 Node1_12_13 GND 2560.0
R_1_12_14_1 Node1_12_14 Node1_12_15 2499999.9999999995
R_1_12_14_2 Node1_12_14 Node1_13_14 2499999.9999999995
R_1_12_14_3 Node1_12_14 GND 2560.0
R_1_12_15_2 Node1_12_15 Node1_13_15 2499999.9999999995
R_1_12_15_3 Node1_12_15 GND 2560.0
R_1_13_0_1 Node1_13_0 Node1_13_1 2499999.9999999995
R_1_13_0_2 Node1_13_0 Node1_14_0 2499999.9999999995
R_1_13_0_3 Node1_13_0 GND 2560.0
R_1_13_1_1 Node1_13_1 Node1_13_2 2499999.9999999995
R_1_13_1_2 Node1_13_1 Node1_14_1 2499999.9999999995
R_1_13_1_3 Node1_13_1 GND 2560.0
R_1_13_2_1 Node1_13_2 Node1_13_3 2499999.9999999995
R_1_13_2_2 Node1_13_2 Node1_14_2 2499999.9999999995
R_1_13_2_3 Node1_13_2 GND 2560.0
R_1_13_3_1 Node1_13_3 Node1_13_4 2499999.9999999995
R_1_13_3_2 Node1_13_3 Node1_14_3 2499999.9999999995
R_1_13_3_3 Node1_13_3 GND 2560.0
R_1_13_4_1 Node1_13_4 Node1_13_5 2499999.9999999995
R_1_13_4_2 Node1_13_4 Node1_14_4 2499999.9999999995
R_1_13_4_3 Node1_13_4 GND 2560.0
R_1_13_5_1 Node1_13_5 Node1_13_6 2499999.9999999995
R_1_13_5_2 Node1_13_5 Node1_14_5 2499999.9999999995
R_1_13_5_3 Node1_13_5 GND 2560.0
R_1_13_6_1 Node1_13_6 Node1_13_7 2499999.9999999995
R_1_13_6_2 Node1_13_6 Node1_14_6 2499999.9999999995
R_1_13_6_3 Node1_13_6 GND 2560.0
R_1_13_7_1 Node1_13_7 Node1_13_8 2499999.9999999995
R_1_13_7_2 Node1_13_7 Node1_14_7 2499999.9999999995
R_1_13_7_3 Node1_13_7 GND 2560.0
R_1_13_8_1 Node1_13_8 Node1_13_9 2499999.9999999995
R_1_13_8_2 Node1_13_8 Node1_14_8 2499999.9999999995
R_1_13_8_3 Node1_13_8 GND 2560.0
R_1_13_9_1 Node1_13_9 Node1_13_10 2499999.9999999995
R_1_13_9_2 Node1_13_9 Node1_14_9 2499999.9999999995
R_1_13_9_3 Node1_13_9 GND 2560.0
R_1_13_10_1 Node1_13_10 Node1_13_11 2499999.9999999995
R_1_13_10_2 Node1_13_10 Node1_14_10 2499999.9999999995
R_1_13_10_3 Node1_13_10 GND 2560.0
R_1_13_11_1 Node1_13_11 Node1_13_12 2499999.9999999995
R_1_13_11_2 Node1_13_11 Node1_14_11 2499999.9999999995
R_1_13_11_3 Node1_13_11 GND 2560.0
R_1_13_12_1 Node1_13_12 Node1_13_13 2499999.9999999995
R_1_13_12_2 Node1_13_12 Node1_14_12 2499999.9999999995
R_1_13_12_3 Node1_13_12 GND 2560.0
R_1_13_13_1 Node1_13_13 Node1_13_14 2499999.9999999995
R_1_13_13_2 Node1_13_13 Node1_14_13 2499999.9999999995
R_1_13_13_3 Node1_13_13 GND 2560.0
R_1_13_14_1 Node1_13_14 Node1_13_15 2499999.9999999995
R_1_13_14_2 Node1_13_14 Node1_14_14 2499999.9999999995
R_1_13_14_3 Node1_13_14 GND 2560.0
R_1_13_15_2 Node1_13_15 Node1_14_15 2499999.9999999995
R_1_13_15_3 Node1_13_15 GND 2560.0
R_1_14_0_1 Node1_14_0 Node1_14_1 2499999.9999999995
R_1_14_0_2 Node1_14_0 Node1_15_0 2499999.9999999995
R_1_14_0_3 Node1_14_0 GND 2560.0
R_1_14_1_1 Node1_14_1 Node1_14_2 2499999.9999999995
R_1_14_1_2 Node1_14_1 Node1_15_1 2499999.9999999995
R_1_14_1_3 Node1_14_1 GND 2560.0
R_1_14_2_1 Node1_14_2 Node1_14_3 2499999.9999999995
R_1_14_2_2 Node1_14_2 Node1_15_2 2499999.9999999995
R_1_14_2_3 Node1_14_2 GND 2560.0
R_1_14_3_1 Node1_14_3 Node1_14_4 2499999.9999999995
R_1_14_3_2 Node1_14_3 Node1_15_3 2499999.9999999995
R_1_14_3_3 Node1_14_3 GND 2560.0
R_1_14_4_1 Node1_14_4 Node1_14_5 2499999.9999999995
R_1_14_4_2 Node1_14_4 Node1_15_4 2499999.9999999995
R_1_14_4_3 Node1_14_4 GND 2560.0
R_1_14_5_1 Node1_14_5 Node1_14_6 2499999.9999999995
R_1_14_5_2 Node1_14_5 Node1_15_5 2499999.9999999995
R_1_14_5_3 Node1_14_5 GND 2560.0
R_1_14_6_1 Node1_14_6 Node1_14_7 2499999.9999999995
R_1_14_6_2 Node1_14_6 Node1_15_6 2499999.9999999995
R_1_14_6_3 Node1_14_6 GND 2560.0
R_1_14_7_1 Node1_14_7 Node1_14_8 2499999.9999999995
R_1_14_7_2 Node1_14_7 Node1_15_7 2499999.9999999995
R_1_14_7_3 Node1_14_7 GND 2560.0
R_1_14_8_1 Node1_14_8 Node1_14_9 2499999.9999999995
R_1_14_8_2 Node1_14_8 Node1_15_8 2499999.9999999995
R_1_14_8_3 Node1_14_8 GND 2560.0
R_1_14_9_1 Node1_14_9 Node1_14_10 2499999.9999999995
R_1_14_9_2 Node1_14_9 Node1_15_9 2499999.9999999995
R_1_14_9_3 Node1_14_9 GND 2560.0
R_1_14_10_1 Node1_14_10 Node1_14_11 2499999.9999999995
R_1_14_10_2 Node1_14_10 Node1_15_10 2499999.9999999995
R_1_14_10_3 Node1_14_10 GND 2560.0
R_1_14_11_1 Node1_14_11 Node1_14_12 2499999.9999999995
R_1_14_11_2 Node1_14_11 Node1_15_11 2499999.9999999995
R_1_14_11_3 Node1_14_11 GND 2560.0
R_1_14_12_1 Node1_14_12 Node1_14_13 2499999.9999999995
R_1_14_12_2 Node1_14_12 Node1_15_12 2499999.9999999995
R_1_14_12_3 Node1_14_12 GND 2560.0
R_1_14_13_1 Node1_14_13 Node1_14_14 2499999.9999999995
R_1_14_13_2 Node1_14_13 Node1_15_13 2499999.9999999995
R_1_14_13_3 Node1_14_13 GND 2560.0
R_1_14_14_1 Node1_14_14 Node1_14_15 2499999.9999999995
R_1_14_14_2 Node1_14_14 Node1_15_14 2499999.9999999995
R_1_14_14_3 Node1_14_14 GND 2560.0
R_1_14_15_2 Node1_14_15 Node1_15_15 2499999.9999999995
R_1_14_15_3 Node1_14_15 GND 2560.0
R_1_15_0_1 Node1_15_0 Node1_15_1 2499999.9999999995
R_1_15_0_3 Node1_15_0 GND 2560.0
R_1_15_1_1 Node1_15_1 Node1_15_2 2499999.9999999995
R_1_15_1_3 Node1_15_1 GND 2560.0
R_1_15_2_1 Node1_15_2 Node1_15_3 2499999.9999999995
R_1_15_2_3 Node1_15_2 GND 2560.0
R_1_15_3_1 Node1_15_3 Node1_15_4 2499999.9999999995
R_1_15_3_3 Node1_15_3 GND 2560.0
R_1_15_4_1 Node1_15_4 Node1_15_5 2499999.9999999995
R_1_15_4_3 Node1_15_4 GND 2560.0
R_1_15_5_1 Node1_15_5 Node1_15_6 2499999.9999999995
R_1_15_5_3 Node1_15_5 GND 2560.0
R_1_15_6_1 Node1_15_6 Node1_15_7 2499999.9999999995
R_1_15_6_3 Node1_15_6 GND 2560.0
R_1_15_7_1 Node1_15_7 Node1_15_8 2499999.9999999995
R_1_15_7_3 Node1_15_7 GND 2560.0
R_1_15_8_1 Node1_15_8 Node1_15_9 2499999.9999999995
R_1_15_8_3 Node1_15_8 GND 2560.0
R_1_15_9_1 Node1_15_9 Node1_15_10 2499999.9999999995
R_1_15_9_3 Node1_15_9 GND 2560.0
R_1_15_10_1 Node1_15_10 Node1_15_11 2499999.9999999995
R_1_15_10_3 Node1_15_10 GND 2560.0
R_1_15_11_1 Node1_15_11 Node1_15_12 2499999.9999999995
R_1_15_11_3 Node1_15_11 GND 2560.0
R_1_15_12_1 Node1_15_12 Node1_15_13 2499999.9999999995
R_1_15_12_3 Node1_15_12 GND 2560.0
R_1_15_13_1 Node1_15_13 Node1_15_14 2499999.9999999995
R_1_15_13_3 Node1_15_13 GND 2560.0
R_1_15_14_1 Node1_15_14 Node1_15_15 2499999.9999999995
R_1_15_14_3 Node1_15_14 GND 2560.0
R_1_15_15_3 Node1_15_15 GND 2560.0
.OP
.OPTIONS LINSOL TYPE=AztecOO
.PRINT DC FORMAT=CSV PRECISION=4 V(Node0_0_0) V(Node0_0_1) V(Node0_0_2) V(Node0_0_3) V(Node0_0_4) V(Node0_0_5) V(Node0_0_6) V(Node0_0_7) V(Node0_0_8) V(Node0_0_9) V(Node0_0_10) V(Node0_0_11) V(Node0_0_12) V(Node0_0_13) V(Node0_0_14) V(Node0_0_15) V(Node0_1_0) V(Node0_1_1) V(Node0_1_2) V(Node0_1_3) V(Node0_1_4) V(Node0_1_5) V(Node0_1_6) V(Node0_1_7) V(Node0_1_8) V(Node0_1_9) V(Node0_1_10) V(Node0_1_11) V(Node0_1_12) V(Node0_1_13) V(Node0_1_14) V(Node0_1_15) V(Node0_2_0) V(Node0_2_1) V(Node0_2_2) V(Node0_2_3) V(Node0_2_4) V(Node0_2_5) V(Node0_2_6) V(Node0_2_7) V(Node0_2_8) V(Node0_2_9) V(Node0_2_10) V(Node0_2_11) V(Node0_2_12) V(Node0_2_13) V(Node0_2_14) V(Node0_2_15) V(Node0_3_0) V(Node0_3_1) V(Node0_3_2) V(Node0_3_3) V(Node0_3_4) V(Node0_3_5) V(Node0_3_6) V(Node0_3_7) V(Node0_3_8) V(Node0_3_9) V(Node0_3_10) V(Node0_3_11) V(Node0_3_12) V(Node0_3_13) V(Node0_3_14) V(Node0_3_15) V(Node0_4_0) V(Node0_4_1) V(Node0_4_2) V(Node0_4_3) V(Node0_4_4) V(Node0_4_5) V(Node0_4_6) V(Node0_4_7) V(Node0_4_8) V(Node0_4_9) V(Node0_4_10) V(Node0_4_11) V(Node0_4_12) V(Node0_4_13) V(Node0_4_14) V(Node0_4_15) V(Node0_5_0) V(Node0_5_1) V(Node0_5_2) V(Node0_5_3) V(Node0_5_4) V(Node0_5_5) V(Node0_5_6) V(Node0_5_7) V(Node0_5_8) V(Node0_5_9) V(Node0_5_10) V(Node0_5_11) V(Node0_5_12) V(Node0_5_13) V(Node0_5_14) V(Node0_5_15) V(Node0_6_0) V(Node0_6_1) V(Node0_6_2) V(Node0_6_3) V(Node0_6_4) V(Node0_6_5) V(Node0_6_6) V(Node0_6_7) V(Node0_6_8) V(Node0_6_9) V(Node0_6_10) V(Node0_6_11) V(Node0_6_12) V(Node0_6_13) V(Node0_6_14) V(Node0_6_15) V(Node0_7_0) V(Node0_7_1) V(Node0_7_2) V(Node0_7_3) V(Node0_7_4) V(Node0_7_5) V(Node0_7_6) V(Node0_7_7) V(Node0_7_8) V(Node0_7_9) V(Node0_7_10) V(Node0_7_11) V(Node0_7_12) V(Node0_7_13) V(Node0_7_14) V(Node0_7_15) V(Node0_8_0) V(Node0_8_1) V(Node0_8_2) V(Node0_8_3) V(Node0_8_4) V(Node0_8_5) V(Node0_8_6) V(Node0_8_7) V(Node0_8_8) V(Node0_8_9) V(Node0_8_10) V(Node0_8_11) V(Node0_8_12) V(Node0_8_13) V(Node0_8_14) V(Node0_8_15) V(Node0_9_0) V(Node0_9_1) V(Node0_9_2) V(Node0_9_3) V(Node0_9_4) V(Node0_9_5) V(Node0_9_6) V(Node0_9_7) V(Node0_9_8) V(Node0_9_9) V(Node0_9_10) V(Node0_9_11) V(Node0_9_12) V(Node0_9_13) V(Node0_9_14) V(Node0_9_15) V(Node0_10_0) V(Node0_10_1) V(Node0_10_2) V(Node0_10_3) V(Node0_10_4) V(Node0_10_5) V(Node0_10_6) V(Node0_10_7) V(Node0_10_8) V(Node0_10_9) V(Node0_10_10) V(Node0_10_11) V(Node0_10_12) V(Node0_10_13) V(Node0_10_14) V(Node0_10_15) V(Node0_11_0) V(Node0_11_1) V(Node0_11_2) V(Node0_11_3) V(Node0_11_4) V(Node0_11_5) V(Node0_11_6) V(Node0_11_7) V(Node0_11_8) V(Node0_11_9) V(Node0_11_10) V(Node0_11_11) V(Node0_11_12) V(Node0_11_13) V(Node0_11_14) V(Node0_11_15) V(Node0_12_0) V(Node0_12_1) V(Node0_12_2) V(Node0_12_3) V(Node0_12_4) V(Node0_12_5) V(Node0_12_6) V(Node0_12_7) V(Node0_12_8) V(Node0_12_9) V(Node0_12_10) V(Node0_12_11) V(Node0_12_12) V(Node0_12_13) V(Node0_12_14) V(Node0_12_15) V(Node0_13_0) V(Node0_13_1) V(Node0_13_2) V(Node0_13_3) V(Node0_13_4) V(Node0_13_5) V(Node0_13_6) V(Node0_13_7) V(Node0_13_8) V(Node0_13_9) V(Node0_13_10) V(Node0_13_11) V(Node0_13_12) V(Node0_13_13) V(Node0_13_14) V(Node0_13_15) V(Node0_14_0) V(Node0_14_1) V(Node0_14_2) V(Node0_14_3) V(Node0_14_4) V(Node0_14_5) V(Node0_14_6) V(Node0_14_7) V(Node0_14_8) V(Node0_14_9) V(Node0_14_10) V(Node0_14_11) V(Node0_14_12) V(Node0_14_13) V(Node0_14_14) V(Node0_14_15) V(Node0_15_0) V(Node0_15_1) V(Node0_15_2) V(Node0_15_3) V(Node0_15_4) V(Node0_15_5) V(Node0_15_6) V(Node0_15_7) V(Node0_15_8) V(Node0_15_9) V(Node0_15_10) V(Node0_15_11) V(Node0_15_12) V(Node0_15_13) V(Node0_15_14) V(Node0_15_15) V(Node1_0_0) V(Node1_0_1) V(Node1_0_2) V(Node1_0_3) V(Node1_0_4) V(Node1_0_5) V(Node1_0_6) V(Node1_0_7) V(Node1_0_8) V(Node1_0_9) V(Node1_0_10) V(Node1_0_11) V(Node1_0_12) V(Node1_0_13) V(Node1_0_14) V(Node1_0_15) V(Node1_1_0) V(Node1_1_1) V(Node1_1_2) V(Node1_1_3) V(Node1_1_4) V(Node1_1_5) V(Node1_1_6) V(Node1_1_7) V(Node1_1_8) V(Node1_1_9) V(Node1_1_10) V(Node1_1_11) V(Node1_1_12) V(Node1_1_13) V(Node1_1_14) V(Node1_1_15) V(Node1_2_0) V(Node1_2_1) V(Node1_2_2) V(Node1_2_3) V(Node1_2_4) V(Node1_2_5) V(Node1_2_6) V(Node1_2_7) V(Node1_2_8) V(Node1_2_9) V(Node1_2_10) V(Node1_2_11) V(Node1_2_12) V(Node1_2_13) V(Node1_2_14) V(Node1_2_15) V(Node1_3_0) V(Node1_3_1) V(Node1_3_2) V(Node1_3_3) V(Node1_3_4) V(Node1_3_5) V(Node1_3_6) V(Node1_3_7) V(Node1_3_8) V(Node1_3_9) V(Node1_3_10) V(Node1_3_11) V(Node1_3_12) V(Node1_3_13) V(Node1_3_14) V(Node1_3_15) V(Node1_4_0) V(Node1_4_1) V(Node1_4_2) V(Node1_4_3) V(Node1_4_4) V(Node1_4_5) V(Node1_4_6) V(Node1_4_7) V(Node1_4_8) V(Node1_4_9) V(Node1_4_10) V(Node1_4_11) V(Node1_4_12) V(Node1_4_13) V(Node1_4_14) V(Node1_4_15) V(Node1_5_0) V(Node1_5_1) V(Node1_5_2) V(Node1_5_3) V(Node1_5_4) V(Node1_5_5) V(Node1_5_6) V(Node1_5_7) V(Node1_5_8) V(Node1_5_9) V(Node1_5_10) V(Node1_5_11) V(Node1_5_12) V(Node1_5_13) V(Node1_5_14) V(Node1_5_15) V(Node1_6_0) V(Node1_6_1) V(Node1_6_2) V(Node1_6_3) V(Node1_6_4) V(Node1_6_5) V(Node1_6_6) V(Node1_6_7) V(Node1_6_8) V(Node1_6_9) V(Node1_6_10) V(Node1_6_11) V(Node1_6_12) V(Node1_6_13) V(Node1_6_14) V(Node1_6_15) V(Node1_7_0) V(Node1_7_1) V(Node1_7_2) V(Node1_7_3) V(Node1_7_4) V(Node1_7_5) V(Node1_7_6) V(Node1_7_7) V(Node1_7_8) V(Node1_7_9) V(Node1_7_10) V(Node1_7_11) V(Node1_7_12) V(Node1_7_13) V(Node1_7_14) V(Node1_7_15) V(Node1_8_0) V(Node1_8_1) V(Node1_8_2) V(Node1_8_3) V(Node1_8_4) V(Node1_8_5) V(Node1_8_6) V(Node1_8_7) V(Node1_8_8) V(Node1_8_9) V(Node1_8_10) V(Node1_8_11) V(Node1_8_12) V(Node1_8_13) V(Node1_8_14) V(Node1_8_15) V(Node1_9_0) V(Node1_9_1) V(Node1_9_2) V(Node1_9_3) V(Node1_9_4) V(Node1_9_5) V(Node1_9_6) V(Node1_9_7) V(Node1_9_8) V(Node1_9_9) V(Node1_9_10) V(Node1_9_11) V(Node1_9_12) V(Node1_9_13) V(Node1_9_14) V(Node1_9_15) V(Node1_10_0) V(Node1_10_1) V(Node1_10_2) V(Node1_10_3) V(Node1_10_4) V(Node1_10_5) V(Node1_10_6) V(Node1_10_7) V(Node1_10_8) V(Node1_10_9) V(Node1_10_10) V(Node1_10_11) V(Node1_10_12) V(Node1_10_13) V(Node1_10_14) V(Node1_10_15) V(Node1_11_0) V(Node1_11_1) V(Node1_11_2) V(Node1_11_3) V(Node1_11_4) V(Node1_11_5) V(Node1_11_6) V(Node1_11_7) V(Node1_11_8) V(Node1_11_9) V(Node1_11_10) V(Node1_11_11) V(Node1_11_12) V(Node1_11_13) V(Node1_11_14) V(Node1_11_15) V(Node1_12_0) V(Node1_12_1) V(Node1_12_2) V(Node1_12_3) V(Node1_12_4) V(Node1_12_5) V(Node1_12_6) V(Node1_12_7) V(Node1_12_8) V(Node1_12_9) V(Node1_12_10) V(Node1_12_11) V(Node1_12_12) V(Node1_12_13) V(Node1_12_14) V(Node1_12_15) V(Node1_13_0) V(Node1_13_1) V(Node1_13_2) V(Node1_13_3) V(Node1_13_4) V(Node1_13_5) V(Node1_13_6) V(Node1_13_7) V(Node1_13_8) V(Node1_13_9) V(Node1_13_10) V(Node1_13_11) V(Node1_13_12) V(Node1_13_13) V(Node1_13_14) V(Node1_13_15) V(Node1_14_0) V(Node1_14_1) V(Node1_14_2) V(Node1_14_3) V(Node1_14_4) V(Node1_14_5) V(Node1_14_6) V(Node1_14_7) V(Node1_14_8) V(Node1_14_9) V(Node1_14_10) V(Node1_14_11) V(Node1_14_12) V(Node1_14_13) V(Node1_14_14) V(Node1_14_15) V(Node1_15_0) V(Node1_15_1) V(Node1_15_2) V(Node1_15_3) V(Node1_15_4) V(Node1_15_5) V(Node1_15_6) V(Node1_15_7) V(Node1_15_8) V(Node1_15_9) V(Node1_15_10) V(Node1_15_11) V(Node1_15_12) V(Node1_15_13) V(Node1_15_14) V(Node1_15_15)
.SAVE TYPE=IC
.end
