.title spice transient solver
Vg GND 0 318.15
R_0_0_0_1 Node0_0_0 Node0_0_1 6033333.33333334
R_0_0_0_2 Node0_0_0 Node0_1_0 6033333.333333337
R_0_0_0_3 Node0_0_0 Node1_0_0 22.24128000000002
C_0_0_0 Node0_0_0 GND 4.0992187499999963e-10
R_0_0_1_1 Node0_0_1 Node0_0_2 6033333.33333334
R_0_0_1_2 Node0_0_1 Node0_1_1 6033333.333333337
R_0_0_1_3 Node0_0_1 Node1_0_1 22.24128000000002
C_0_0_1 Node0_0_1 GND 4.0992187499999963e-10
R_0_0_2_1 Node0_0_2 Node0_0_3 6033333.33333334
R_0_0_2_2 Node0_0_2 Node0_1_2 6033333.333333337
R_0_0_2_3 Node0_0_2 Node1_0_2 22.24128000000002
C_0_0_2 Node0_0_2 GND 4.0992187499999963e-10
R_0_0_3_1 Node0_0_3 Node0_0_4 6033333.33333334
R_0_0_3_2 Node0_0_3 Node0_1_3 6033333.333333337
R_0_0_3_3 Node0_0_3 Node1_0_3 22.24128000000002
C_0_0_3 Node0_0_3 GND 4.0992187499999963e-10
R_0_0_4_1 Node0_0_4 Node0_0_5 6033333.33333334
R_0_0_4_2 Node0_0_4 Node0_1_4 6033333.333333337
R_0_0_4_3 Node0_0_4 Node1_0_4 22.24128000000002
C_0_0_4 Node0_0_4 GND 4.0992187499999963e-10
R_0_0_5_1 Node0_0_5 Node0_0_6 6033333.33333334
R_0_0_5_2 Node0_0_5 Node0_1_5 6033333.333333337
R_0_0_5_3 Node0_0_5 Node1_0_5 22.24128000000002
C_0_0_5 Node0_0_5 GND 4.0992187499999963e-10
R_0_0_6_1 Node0_0_6 Node0_0_7 6033333.33333334
R_0_0_6_2 Node0_0_6 Node0_1_6 6033333.333333337
R_0_0_6_3 Node0_0_6 Node1_0_6 22.24128000000002
C_0_0_6 Node0_0_6 GND 4.0992187499999963e-10
R_0_0_7_1 Node0_0_7 Node0_0_8 6033333.33333334
R_0_0_7_2 Node0_0_7 Node0_1_7 6033333.333333337
R_0_0_7_3 Node0_0_7 Node1_0_7 22.24128000000002
C_0_0_7 Node0_0_7 GND 4.0992187499999963e-10
R_0_0_8_1 Node0_0_8 Node0_0_9 6033333.33333334
R_0_0_8_2 Node0_0_8 Node0_1_8 6033333.333333337
R_0_0_8_3 Node0_0_8 Node1_0_8 22.24128000000002
C_0_0_8 Node0_0_8 GND 4.0992187499999963e-10
R_0_0_9_1 Node0_0_9 Node0_0_10 6033333.33333334
R_0_0_9_2 Node0_0_9 Node0_1_9 6033333.333333337
R_0_0_9_3 Node0_0_9 Node1_0_9 22.24128000000002
C_0_0_9 Node0_0_9 GND 4.0992187499999963e-10
R_0_0_10_1 Node0_0_10 Node0_0_11 6033333.33333334
R_0_0_10_2 Node0_0_10 Node0_1_10 6033333.333333337
R_0_0_10_3 Node0_0_10 Node1_0_10 22.24128000000002
C_0_0_10 Node0_0_10 GND 4.0992187499999963e-10
R_0_0_11_1 Node0_0_11 Node0_0_12 6033333.33333334
R_0_0_11_2 Node0_0_11 Node0_1_11 6033333.333333337
R_0_0_11_3 Node0_0_11 Node1_0_11 22.24128000000002
C_0_0_11 Node0_0_11 GND 4.0992187499999963e-10
R_0_0_12_1 Node0_0_12 Node0_0_13 6033333.33333334
R_0_0_12_2 Node0_0_12 Node0_1_12 6033333.333333337
R_0_0_12_3 Node0_0_12 Node1_0_12 22.24128000000002
C_0_0_12 Node0_0_12 GND 4.0992187499999963e-10
R_0_0_13_1 Node0_0_13 Node0_0_14 6033333.33333334
R_0_0_13_2 Node0_0_13 Node0_1_13 6033333.333333337
R_0_0_13_3 Node0_0_13 Node1_0_13 22.24128000000002
C_0_0_13 Node0_0_13 GND 4.0992187499999963e-10
R_0_0_14_1 Node0_0_14 Node0_0_15 6033333.333333337
R_0_0_14_2 Node0_0_14 Node0_1_14 6033333.333333337
R_0_0_14_3 Node0_0_14 Node1_0_14 22.24128000000002
C_0_0_14 Node0_0_14 GND 4.0992187499999963e-10
R_0_0_15_2 Node0_0_15 Node0_1_15 6033333.333333331
R_0_0_15_3 Node0_0_15 Node1_0_15 22.24128
C_0_0_15 Node0_0_15 GND 4.09921875e-10
R_0_1_0_1 Node0_1_0 Node0_1_1 6033333.333333334
R_0_1_0_2 Node0_1_0 Node0_2_0 6033333.333333334
R_0_1_0_3 Node0_1_0 Node1_1_0 22.24128
C_0_1_0 Node0_1_0 GND 4.09921875e-10
R_0_1_1_1 Node0_1_1 Node0_1_2 6033333.333333334
R_0_1_1_2 Node0_1_1 Node0_2_1 6033333.333333334
R_0_1_1_3 Node0_1_1 Node1_1_1 22.24128
C_0_1_1 Node0_1_1 GND 4.09921875e-10
R_0_1_2_1 Node0_1_2 Node0_1_3 6033333.333333334
R_0_1_2_2 Node0_1_2 Node0_2_2 6033333.333333334
R_0_1_2_3 Node0_1_2 Node1_1_2 22.24128
C_0_1_2 Node0_1_2 GND 4.09921875e-10
R_0_1_3_1 Node0_1_3 Node0_1_4 6033333.333333334
R_0_1_3_2 Node0_1_3 Node0_2_3 6033333.333333334
R_0_1_3_3 Node0_1_3 Node1_1_3 22.24128
C_0_1_3 Node0_1_3 GND 4.09921875e-10
R_0_1_4_1 Node0_1_4 Node0_1_5 6033333.333333334
R_0_1_4_2 Node0_1_4 Node0_2_4 6033333.333333334
R_0_1_4_3 Node0_1_4 Node1_1_4 22.24128
C_0_1_4 Node0_1_4 GND 4.09921875e-10
R_0_1_5_1 Node0_1_5 Node0_1_6 6033333.333333334
R_0_1_5_2 Node0_1_5 Node0_2_5 6033333.333333334
R_0_1_5_3 Node0_1_5 Node1_1_5 22.24128
C_0_1_5 Node0_1_5 GND 4.09921875e-10
R_0_1_6_1 Node0_1_6 Node0_1_7 6033333.333333334
R_0_1_6_2 Node0_1_6 Node0_2_6 6033333.333333334
R_0_1_6_3 Node0_1_6 Node1_1_6 22.24128
C_0_1_6 Node0_1_6 GND 4.09921875e-10
R_0_1_7_1 Node0_1_7 Node0_1_8 6033333.333333334
R_0_1_7_2 Node0_1_7 Node0_2_7 6033333.333333334
R_0_1_7_3 Node0_1_7 Node1_1_7 22.24128
C_0_1_7 Node0_1_7 GND 4.09921875e-10
R_0_1_8_1 Node0_1_8 Node0_1_9 6033333.333333334
R_0_1_8_2 Node0_1_8 Node0_2_8 6033333.333333334
R_0_1_8_3 Node0_1_8 Node1_1_8 22.24128
C_0_1_8 Node0_1_8 GND 4.09921875e-10
R_0_1_9_1 Node0_1_9 Node0_1_10 6033333.333333334
R_0_1_9_2 Node0_1_9 Node0_2_9 6033333.333333334
R_0_1_9_3 Node0_1_9 Node1_1_9 22.24128
C_0_1_9 Node0_1_9 GND 4.09921875e-10
R_0_1_10_1 Node0_1_10 Node0_1_11 6033333.333333334
R_0_1_10_2 Node0_1_10 Node0_2_10 6033333.333333334
R_0_1_10_3 Node0_1_10 Node1_1_10 22.24128
C_0_1_10 Node0_1_10 GND 4.09921875e-10
R_0_1_11_1 Node0_1_11 Node0_1_12 6033333.333333334
R_0_1_11_2 Node0_1_11 Node0_2_11 6033333.333333334
R_0_1_11_3 Node0_1_11 Node1_1_11 22.24128
C_0_1_11 Node0_1_11 GND 4.09921875e-10
R_0_1_12_1 Node0_1_12 Node0_1_13 6033333.333333334
R_0_1_12_2 Node0_1_12 Node0_2_12 6033333.333333334
R_0_1_12_3 Node0_1_12 Node1_1_12 22.24128
C_0_1_12 Node0_1_12 GND 4.09921875e-10
R_0_1_13_1 Node0_1_13 Node0_1_14 6033333.333333334
R_0_1_13_2 Node0_1_13 Node0_2_13 6033333.333333334
R_0_1_13_3 Node0_1_13 Node1_1_13 22.24128
C_0_1_13 Node0_1_13 GND 4.09921875e-10
R_0_1_14_1 Node0_1_14 Node0_1_15 6033333.333333331
R_0_1_14_2 Node0_1_14 Node0_2_14 6033333.333333334
R_0_1_14_3 Node0_1_14 Node1_1_14 22.24128
C_0_1_14 Node0_1_14 GND 4.09921875e-10
R_0_1_15_2 Node0_1_15 Node0_2_15 6033333.333333328
R_0_1_15_3 Node0_1_15 Node1_1_15 22.24127999999998
C_0_1_15 Node0_1_15 GND 4.0992187500000036e-10
R_0_2_0_1 Node0_2_0 Node0_2_1 6033333.333333334
R_0_2_0_2 Node0_2_0 Node0_3_0 6033333.333333334
R_0_2_0_3 Node0_2_0 Node1_2_0 22.24128
C_0_2_0 Node0_2_0 GND 4.09921875e-10
R_0_2_1_1 Node0_2_1 Node0_2_2 6033333.333333334
R_0_2_1_2 Node0_2_1 Node0_3_1 6033333.333333334
R_0_2_1_3 Node0_2_1 Node1_2_1 22.24128
C_0_2_1 Node0_2_1 GND 4.09921875e-10
R_0_2_2_1 Node0_2_2 Node0_2_3 6033333.333333334
R_0_2_2_2 Node0_2_2 Node0_3_2 6033333.333333334
R_0_2_2_3 Node0_2_2 Node1_2_2 22.24128
C_0_2_2 Node0_2_2 GND 4.09921875e-10
R_0_2_3_1 Node0_2_3 Node0_2_4 6033333.333333334
R_0_2_3_2 Node0_2_3 Node0_3_3 6033333.333333334
R_0_2_3_3 Node0_2_3 Node1_2_3 22.24128
C_0_2_3 Node0_2_3 GND 4.09921875e-10
R_0_2_4_1 Node0_2_4 Node0_2_5 6033333.333333334
R_0_2_4_2 Node0_2_4 Node0_3_4 6033333.333333334
R_0_2_4_3 Node0_2_4 Node1_2_4 22.24128
C_0_2_4 Node0_2_4 GND 4.09921875e-10
R_0_2_5_1 Node0_2_5 Node0_2_6 6033333.333333334
R_0_2_5_2 Node0_2_5 Node0_3_5 6033333.333333334
R_0_2_5_3 Node0_2_5 Node1_2_5 22.24128
C_0_2_5 Node0_2_5 GND 4.09921875e-10
R_0_2_6_1 Node0_2_6 Node0_2_7 6033333.333333334
R_0_2_6_2 Node0_2_6 Node0_3_6 6033333.333333334
R_0_2_6_3 Node0_2_6 Node1_2_6 22.24128
C_0_2_6 Node0_2_6 GND 4.09921875e-10
R_0_2_7_1 Node0_2_7 Node0_2_8 6033333.333333334
R_0_2_7_2 Node0_2_7 Node0_3_7 6033333.333333334
R_0_2_7_3 Node0_2_7 Node1_2_7 22.24128
C_0_2_7 Node0_2_7 GND 4.09921875e-10
R_0_2_8_1 Node0_2_8 Node0_2_9 6033333.333333334
R_0_2_8_2 Node0_2_8 Node0_3_8 6033333.333333334
R_0_2_8_3 Node0_2_8 Node1_2_8 22.24128
C_0_2_8 Node0_2_8 GND 4.09921875e-10
R_0_2_9_1 Node0_2_9 Node0_2_10 6033333.333333334
R_0_2_9_2 Node0_2_9 Node0_3_9 6033333.333333334
R_0_2_9_3 Node0_2_9 Node1_2_9 22.24128
C_0_2_9 Node0_2_9 GND 4.09921875e-10
R_0_2_10_1 Node0_2_10 Node0_2_11 6033333.333333334
R_0_2_10_2 Node0_2_10 Node0_3_10 6033333.333333334
R_0_2_10_3 Node0_2_10 Node1_2_10 22.24128
C_0_2_10 Node0_2_10 GND 4.09921875e-10
R_0_2_11_1 Node0_2_11 Node0_2_12 6033333.333333334
R_0_2_11_2 Node0_2_11 Node0_3_11 6033333.333333334
R_0_2_11_3 Node0_2_11 Node1_2_11 22.24128
C_0_2_11 Node0_2_11 GND 4.09921875e-10
R_0_2_12_1 Node0_2_12 Node0_2_13 6033333.333333334
R_0_2_12_2 Node0_2_12 Node0_3_12 6033333.333333334
R_0_2_12_3 Node0_2_12 Node1_2_12 22.24128
C_0_2_12 Node0_2_12 GND 4.09921875e-10
R_0_2_13_1 Node0_2_13 Node0_2_14 6033333.333333334
R_0_2_13_2 Node0_2_13 Node0_3_13 6033333.333333334
R_0_2_13_3 Node0_2_13 Node1_2_13 22.24128
C_0_2_13 Node0_2_13 GND 4.09921875e-10
R_0_2_14_1 Node0_2_14 Node0_2_15 6033333.333333331
R_0_2_14_2 Node0_2_14 Node0_3_14 6033333.333333334
R_0_2_14_3 Node0_2_14 Node1_2_14 22.24128
C_0_2_14 Node0_2_14 GND 4.09921875e-10
R_0_2_15_2 Node0_2_15 Node0_3_15 6033333.333333328
R_0_2_15_3 Node0_2_15 Node1_2_15 22.24127999999998
C_0_2_15 Node0_2_15 GND 4.0992187500000036e-10
R_0_3_0_1 Node0_3_0 Node0_3_1 6033333.333333334
R_0_3_0_2 Node0_3_0 Node0_4_0 6033333.333333334
R_0_3_0_3 Node0_3_0 Node1_3_0 22.24128
C_0_3_0 Node0_3_0 GND 4.09921875e-10
R_0_3_1_1 Node0_3_1 Node0_3_2 6033333.333333334
R_0_3_1_2 Node0_3_1 Node0_4_1 6033333.333333334
R_0_3_1_3 Node0_3_1 Node1_3_1 22.24128
C_0_3_1 Node0_3_1 GND 4.09921875e-10
R_0_3_2_1 Node0_3_2 Node0_3_3 6033333.333333334
R_0_3_2_2 Node0_3_2 Node0_4_2 6033333.333333334
R_0_3_2_3 Node0_3_2 Node1_3_2 22.24128
C_0_3_2 Node0_3_2 GND 4.09921875e-10
R_0_3_3_1 Node0_3_3 Node0_3_4 6033333.333333334
R_0_3_3_2 Node0_3_3 Node0_4_3 6033333.333333334
R_0_3_3_3 Node0_3_3 Node1_3_3 22.24128
C_0_3_3 Node0_3_3 GND 4.09921875e-10
R_0_3_4_1 Node0_3_4 Node0_3_5 6033333.333333334
R_0_3_4_2 Node0_3_4 Node0_4_4 6033333.333333334
R_0_3_4_3 Node0_3_4 Node1_3_4 22.24128
C_0_3_4 Node0_3_4 GND 4.09921875e-10
R_0_3_5_1 Node0_3_5 Node0_3_6 6033333.333333334
R_0_3_5_2 Node0_3_5 Node0_4_5 6033333.333333334
R_0_3_5_3 Node0_3_5 Node1_3_5 22.24128
C_0_3_5 Node0_3_5 GND 4.09921875e-10
R_0_3_6_1 Node0_3_6 Node0_3_7 6033333.333333334
R_0_3_6_2 Node0_3_6 Node0_4_6 6033333.333333334
R_0_3_6_3 Node0_3_6 Node1_3_6 22.24128
C_0_3_6 Node0_3_6 GND 4.09921875e-10
R_0_3_7_1 Node0_3_7 Node0_3_8 6033333.333333334
R_0_3_7_2 Node0_3_7 Node0_4_7 6033333.333333334
R_0_3_7_3 Node0_3_7 Node1_3_7 22.24128
C_0_3_7 Node0_3_7 GND 4.09921875e-10
R_0_3_8_1 Node0_3_8 Node0_3_9 6033333.333333334
R_0_3_8_2 Node0_3_8 Node0_4_8 6033333.333333334
R_0_3_8_3 Node0_3_8 Node1_3_8 22.24128
C_0_3_8 Node0_3_8 GND 4.09921875e-10
R_0_3_9_1 Node0_3_9 Node0_3_10 6033333.333333334
R_0_3_9_2 Node0_3_9 Node0_4_9 6033333.333333334
R_0_3_9_3 Node0_3_9 Node1_3_9 22.24128
C_0_3_9 Node0_3_9 GND 4.09921875e-10
R_0_3_10_1 Node0_3_10 Node0_3_11 6033333.333333334
R_0_3_10_2 Node0_3_10 Node0_4_10 6033333.333333334
R_0_3_10_3 Node0_3_10 Node1_3_10 22.24128
C_0_3_10 Node0_3_10 GND 4.09921875e-10
R_0_3_11_1 Node0_3_11 Node0_3_12 6033333.333333334
R_0_3_11_2 Node0_3_11 Node0_4_11 6033333.333333334
R_0_3_11_3 Node0_3_11 Node1_3_11 22.24128
C_0_3_11 Node0_3_11 GND 4.09921875e-10
R_0_3_12_1 Node0_3_12 Node0_3_13 6033333.333333334
R_0_3_12_2 Node0_3_12 Node0_4_12 6033333.333333334
R_0_3_12_3 Node0_3_12 Node1_3_12 22.24128
C_0_3_12 Node0_3_12 GND 4.09921875e-10
R_0_3_13_1 Node0_3_13 Node0_3_14 6033333.333333334
R_0_3_13_2 Node0_3_13 Node0_4_13 6033333.333333334
R_0_3_13_3 Node0_3_13 Node1_3_13 22.24128
C_0_3_13 Node0_3_13 GND 4.09921875e-10
R_0_3_14_1 Node0_3_14 Node0_3_15 6033333.333333331
R_0_3_14_2 Node0_3_14 Node0_4_14 6033333.333333334
R_0_3_14_3 Node0_3_14 Node1_3_14 22.24128
C_0_3_14 Node0_3_14 GND 4.09921875e-10
R_0_3_15_2 Node0_3_15 Node0_4_15 6033333.333333328
R_0_3_15_3 Node0_3_15 Node1_3_15 22.24127999999998
C_0_3_15 Node0_3_15 GND 4.0992187500000036e-10
R_0_4_0_1 Node0_4_0 Node0_4_1 6033333.333333334
R_0_4_0_2 Node0_4_0 Node0_5_0 6033333.333333334
R_0_4_0_3 Node0_4_0 Node1_4_0 22.24128
C_0_4_0 Node0_4_0 GND 4.09921875e-10
R_0_4_1_1 Node0_4_1 Node0_4_2 6033333.333333334
R_0_4_1_2 Node0_4_1 Node0_5_1 6033333.333333334
R_0_4_1_3 Node0_4_1 Node1_4_1 22.24128
C_0_4_1 Node0_4_1 GND 4.09921875e-10
R_0_4_2_1 Node0_4_2 Node0_4_3 6033333.333333334
R_0_4_2_2 Node0_4_2 Node0_5_2 6033333.333333334
R_0_4_2_3 Node0_4_2 Node1_4_2 22.24128
C_0_4_2 Node0_4_2 GND 4.09921875e-10
R_0_4_3_1 Node0_4_3 Node0_4_4 6033333.333333334
R_0_4_3_2 Node0_4_3 Node0_5_3 6033333.333333334
R_0_4_3_3 Node0_4_3 Node1_4_3 22.24128
C_0_4_3 Node0_4_3 GND 4.09921875e-10
R_0_4_4_1 Node0_4_4 Node0_4_5 6033333.333333334
R_0_4_4_2 Node0_4_4 Node0_5_4 6033333.333333334
R_0_4_4_3 Node0_4_4 Node1_4_4 22.24128
C_0_4_4 Node0_4_4 GND 4.09921875e-10
R_0_4_5_1 Node0_4_5 Node0_4_6 6033333.333333334
R_0_4_5_2 Node0_4_5 Node0_5_5 6033333.333333334
R_0_4_5_3 Node0_4_5 Node1_4_5 22.24128
C_0_4_5 Node0_4_5 GND 4.09921875e-10
R_0_4_6_1 Node0_4_6 Node0_4_7 6033333.333333334
R_0_4_6_2 Node0_4_6 Node0_5_6 6033333.333333334
R_0_4_6_3 Node0_4_6 Node1_4_6 22.24128
C_0_4_6 Node0_4_6 GND 4.09921875e-10
R_0_4_7_1 Node0_4_7 Node0_4_8 6033333.333333334
R_0_4_7_2 Node0_4_7 Node0_5_7 6033333.333333334
R_0_4_7_3 Node0_4_7 Node1_4_7 22.24128
C_0_4_7 Node0_4_7 GND 4.09921875e-10
R_0_4_8_1 Node0_4_8 Node0_4_9 6033333.333333334
R_0_4_8_2 Node0_4_8 Node0_5_8 6033333.333333334
R_0_4_8_3 Node0_4_8 Node1_4_8 22.24128
C_0_4_8 Node0_4_8 GND 4.09921875e-10
R_0_4_9_1 Node0_4_9 Node0_4_10 6033333.333333334
R_0_4_9_2 Node0_4_9 Node0_5_9 6033333.333333334
R_0_4_9_3 Node0_4_9 Node1_4_9 22.24128
C_0_4_9 Node0_4_9 GND 4.09921875e-10
R_0_4_10_1 Node0_4_10 Node0_4_11 6033333.333333334
R_0_4_10_2 Node0_4_10 Node0_5_10 6033333.333333334
R_0_4_10_3 Node0_4_10 Node1_4_10 22.24128
C_0_4_10 Node0_4_10 GND 4.09921875e-10
R_0_4_11_1 Node0_4_11 Node0_4_12 6033333.333333334
R_0_4_11_2 Node0_4_11 Node0_5_11 6033333.333333334
R_0_4_11_3 Node0_4_11 Node1_4_11 22.24128
C_0_4_11 Node0_4_11 GND 4.09921875e-10
R_0_4_12_1 Node0_4_12 Node0_4_13 6033333.333333334
R_0_4_12_2 Node0_4_12 Node0_5_12 6033333.333333334
R_0_4_12_3 Node0_4_12 Node1_4_12 22.24128
C_0_4_12 Node0_4_12 GND 4.09921875e-10
R_0_4_13_1 Node0_4_13 Node0_4_14 6033333.333333334
R_0_4_13_2 Node0_4_13 Node0_5_13 6033333.333333334
R_0_4_13_3 Node0_4_13 Node1_4_13 22.24128
C_0_4_13 Node0_4_13 GND 4.09921875e-10
R_0_4_14_1 Node0_4_14 Node0_4_15 6033333.333333331
R_0_4_14_2 Node0_4_14 Node0_5_14 6033333.333333334
R_0_4_14_3 Node0_4_14 Node1_4_14 22.24128
C_0_4_14 Node0_4_14 GND 4.09921875e-10
R_0_4_15_2 Node0_4_15 Node0_5_15 6033333.333333328
R_0_4_15_3 Node0_4_15 Node1_4_15 22.24127999999998
C_0_4_15 Node0_4_15 GND 4.0992187500000036e-10
R_0_5_0_1 Node0_5_0 Node0_5_1 6033333.333333334
R_0_5_0_2 Node0_5_0 Node0_6_0 6033333.333333334
R_0_5_0_3 Node0_5_0 Node1_5_0 22.24128
C_0_5_0 Node0_5_0 GND 4.09921875e-10
R_0_5_1_1 Node0_5_1 Node0_5_2 6033333.333333334
R_0_5_1_2 Node0_5_1 Node0_6_1 6033333.333333334
R_0_5_1_3 Node0_5_1 Node1_5_1 22.24128
C_0_5_1 Node0_5_1 GND 4.09921875e-10
R_0_5_2_1 Node0_5_2 Node0_5_3 6033333.333333334
R_0_5_2_2 Node0_5_2 Node0_6_2 6033333.333333334
R_0_5_2_3 Node0_5_2 Node1_5_2 22.24128
C_0_5_2 Node0_5_2 GND 4.09921875e-10
R_0_5_3_1 Node0_5_3 Node0_5_4 6033333.333333334
R_0_5_3_2 Node0_5_3 Node0_6_3 6033333.333333334
R_0_5_3_3 Node0_5_3 Node1_5_3 22.24128
C_0_5_3 Node0_5_3 GND 4.09921875e-10
R_0_5_4_1 Node0_5_4 Node0_5_5 6033333.333333334
R_0_5_4_2 Node0_5_4 Node0_6_4 6033333.333333334
R_0_5_4_3 Node0_5_4 Node1_5_4 22.24128
C_0_5_4 Node0_5_4 GND 4.09921875e-10
R_0_5_5_1 Node0_5_5 Node0_5_6 6033333.333333334
R_0_5_5_2 Node0_5_5 Node0_6_5 6033333.333333334
R_0_5_5_3 Node0_5_5 Node1_5_5 22.24128
C_0_5_5 Node0_5_5 GND 4.09921875e-10
R_0_5_6_1 Node0_5_6 Node0_5_7 6033333.333333334
R_0_5_6_2 Node0_5_6 Node0_6_6 6033333.333333334
R_0_5_6_3 Node0_5_6 Node1_5_6 22.24128
C_0_5_6 Node0_5_6 GND 4.09921875e-10
R_0_5_7_1 Node0_5_7 Node0_5_8 6033333.333333334
R_0_5_7_2 Node0_5_7 Node0_6_7 6033333.333333334
R_0_5_7_3 Node0_5_7 Node1_5_7 22.24128
C_0_5_7 Node0_5_7 GND 4.09921875e-10
R_0_5_8_1 Node0_5_8 Node0_5_9 6033333.333333334
R_0_5_8_2 Node0_5_8 Node0_6_8 6033333.333333334
R_0_5_8_3 Node0_5_8 Node1_5_8 22.24128
C_0_5_8 Node0_5_8 GND 4.09921875e-10
R_0_5_9_1 Node0_5_9 Node0_5_10 6033333.333333334
R_0_5_9_2 Node0_5_9 Node0_6_9 6033333.333333332
R_0_5_9_3 Node0_5_9 Node1_5_9 22.24128
C_0_5_9 Node0_5_9 GND 4.09921875e-10
R_0_5_10_1 Node0_5_10 Node0_5_11 6033333.333333334
R_0_5_10_2 Node0_5_10 Node0_6_10 6033333.333333334
R_0_5_10_3 Node0_5_10 Node1_5_10 22.24128
C_0_5_10 Node0_5_10 GND 4.09921875e-10
R_0_5_11_1 Node0_5_11 Node0_5_12 6033333.333333334
R_0_5_11_2 Node0_5_11 Node0_6_11 6033333.333333334
R_0_5_11_3 Node0_5_11 Node1_5_11 22.24128
C_0_5_11 Node0_5_11 GND 4.09921875e-10
R_0_5_12_1 Node0_5_12 Node0_5_13 6033333.333333334
R_0_5_12_2 Node0_5_12 Node0_6_12 6033333.333333334
R_0_5_12_3 Node0_5_12 Node1_5_12 22.24128
C_0_5_12 Node0_5_12 GND 4.09921875e-10
R_0_5_13_1 Node0_5_13 Node0_5_14 6033333.333333334
R_0_5_13_2 Node0_5_13 Node0_6_13 6033333.333333334
R_0_5_13_3 Node0_5_13 Node1_5_13 22.24128
C_0_5_13 Node0_5_13 GND 4.09921875e-10
R_0_5_14_1 Node0_5_14 Node0_5_15 6033333.333333331
R_0_5_14_2 Node0_5_14 Node0_6_14 6033333.333333334
R_0_5_14_3 Node0_5_14 Node1_5_14 22.24128
C_0_5_14 Node0_5_14 GND 4.09921875e-10
R_0_5_15_2 Node0_5_15 Node0_6_15 6033333.333333328
R_0_5_15_3 Node0_5_15 Node1_5_15 22.24127999999998
C_0_5_15 Node0_5_15 GND 4.0992187500000036e-10
R_0_6_0_1 Node0_6_0 Node0_6_1 6033333.333333334
R_0_6_0_2 Node0_6_0 Node0_7_0 6033333.333333334
R_0_6_0_3 Node0_6_0 Node1_6_0 22.241279999999996
C_0_6_0 Node0_6_0 GND 4.09921875e-10
R_0_6_1_1 Node0_6_1 Node0_6_2 6033333.333333334
R_0_6_1_2 Node0_6_1 Node0_7_1 6033333.333333334
R_0_6_1_3 Node0_6_1 Node1_6_1 22.241279999999996
C_0_6_1 Node0_6_1 GND 4.0992187499999994e-10
R_0_6_2_1 Node0_6_2 Node0_6_3 6033333.333333334
R_0_6_2_2 Node0_6_2 Node0_7_2 6033333.333333334
R_0_6_2_3 Node0_6_2 Node1_6_2 22.241279999999996
C_0_6_2 Node0_6_2 GND 4.0992187499999994e-10
R_0_6_3_1 Node0_6_3 Node0_6_4 6033333.333333334
R_0_6_3_2 Node0_6_3 Node0_7_3 6033333.333333334
R_0_6_3_3 Node0_6_3 Node1_6_3 22.241279999999996
C_0_6_3 Node0_6_3 GND 4.0992187499999994e-10
R_0_6_4_1 Node0_6_4 Node0_6_5 6033333.333333334
R_0_6_4_2 Node0_6_4 Node0_7_4 6033333.333333334
R_0_6_4_3 Node0_6_4 Node1_6_4 22.241279999999996
C_0_6_4 Node0_6_4 GND 4.0992187499999994e-10
R_0_6_5_1 Node0_6_5 Node0_6_6 6033333.333333334
R_0_6_5_2 Node0_6_5 Node0_7_5 6033333.333333334
R_0_6_5_3 Node0_6_5 Node1_6_5 22.241279999999996
C_0_6_5 Node0_6_5 GND 4.0992187499999994e-10
R_0_6_6_1 Node0_6_6 Node0_6_7 6033333.333333334
R_0_6_6_2 Node0_6_6 Node0_7_6 6033333.333333334
R_0_6_6_3 Node0_6_6 Node1_6_6 22.241279999999996
C_0_6_6 Node0_6_6 GND 4.0992187500000005e-10
R_0_6_7_1 Node0_6_7 Node0_6_8 6033333.333333334
R_0_6_7_2 Node0_6_7 Node0_7_7 6033333.333333334
R_0_6_7_3 Node0_6_7 Node1_6_7 22.241279999999996
C_0_6_7 Node0_6_7 GND 4.0992187499999994e-10
R_0_6_8_1 Node0_6_8 Node0_6_9 6033333.333333332
R_0_6_8_2 Node0_6_8 Node0_7_8 6033333.333333334
R_0_6_8_3 Node0_6_8 Node1_6_8 22.241279999999996
C_0_6_8 Node0_6_8 GND 4.0992187499999994e-10
R_0_6_9_1 Node0_6_9 Node0_6_10 6033333.333333332
R_0_6_9_2 Node0_6_9 Node0_7_9 6033333.33333333
R_0_6_9_3 Node0_6_9 Node1_6_9 22.241279999999986
C_0_6_9 Node0_6_9 GND 4.0992187500000025e-10
R_0_6_10_1 Node0_6_10 Node0_6_11 6033333.333333334
R_0_6_10_2 Node0_6_10 Node0_7_10 6033333.333333334
R_0_6_10_3 Node0_6_10 Node1_6_10 22.241279999999996
C_0_6_10 Node0_6_10 GND 4.0992187499999994e-10
R_0_6_11_1 Node0_6_11 Node0_6_12 6033333.333333334
R_0_6_11_2 Node0_6_11 Node0_7_11 6033333.333333334
R_0_6_11_3 Node0_6_11 Node1_6_11 22.241279999999996
C_0_6_11 Node0_6_11 GND 4.0992187499999994e-10
R_0_6_12_1 Node0_6_12 Node0_6_13 6033333.333333334
R_0_6_12_2 Node0_6_12 Node0_7_12 6033333.333333334
R_0_6_12_3 Node0_6_12 Node1_6_12 22.241279999999996
C_0_6_12 Node0_6_12 GND 4.0992187499999994e-10
R_0_6_13_1 Node0_6_13 Node0_6_14 6033333.333333334
R_0_6_13_2 Node0_6_13 Node0_7_13 6033333.333333334
R_0_6_13_3 Node0_6_13 Node1_6_13 22.241279999999996
C_0_6_13 Node0_6_13 GND 4.0992187499999994e-10
R_0_6_14_1 Node0_6_14 Node0_6_15 6033333.333333331
R_0_6_14_2 Node0_6_14 Node0_7_14 6033333.333333334
R_0_6_14_3 Node0_6_14 Node1_6_14 22.241279999999996
C_0_6_14 Node0_6_14 GND 4.0992187499999994e-10
R_0_6_15_2 Node0_6_15 Node0_7_15 6033333.333333328
R_0_6_15_3 Node0_6_15 Node1_6_15 22.241279999999982
C_0_6_15 Node0_6_15 GND 4.099218750000004e-10
R_0_7_0_1 Node0_7_0 Node0_7_1 6033333.333333334
R_0_7_0_2 Node0_7_0 Node0_8_0 6033333.333333334
R_0_7_0_3 Node0_7_0 Node1_7_0 22.24128
C_0_7_0 Node0_7_0 GND 4.09921875e-10
R_0_7_1_1 Node0_7_1 Node0_7_2 6033333.333333334
R_0_7_1_2 Node0_7_1 Node0_8_1 6033333.333333334
R_0_7_1_3 Node0_7_1 Node1_7_1 22.24128
C_0_7_1 Node0_7_1 GND 4.09921875e-10
R_0_7_2_1 Node0_7_2 Node0_7_3 6033333.333333334
R_0_7_2_2 Node0_7_2 Node0_8_2 6033333.333333334
R_0_7_2_3 Node0_7_2 Node1_7_2 22.24128
C_0_7_2 Node0_7_2 GND 4.09921875e-10
R_0_7_3_1 Node0_7_3 Node0_7_4 6033333.333333334
R_0_7_3_2 Node0_7_3 Node0_8_3 6033333.333333334
R_0_7_3_3 Node0_7_3 Node1_7_3 22.24128
C_0_7_3 Node0_7_3 GND 4.09921875e-10
R_0_7_4_1 Node0_7_4 Node0_7_5 6033333.333333334
R_0_7_4_2 Node0_7_4 Node0_8_4 6033333.333333334
R_0_7_4_3 Node0_7_4 Node1_7_4 22.24128
C_0_7_4 Node0_7_4 GND 4.09921875e-10
R_0_7_5_1 Node0_7_5 Node0_7_6 6033333.333333334
R_0_7_5_2 Node0_7_5 Node0_8_5 6033333.333333334
R_0_7_5_3 Node0_7_5 Node1_7_5 22.24128
C_0_7_5 Node0_7_5 GND 4.09921875e-10
R_0_7_6_1 Node0_7_6 Node0_7_7 6033333.333333334
R_0_7_6_2 Node0_7_6 Node0_8_6 6033333.333333334
R_0_7_6_3 Node0_7_6 Node1_7_6 22.24128
C_0_7_6 Node0_7_6 GND 4.09921875e-10
R_0_7_7_1 Node0_7_7 Node0_7_8 6033333.333333334
R_0_7_7_2 Node0_7_7 Node0_8_7 6033333.333333334
R_0_7_7_3 Node0_7_7 Node1_7_7 22.24128
C_0_7_7 Node0_7_7 GND 4.09921875e-10
R_0_7_8_1 Node0_7_8 Node0_7_9 6033333.333333332
R_0_7_8_2 Node0_7_8 Node0_8_8 6033333.333333334
R_0_7_8_3 Node0_7_8 Node1_7_8 22.24128
C_0_7_8 Node0_7_8 GND 4.09921875e-10
R_0_7_9_1 Node0_7_9 Node0_7_10 6033333.333333332
R_0_7_9_2 Node0_7_9 Node0_8_9 6033333.333333329
R_0_7_9_3 Node0_7_9 Node1_7_9 22.241279999999982
C_0_7_9 Node0_7_9 GND 4.0992187500000036e-10
R_0_7_10_1 Node0_7_10 Node0_7_11 6033333.333333334
R_0_7_10_2 Node0_7_10 Node0_8_10 6033333.333333334
R_0_7_10_3 Node0_7_10 Node1_7_10 22.24128
C_0_7_10 Node0_7_10 GND 4.09921875e-10
R_0_7_11_1 Node0_7_11 Node0_7_12 6033333.333333334
R_0_7_11_2 Node0_7_11 Node0_8_11 6033333.333333334
R_0_7_11_3 Node0_7_11 Node1_7_11 22.24128
C_0_7_11 Node0_7_11 GND 4.09921875e-10
R_0_7_12_1 Node0_7_12 Node0_7_13 6033333.333333334
R_0_7_12_2 Node0_7_12 Node0_8_12 6033333.333333334
R_0_7_12_3 Node0_7_12 Node1_7_12 22.24128
C_0_7_12 Node0_7_12 GND 4.09921875e-10
R_0_7_13_1 Node0_7_13 Node0_7_14 6033333.333333334
R_0_7_13_2 Node0_7_13 Node0_8_13 6033333.333333334
R_0_7_13_3 Node0_7_13 Node1_7_13 22.24128
C_0_7_13 Node0_7_13 GND 4.09921875e-10
R_0_7_14_1 Node0_7_14 Node0_7_15 6033333.333333331
R_0_7_14_2 Node0_7_14 Node0_8_14 6033333.333333334
R_0_7_14_3 Node0_7_14 Node1_7_14 22.24128
C_0_7_14 Node0_7_14 GND 4.09921875e-10
R_0_7_15_2 Node0_7_15 Node0_8_15 6033333.333333328
R_0_7_15_3 Node0_7_15 Node1_7_15 22.24127999999998
C_0_7_15 Node0_7_15 GND 4.0992187500000036e-10
R_0_8_0_1 Node0_8_0 Node0_8_1 6033333.333333334
R_0_8_0_2 Node0_8_0 Node0_9_0 6033333.333333336
R_0_8_0_3 Node0_8_0 Node1_8_0 22.24128
C_0_8_0 Node0_8_0 GND 4.09921875e-10
R_0_8_1_1 Node0_8_1 Node0_8_2 6033333.333333334
R_0_8_1_2 Node0_8_1 Node0_9_1 6033333.333333336
R_0_8_1_3 Node0_8_1 Node1_8_1 22.24128
C_0_8_1 Node0_8_1 GND 4.09921875e-10
R_0_8_2_1 Node0_8_2 Node0_8_3 6033333.333333334
R_0_8_2_2 Node0_8_2 Node0_9_2 6033333.333333336
R_0_8_2_3 Node0_8_2 Node1_8_2 22.24128
C_0_8_2 Node0_8_2 GND 4.09921875e-10
R_0_8_3_1 Node0_8_3 Node0_8_4 6033333.333333334
R_0_8_3_2 Node0_8_3 Node0_9_3 6033333.333333336
R_0_8_3_3 Node0_8_3 Node1_8_3 22.24128
C_0_8_3 Node0_8_3 GND 4.09921875e-10
R_0_8_4_1 Node0_8_4 Node0_8_5 6033333.333333334
R_0_8_4_2 Node0_8_4 Node0_9_4 6033333.333333336
R_0_8_4_3 Node0_8_4 Node1_8_4 22.24128
C_0_8_4 Node0_8_4 GND 4.09921875e-10
R_0_8_5_1 Node0_8_5 Node0_8_6 6033333.333333334
R_0_8_5_2 Node0_8_5 Node0_9_5 6033333.333333336
R_0_8_5_3 Node0_8_5 Node1_8_5 22.24128
C_0_8_5 Node0_8_5 GND 4.09921875e-10
R_0_8_6_1 Node0_8_6 Node0_8_7 6033333.333333334
R_0_8_6_2 Node0_8_6 Node0_9_6 6033333.333333337
R_0_8_6_3 Node0_8_6 Node1_8_6 22.24128
C_0_8_6 Node0_8_6 GND 4.09921875e-10
R_0_8_7_1 Node0_8_7 Node0_8_8 6033333.333333334
R_0_8_7_2 Node0_8_7 Node0_9_7 6033333.333333336
R_0_8_7_3 Node0_8_7 Node1_8_7 22.24128
C_0_8_7 Node0_8_7 GND 4.09921875e-10
R_0_8_8_1 Node0_8_8 Node0_8_9 6033333.333333332
R_0_8_8_2 Node0_8_8 Node0_9_8 6033333.333333336
R_0_8_8_3 Node0_8_8 Node1_8_8 22.24128
C_0_8_8 Node0_8_8 GND 4.09921875e-10
R_0_8_9_1 Node0_8_9 Node0_8_10 6033333.333333332
R_0_8_9_2 Node0_8_9 Node0_9_9 6033333.333333332
R_0_8_9_3 Node0_8_9 Node1_8_9 22.241279999999982
C_0_8_9 Node0_8_9 GND 4.0992187500000036e-10
R_0_8_10_1 Node0_8_10 Node0_8_11 6033333.333333334
R_0_8_10_2 Node0_8_10 Node0_9_10 6033333.333333336
R_0_8_10_3 Node0_8_10 Node1_8_10 22.24128
C_0_8_10 Node0_8_10 GND 4.09921875e-10
R_0_8_11_1 Node0_8_11 Node0_8_12 6033333.333333334
R_0_8_11_2 Node0_8_11 Node0_9_11 6033333.333333336
R_0_8_11_3 Node0_8_11 Node1_8_11 22.24128
C_0_8_11 Node0_8_11 GND 4.09921875e-10
R_0_8_12_1 Node0_8_12 Node0_8_13 6033333.333333334
R_0_8_12_2 Node0_8_12 Node0_9_12 6033333.333333336
R_0_8_12_3 Node0_8_12 Node1_8_12 22.24128
C_0_8_12 Node0_8_12 GND 4.09921875e-10
R_0_8_13_1 Node0_8_13 Node0_8_14 6033333.333333334
R_0_8_13_2 Node0_8_13 Node0_9_13 6033333.333333336
R_0_8_13_3 Node0_8_13 Node1_8_13 22.24128
C_0_8_13 Node0_8_13 GND 4.09921875e-10
R_0_8_14_1 Node0_8_14 Node0_8_15 6033333.333333331
R_0_8_14_2 Node0_8_14 Node0_9_14 6033333.333333336
R_0_8_14_3 Node0_8_14 Node1_8_14 22.24128
C_0_8_14 Node0_8_14 GND 4.09921875e-10
R_0_8_15_2 Node0_8_15 Node0_9_15 6033333.333333331
R_0_8_15_3 Node0_8_15 Node1_8_15 22.24127999999998
C_0_8_15 Node0_8_15 GND 4.0992187500000036e-10
R_0_9_0_1 Node0_9_0 Node0_9_1 6033333.333333339
R_0_9_0_2 Node0_9_0 Node0_10_0 6033333.333333336
R_0_9_0_3 Node0_9_0 Node1_9_0 22.241280000000017
C_0_9_0 Node0_9_0 GND 4.0992187499999963e-10
R_0_9_1_1 Node0_9_1 Node0_9_2 6033333.333333339
R_0_9_1_2 Node0_9_1 Node0_10_1 6033333.333333336
R_0_9_1_3 Node0_9_1 Node1_9_1 22.241280000000017
C_0_9_1 Node0_9_1 GND 4.0992187499999963e-10
R_0_9_2_1 Node0_9_2 Node0_9_3 6033333.333333339
R_0_9_2_2 Node0_9_2 Node0_10_2 6033333.333333336
R_0_9_2_3 Node0_9_2 Node1_9_2 22.241280000000017
C_0_9_2 Node0_9_2 GND 4.0992187499999963e-10
R_0_9_3_1 Node0_9_3 Node0_9_4 6033333.333333339
R_0_9_3_2 Node0_9_3 Node0_10_3 6033333.333333336
R_0_9_3_3 Node0_9_3 Node1_9_3 22.241280000000017
C_0_9_3 Node0_9_3 GND 4.0992187499999963e-10
R_0_9_4_1 Node0_9_4 Node0_9_5 6033333.333333339
R_0_9_4_2 Node0_9_4 Node0_10_4 6033333.333333336
R_0_9_4_3 Node0_9_4 Node1_9_4 22.241280000000017
C_0_9_4 Node0_9_4 GND 4.0992187499999963e-10
R_0_9_5_1 Node0_9_5 Node0_9_6 6033333.33333334
R_0_9_5_2 Node0_9_5 Node0_10_5 6033333.333333336
R_0_9_5_3 Node0_9_5 Node1_9_5 22.241280000000017
C_0_9_5 Node0_9_5 GND 4.0992187499999963e-10
R_0_9_6_1 Node0_9_6 Node0_9_7 6033333.33333334
R_0_9_6_2 Node0_9_6 Node0_10_6 6033333.333333337
R_0_9_6_3 Node0_9_6 Node1_9_6 22.241280000000017
C_0_9_6 Node0_9_6 GND 4.0992187499999963e-10
R_0_9_7_1 Node0_9_7 Node0_9_8 6033333.333333339
R_0_9_7_2 Node0_9_7 Node0_10_7 6033333.333333336
R_0_9_7_3 Node0_9_7 Node1_9_7 22.241280000000017
C_0_9_7 Node0_9_7 GND 4.0992187499999963e-10
R_0_9_8_1 Node0_9_8 Node0_9_9 6033333.333333338
R_0_9_8_2 Node0_9_8 Node0_10_8 6033333.333333336
R_0_9_8_3 Node0_9_8 Node1_9_8 22.241280000000017
C_0_9_8 Node0_9_8 GND 4.0992187499999963e-10
R_0_9_9_1 Node0_9_9 Node0_9_10 6033333.333333338
R_0_9_9_2 Node0_9_9 Node0_10_9 6033333.333333335
R_0_9_9_3 Node0_9_9 Node1_9_9 22.241280000000007
C_0_9_9 Node0_9_9 GND 4.0992187499999984e-10
R_0_9_10_1 Node0_9_10 Node0_9_11 6033333.333333339
R_0_9_10_2 Node0_9_10 Node0_10_10 6033333.333333336
R_0_9_10_3 Node0_9_10 Node1_9_10 22.241280000000017
C_0_9_10 Node0_9_10 GND 4.0992187499999963e-10
R_0_9_11_1 Node0_9_11 Node0_9_12 6033333.333333339
R_0_9_11_2 Node0_9_11 Node0_10_11 6033333.333333336
R_0_9_11_3 Node0_9_11 Node1_9_11 22.241280000000017
C_0_9_11 Node0_9_11 GND 4.0992187499999963e-10
R_0_9_12_1 Node0_9_12 Node0_9_13 6033333.333333339
R_0_9_12_2 Node0_9_12 Node0_10_12 6033333.333333336
R_0_9_12_3 Node0_9_12 Node1_9_12 22.241280000000017
C_0_9_12 Node0_9_12 GND 4.0992187499999963e-10
R_0_9_13_1 Node0_9_13 Node0_9_14 6033333.333333339
R_0_9_13_2 Node0_9_13 Node0_10_13 6033333.333333336
R_0_9_13_3 Node0_9_13 Node1_9_13 22.241280000000017
C_0_9_13 Node0_9_13 GND 4.0992187499999963e-10
R_0_9_14_1 Node0_9_14 Node0_9_15 6033333.333333336
R_0_9_14_2 Node0_9_14 Node0_10_14 6033333.333333336
R_0_9_14_3 Node0_9_14 Node1_9_14 22.241280000000017
C_0_9_14 Node0_9_14 GND 4.0992187499999963e-10
R_0_9_15_2 Node0_9_15 Node0_10_15 6033333.333333331
R_0_9_15_3 Node0_9_15 Node1_9_15 22.24128
C_0_9_15 Node0_9_15 GND 4.09921875e-10
R_0_10_0_1 Node0_10_0 Node0_10_1 6033333.333333334
R_0_10_0_2 Node0_10_0 Node0_11_0 6033333.333333334
R_0_10_0_3 Node0_10_0 Node1_10_0 22.24128
C_0_10_0 Node0_10_0 GND 4.09921875e-10
R_0_10_1_1 Node0_10_1 Node0_10_2 6033333.333333334
R_0_10_1_2 Node0_10_1 Node0_11_1 6033333.333333334
R_0_10_1_3 Node0_10_1 Node1_10_1 22.24128
C_0_10_1 Node0_10_1 GND 4.09921875e-10
R_0_10_2_1 Node0_10_2 Node0_10_3 6033333.333333334
R_0_10_2_2 Node0_10_2 Node0_11_2 6033333.333333334
R_0_10_2_3 Node0_10_2 Node1_10_2 22.24128
C_0_10_2 Node0_10_2 GND 4.09921875e-10
R_0_10_3_1 Node0_10_3 Node0_10_4 6033333.333333334
R_0_10_3_2 Node0_10_3 Node0_11_3 6033333.333333334
R_0_10_3_3 Node0_10_3 Node1_10_3 22.24128
C_0_10_3 Node0_10_3 GND 4.09921875e-10
R_0_10_4_1 Node0_10_4 Node0_10_5 6033333.333333334
R_0_10_4_2 Node0_10_4 Node0_11_4 6033333.333333334
R_0_10_4_3 Node0_10_4 Node1_10_4 22.24128
C_0_10_4 Node0_10_4 GND 4.09921875e-10
R_0_10_5_1 Node0_10_5 Node0_10_6 6033333.333333334
R_0_10_5_2 Node0_10_5 Node0_11_5 6033333.333333334
R_0_10_5_3 Node0_10_5 Node1_10_5 22.24128
C_0_10_5 Node0_10_5 GND 4.09921875e-10
R_0_10_6_1 Node0_10_6 Node0_10_7 6033333.333333334
R_0_10_6_2 Node0_10_6 Node0_11_6 6033333.333333334
R_0_10_6_3 Node0_10_6 Node1_10_6 22.24128
C_0_10_6 Node0_10_6 GND 4.09921875e-10
R_0_10_7_1 Node0_10_7 Node0_10_8 6033333.333333334
R_0_10_7_2 Node0_10_7 Node0_11_7 6033333.333333334
R_0_10_7_3 Node0_10_7 Node1_10_7 22.24128
C_0_10_7 Node0_10_7 GND 4.09921875e-10
R_0_10_8_1 Node0_10_8 Node0_10_9 6033333.333333334
R_0_10_8_2 Node0_10_8 Node0_11_8 6033333.333333334
R_0_10_8_3 Node0_10_8 Node1_10_8 22.24128
C_0_10_8 Node0_10_8 GND 4.09921875e-10
R_0_10_9_1 Node0_10_9 Node0_10_10 6033333.333333334
R_0_10_9_2 Node0_10_9 Node0_11_9 6033333.333333334
R_0_10_9_3 Node0_10_9 Node1_10_9 22.24128
C_0_10_9 Node0_10_9 GND 4.09921875e-10
R_0_10_10_1 Node0_10_10 Node0_10_11 6033333.333333334
R_0_10_10_2 Node0_10_10 Node0_11_10 6033333.333333334
R_0_10_10_3 Node0_10_10 Node1_10_10 22.24128
C_0_10_10 Node0_10_10 GND 4.09921875e-10
R_0_10_11_1 Node0_10_11 Node0_10_12 6033333.333333334
R_0_10_11_2 Node0_10_11 Node0_11_11 6033333.333333334
R_0_10_11_3 Node0_10_11 Node1_10_11 22.24128
C_0_10_11 Node0_10_11 GND 4.09921875e-10
R_0_10_12_1 Node0_10_12 Node0_10_13 6033333.333333334
R_0_10_12_2 Node0_10_12 Node0_11_12 6033333.333333334
R_0_10_12_3 Node0_10_12 Node1_10_12 22.24128
C_0_10_12 Node0_10_12 GND 4.09921875e-10
R_0_10_13_1 Node0_10_13 Node0_10_14 6033333.333333334
R_0_10_13_2 Node0_10_13 Node0_11_13 6033333.333333334
R_0_10_13_3 Node0_10_13 Node1_10_13 22.24128
C_0_10_13 Node0_10_13 GND 4.09921875e-10
R_0_10_14_1 Node0_10_14 Node0_10_15 6033333.333333331
R_0_10_14_2 Node0_10_14 Node0_11_14 6033333.333333334
R_0_10_14_3 Node0_10_14 Node1_10_14 22.24128
C_0_10_14 Node0_10_14 GND 4.09921875e-10
R_0_10_15_2 Node0_10_15 Node0_11_15 6033333.333333328
R_0_10_15_3 Node0_10_15 Node1_10_15 22.24127999999998
C_0_10_15 Node0_10_15 GND 4.0992187500000036e-10
R_0_11_0_1 Node0_11_0 Node0_11_1 6033333.333333334
R_0_11_0_2 Node0_11_0 Node0_12_0 6033333.333333334
R_0_11_0_3 Node0_11_0 Node1_11_0 22.24128
C_0_11_0 Node0_11_0 GND 4.09921875e-10
R_0_11_1_1 Node0_11_1 Node0_11_2 6033333.333333334
R_0_11_1_2 Node0_11_1 Node0_12_1 6033333.333333334
R_0_11_1_3 Node0_11_1 Node1_11_1 22.24128
C_0_11_1 Node0_11_1 GND 4.09921875e-10
R_0_11_2_1 Node0_11_2 Node0_11_3 6033333.333333334
R_0_11_2_2 Node0_11_2 Node0_12_2 6033333.333333334
R_0_11_2_3 Node0_11_2 Node1_11_2 22.24128
C_0_11_2 Node0_11_2 GND 4.09921875e-10
R_0_11_3_1 Node0_11_3 Node0_11_4 6033333.333333334
R_0_11_3_2 Node0_11_3 Node0_12_3 6033333.333333334
R_0_11_3_3 Node0_11_3 Node1_11_3 22.24128
C_0_11_3 Node0_11_3 GND 4.09921875e-10
R_0_11_4_1 Node0_11_4 Node0_11_5 6033333.333333334
R_0_11_4_2 Node0_11_4 Node0_12_4 6033333.333333334
R_0_11_4_3 Node0_11_4 Node1_11_4 22.24128
C_0_11_4 Node0_11_4 GND 4.09921875e-10
R_0_11_5_1 Node0_11_5 Node0_11_6 6033333.333333334
R_0_11_5_2 Node0_11_5 Node0_12_5 6033333.333333334
R_0_11_5_3 Node0_11_5 Node1_11_5 22.24128
C_0_11_5 Node0_11_5 GND 4.09921875e-10
R_0_11_6_1 Node0_11_6 Node0_11_7 6033333.333333334
R_0_11_6_2 Node0_11_6 Node0_12_6 6033333.333333334
R_0_11_6_3 Node0_11_6 Node1_11_6 22.24128
C_0_11_6 Node0_11_6 GND 4.09921875e-10
R_0_11_7_1 Node0_11_7 Node0_11_8 6033333.333333334
R_0_11_7_2 Node0_11_7 Node0_12_7 6033333.333333334
R_0_11_7_3 Node0_11_7 Node1_11_7 22.24128
C_0_11_7 Node0_11_7 GND 4.09921875e-10
R_0_11_8_1 Node0_11_8 Node0_11_9 6033333.333333334
R_0_11_8_2 Node0_11_8 Node0_12_8 6033333.333333334
R_0_11_8_3 Node0_11_8 Node1_11_8 22.24128
C_0_11_8 Node0_11_8 GND 4.09921875e-10
R_0_11_9_1 Node0_11_9 Node0_11_10 6033333.333333334
R_0_11_9_2 Node0_11_9 Node0_12_9 6033333.333333334
R_0_11_9_3 Node0_11_9 Node1_11_9 22.24128
C_0_11_9 Node0_11_9 GND 4.09921875e-10
R_0_11_10_1 Node0_11_10 Node0_11_11 6033333.333333334
R_0_11_10_2 Node0_11_10 Node0_12_10 6033333.333333334
R_0_11_10_3 Node0_11_10 Node1_11_10 22.24128
C_0_11_10 Node0_11_10 GND 4.09921875e-10
R_0_11_11_1 Node0_11_11 Node0_11_12 6033333.333333334
R_0_11_11_2 Node0_11_11 Node0_12_11 6033333.333333334
R_0_11_11_3 Node0_11_11 Node1_11_11 22.24128
C_0_11_11 Node0_11_11 GND 4.09921875e-10
R_0_11_12_1 Node0_11_12 Node0_11_13 6033333.333333334
R_0_11_12_2 Node0_11_12 Node0_12_12 6033333.333333334
R_0_11_12_3 Node0_11_12 Node1_11_12 22.24128
C_0_11_12 Node0_11_12 GND 4.09921875e-10
R_0_11_13_1 Node0_11_13 Node0_11_14 6033333.333333334
R_0_11_13_2 Node0_11_13 Node0_12_13 6033333.333333334
R_0_11_13_3 Node0_11_13 Node1_11_13 22.24128
C_0_11_13 Node0_11_13 GND 4.09921875e-10
R_0_11_14_1 Node0_11_14 Node0_11_15 6033333.333333331
R_0_11_14_2 Node0_11_14 Node0_12_14 6033333.333333334
R_0_11_14_3 Node0_11_14 Node1_11_14 22.24128
C_0_11_14 Node0_11_14 GND 4.09921875e-10
R_0_11_15_2 Node0_11_15 Node0_12_15 6033333.333333328
R_0_11_15_3 Node0_11_15 Node1_11_15 22.24127999999998
C_0_11_15 Node0_11_15 GND 4.0992187500000036e-10
R_0_12_0_1 Node0_12_0 Node0_12_1 6033333.333333334
R_0_12_0_2 Node0_12_0 Node0_13_0 6033333.333333334
R_0_12_0_3 Node0_12_0 Node1_12_0 22.24128
C_0_12_0 Node0_12_0 GND 4.09921875e-10
R_0_12_1_1 Node0_12_1 Node0_12_2 6033333.333333334
R_0_12_1_2 Node0_12_1 Node0_13_1 6033333.333333334
R_0_12_1_3 Node0_12_1 Node1_12_1 22.24128
C_0_12_1 Node0_12_1 GND 4.09921875e-10
R_0_12_2_1 Node0_12_2 Node0_12_3 6033333.333333334
R_0_12_2_2 Node0_12_2 Node0_13_2 6033333.333333334
R_0_12_2_3 Node0_12_2 Node1_12_2 22.24128
C_0_12_2 Node0_12_2 GND 4.09921875e-10
R_0_12_3_1 Node0_12_3 Node0_12_4 6033333.333333334
R_0_12_3_2 Node0_12_3 Node0_13_3 6033333.333333334
R_0_12_3_3 Node0_12_3 Node1_12_3 22.24128
C_0_12_3 Node0_12_3 GND 4.09921875e-10
R_0_12_4_1 Node0_12_4 Node0_12_5 6033333.333333334
R_0_12_4_2 Node0_12_4 Node0_13_4 6033333.333333334
R_0_12_4_3 Node0_12_4 Node1_12_4 22.24128
C_0_12_4 Node0_12_4 GND 4.09921875e-10
R_0_12_5_1 Node0_12_5 Node0_12_6 6033333.333333334
R_0_12_5_2 Node0_12_5 Node0_13_5 6033333.333333334
R_0_12_5_3 Node0_12_5 Node1_12_5 22.24128
C_0_12_5 Node0_12_5 GND 4.09921875e-10
R_0_12_6_1 Node0_12_6 Node0_12_7 6033333.333333334
R_0_12_6_2 Node0_12_6 Node0_13_6 6033333.333333334
R_0_12_6_3 Node0_12_6 Node1_12_6 22.24128
C_0_12_6 Node0_12_6 GND 4.09921875e-10
R_0_12_7_1 Node0_12_7 Node0_12_8 6033333.333333334
R_0_12_7_2 Node0_12_7 Node0_13_7 6033333.333333334
R_0_12_7_3 Node0_12_7 Node1_12_7 22.24128
C_0_12_7 Node0_12_7 GND 4.09921875e-10
R_0_12_8_1 Node0_12_8 Node0_12_9 6033333.333333334
R_0_12_8_2 Node0_12_8 Node0_13_8 6033333.333333334
R_0_12_8_3 Node0_12_8 Node1_12_8 22.24128
C_0_12_8 Node0_12_8 GND 4.09921875e-10
R_0_12_9_1 Node0_12_9 Node0_12_10 6033333.333333334
R_0_12_9_2 Node0_12_9 Node0_13_9 6033333.333333334
R_0_12_9_3 Node0_12_9 Node1_12_9 22.24128
C_0_12_9 Node0_12_9 GND 4.09921875e-10
R_0_12_10_1 Node0_12_10 Node0_12_11 6033333.333333334
R_0_12_10_2 Node0_12_10 Node0_13_10 6033333.333333334
R_0_12_10_3 Node0_12_10 Node1_12_10 22.24128
C_0_12_10 Node0_12_10 GND 4.09921875e-10
R_0_12_11_1 Node0_12_11 Node0_12_12 6033333.333333334
R_0_12_11_2 Node0_12_11 Node0_13_11 6033333.333333334
R_0_12_11_3 Node0_12_11 Node1_12_11 22.24128
C_0_12_11 Node0_12_11 GND 4.09921875e-10
R_0_12_12_1 Node0_12_12 Node0_12_13 6033333.333333334
R_0_12_12_2 Node0_12_12 Node0_13_12 6033333.333333334
R_0_12_12_3 Node0_12_12 Node1_12_12 22.24128
C_0_12_12 Node0_12_12 GND 4.09921875e-10
R_0_12_13_1 Node0_12_13 Node0_12_14 6033333.333333334
R_0_12_13_2 Node0_12_13 Node0_13_13 6033333.333333334
R_0_12_13_3 Node0_12_13 Node1_12_13 22.24128
C_0_12_13 Node0_12_13 GND 4.09921875e-10
R_0_12_14_1 Node0_12_14 Node0_12_15 6033333.333333331
R_0_12_14_2 Node0_12_14 Node0_13_14 6033333.333333334
R_0_12_14_3 Node0_12_14 Node1_12_14 22.24128
C_0_12_14 Node0_12_14 GND 4.09921875e-10
R_0_12_15_2 Node0_12_15 Node0_13_15 6033333.333333328
R_0_12_15_3 Node0_12_15 Node1_12_15 22.24127999999998
C_0_12_15 Node0_12_15 GND 4.0992187500000036e-10
R_0_13_0_1 Node0_13_0 Node0_13_1 6033333.333333334
R_0_13_0_2 Node0_13_0 Node0_14_0 6033333.333333334
R_0_13_0_3 Node0_13_0 Node1_13_0 22.24128
C_0_13_0 Node0_13_0 GND 4.09921875e-10
R_0_13_1_1 Node0_13_1 Node0_13_2 6033333.333333334
R_0_13_1_2 Node0_13_1 Node0_14_1 6033333.333333334
R_0_13_1_3 Node0_13_1 Node1_13_1 22.24128
C_0_13_1 Node0_13_1 GND 4.09921875e-10
R_0_13_2_1 Node0_13_2 Node0_13_3 6033333.333333334
R_0_13_2_2 Node0_13_2 Node0_14_2 6033333.333333334
R_0_13_2_3 Node0_13_2 Node1_13_2 22.24128
C_0_13_2 Node0_13_2 GND 4.09921875e-10
R_0_13_3_1 Node0_13_3 Node0_13_4 6033333.333333334
R_0_13_3_2 Node0_13_3 Node0_14_3 6033333.333333334
R_0_13_3_3 Node0_13_3 Node1_13_3 22.24128
C_0_13_3 Node0_13_3 GND 4.09921875e-10
R_0_13_4_1 Node0_13_4 Node0_13_5 6033333.333333334
R_0_13_4_2 Node0_13_4 Node0_14_4 6033333.333333334
R_0_13_4_3 Node0_13_4 Node1_13_4 22.24128
C_0_13_4 Node0_13_4 GND 4.09921875e-10
R_0_13_5_1 Node0_13_5 Node0_13_6 6033333.333333334
R_0_13_5_2 Node0_13_5 Node0_14_5 6033333.333333334
R_0_13_5_3 Node0_13_5 Node1_13_5 22.24128
C_0_13_5 Node0_13_5 GND 4.09921875e-10
R_0_13_6_1 Node0_13_6 Node0_13_7 6033333.333333334
R_0_13_6_2 Node0_13_6 Node0_14_6 6033333.333333334
R_0_13_6_3 Node0_13_6 Node1_13_6 22.24128
C_0_13_6 Node0_13_6 GND 4.09921875e-10
R_0_13_7_1 Node0_13_7 Node0_13_8 6033333.333333334
R_0_13_7_2 Node0_13_7 Node0_14_7 6033333.333333334
R_0_13_7_3 Node0_13_7 Node1_13_7 22.24128
C_0_13_7 Node0_13_7 GND 4.09921875e-10
R_0_13_8_1 Node0_13_8 Node0_13_9 6033333.333333334
R_0_13_8_2 Node0_13_8 Node0_14_8 6033333.333333334
R_0_13_8_3 Node0_13_8 Node1_13_8 22.24128
C_0_13_8 Node0_13_8 GND 4.09921875e-10
R_0_13_9_1 Node0_13_9 Node0_13_10 6033333.333333334
R_0_13_9_2 Node0_13_9 Node0_14_9 6033333.333333334
R_0_13_9_3 Node0_13_9 Node1_13_9 22.24128
C_0_13_9 Node0_13_9 GND 4.09921875e-10
R_0_13_10_1 Node0_13_10 Node0_13_11 6033333.333333334
R_0_13_10_2 Node0_13_10 Node0_14_10 6033333.333333334
R_0_13_10_3 Node0_13_10 Node1_13_10 22.24128
C_0_13_10 Node0_13_10 GND 4.09921875e-10
R_0_13_11_1 Node0_13_11 Node0_13_12 6033333.333333334
R_0_13_11_2 Node0_13_11 Node0_14_11 6033333.333333334
R_0_13_11_3 Node0_13_11 Node1_13_11 22.24128
C_0_13_11 Node0_13_11 GND 4.09921875e-10
R_0_13_12_1 Node0_13_12 Node0_13_13 6033333.333333334
R_0_13_12_2 Node0_13_12 Node0_14_12 6033333.333333334
R_0_13_12_3 Node0_13_12 Node1_13_12 22.24128
C_0_13_12 Node0_13_12 GND 4.09921875e-10
R_0_13_13_1 Node0_13_13 Node0_13_14 6033333.333333334
R_0_13_13_2 Node0_13_13 Node0_14_13 6033333.333333334
R_0_13_13_3 Node0_13_13 Node1_13_13 22.24128
C_0_13_13 Node0_13_13 GND 4.09921875e-10
R_0_13_14_1 Node0_13_14 Node0_13_15 6033333.333333331
R_0_13_14_2 Node0_13_14 Node0_14_14 6033333.333333334
R_0_13_14_3 Node0_13_14 Node1_13_14 22.24128
C_0_13_14 Node0_13_14 GND 4.09921875e-10
R_0_13_15_2 Node0_13_15 Node0_14_15 6033333.333333328
R_0_13_15_3 Node0_13_15 Node1_13_15 22.24127999999998
C_0_13_15 Node0_13_15 GND 4.0992187500000036e-10
R_0_14_0_1 Node0_14_0 Node0_14_1 6033333.333333334
R_0_14_0_2 Node0_14_0 Node0_15_0 6033333.333333334
R_0_14_0_3 Node0_14_0 Node1_14_0 22.24128
C_0_14_0 Node0_14_0 GND 4.09921875e-10
R_0_14_1_1 Node0_14_1 Node0_14_2 6033333.333333334
R_0_14_1_2 Node0_14_1 Node0_15_1 6033333.333333334
R_0_14_1_3 Node0_14_1 Node1_14_1 22.24128
C_0_14_1 Node0_14_1 GND 4.09921875e-10
R_0_14_2_1 Node0_14_2 Node0_14_3 6033333.333333334
R_0_14_2_2 Node0_14_2 Node0_15_2 6033333.333333334
R_0_14_2_3 Node0_14_2 Node1_14_2 22.24128
C_0_14_2 Node0_14_2 GND 4.09921875e-10
R_0_14_3_1 Node0_14_3 Node0_14_4 6033333.333333334
R_0_14_3_2 Node0_14_3 Node0_15_3 6033333.333333334
R_0_14_3_3 Node0_14_3 Node1_14_3 22.24128
C_0_14_3 Node0_14_3 GND 4.09921875e-10
R_0_14_4_1 Node0_14_4 Node0_14_5 6033333.333333334
R_0_14_4_2 Node0_14_4 Node0_15_4 6033333.333333334
R_0_14_4_3 Node0_14_4 Node1_14_4 22.24128
C_0_14_4 Node0_14_4 GND 4.09921875e-10
R_0_14_5_1 Node0_14_5 Node0_14_6 6033333.333333334
R_0_14_5_2 Node0_14_5 Node0_15_5 6033333.333333334
R_0_14_5_3 Node0_14_5 Node1_14_5 22.24128
C_0_14_5 Node0_14_5 GND 4.09921875e-10
R_0_14_6_1 Node0_14_6 Node0_14_7 6033333.333333334
R_0_14_6_2 Node0_14_6 Node0_15_6 6033333.333333334
R_0_14_6_3 Node0_14_6 Node1_14_6 22.24128
C_0_14_6 Node0_14_6 GND 4.09921875e-10
R_0_14_7_1 Node0_14_7 Node0_14_8 6033333.333333334
R_0_14_7_2 Node0_14_7 Node0_15_7 6033333.333333334
R_0_14_7_3 Node0_14_7 Node1_14_7 22.24128
C_0_14_7 Node0_14_7 GND 4.09921875e-10
R_0_14_8_1 Node0_14_8 Node0_14_9 6033333.333333334
R_0_14_8_2 Node0_14_8 Node0_15_8 6033333.333333334
R_0_14_8_3 Node0_14_8 Node1_14_8 22.24128
C_0_14_8 Node0_14_8 GND 4.09921875e-10
R_0_14_9_1 Node0_14_9 Node0_14_10 6033333.333333334
R_0_14_9_2 Node0_14_9 Node0_15_9 6033333.333333334
R_0_14_9_3 Node0_14_9 Node1_14_9 22.24128
C_0_14_9 Node0_14_9 GND 4.09921875e-10
R_0_14_10_1 Node0_14_10 Node0_14_11 6033333.333333334
R_0_14_10_2 Node0_14_10 Node0_15_10 6033333.333333334
R_0_14_10_3 Node0_14_10 Node1_14_10 22.24128
C_0_14_10 Node0_14_10 GND 4.09921875e-10
R_0_14_11_1 Node0_14_11 Node0_14_12 6033333.333333334
R_0_14_11_2 Node0_14_11 Node0_15_11 6033333.333333334
R_0_14_11_3 Node0_14_11 Node1_14_11 22.24128
C_0_14_11 Node0_14_11 GND 4.09921875e-10
R_0_14_12_1 Node0_14_12 Node0_14_13 6033333.333333334
R_0_14_12_2 Node0_14_12 Node0_15_12 6033333.333333334
R_0_14_12_3 Node0_14_12 Node1_14_12 22.24128
C_0_14_12 Node0_14_12 GND 4.09921875e-10
R_0_14_13_1 Node0_14_13 Node0_14_14 6033333.333333334
R_0_14_13_2 Node0_14_13 Node0_15_13 6033333.333333334
R_0_14_13_3 Node0_14_13 Node1_14_13 22.24128
C_0_14_13 Node0_14_13 GND 4.09921875e-10
R_0_14_14_1 Node0_14_14 Node0_14_15 6033333.333333331
R_0_14_14_2 Node0_14_14 Node0_15_14 6033333.333333334
R_0_14_14_3 Node0_14_14 Node1_14_14 22.24128
C_0_14_14 Node0_14_14 GND 4.09921875e-10
R_0_14_15_2 Node0_14_15 Node0_15_15 6033333.333333328
R_0_14_15_3 Node0_14_15 Node1_14_15 22.24127999999998
C_0_14_15 Node0_14_15 GND 4.0992187500000036e-10
R_0_15_0_1 Node0_15_0 Node0_15_1 6033333.333333334
R_0_15_0_3 Node0_15_0 Node1_15_0 22.24128
C_0_15_0 Node0_15_0 GND 4.09921875e-10
R_0_15_1_1 Node0_15_1 Node0_15_2 6033333.333333334
R_0_15_1_3 Node0_15_1 Node1_15_1 22.24128
C_0_15_1 Node0_15_1 GND 4.09921875e-10
R_0_15_2_1 Node0_15_2 Node0_15_3 6033333.333333334
R_0_15_2_3 Node0_15_2 Node1_15_2 22.24128
C_0_15_2 Node0_15_2 GND 4.09921875e-10
R_0_15_3_1 Node0_15_3 Node0_15_4 6033333.333333334
R_0_15_3_3 Node0_15_3 Node1_15_3 22.24128
C_0_15_3 Node0_15_3 GND 4.09921875e-10
R_0_15_4_1 Node0_15_4 Node0_15_5 6033333.333333334
R_0_15_4_3 Node0_15_4 Node1_15_4 22.24128
C_0_15_4 Node0_15_4 GND 4.09921875e-10
R_0_15_5_1 Node0_15_5 Node0_15_6 6033333.333333334
R_0_15_5_3 Node0_15_5 Node1_15_5 22.24128
C_0_15_5 Node0_15_5 GND 4.09921875e-10
R_0_15_6_1 Node0_15_6 Node0_15_7 6033333.333333334
R_0_15_6_3 Node0_15_6 Node1_15_6 22.24128
C_0_15_6 Node0_15_6 GND 4.09921875e-10
R_0_15_7_1 Node0_15_7 Node0_15_8 6033333.333333334
R_0_15_7_3 Node0_15_7 Node1_15_7 22.24128
C_0_15_7 Node0_15_7 GND 4.09921875e-10
R_0_15_8_1 Node0_15_8 Node0_15_9 6033333.333333334
R_0_15_8_3 Node0_15_8 Node1_15_8 22.24128
C_0_15_8 Node0_15_8 GND 4.09921875e-10
R_0_15_9_1 Node0_15_9 Node0_15_10 6033333.333333334
R_0_15_9_3 Node0_15_9 Node1_15_9 22.24128
C_0_15_9 Node0_15_9 GND 4.09921875e-10
R_0_15_10_1 Node0_15_10 Node0_15_11 6033333.333333334
R_0_15_10_3 Node0_15_10 Node1_15_10 22.24128
C_0_15_10 Node0_15_10 GND 4.09921875e-10
R_0_15_11_1 Node0_15_11 Node0_15_12 6033333.333333334
R_0_15_11_3 Node0_15_11 Node1_15_11 22.24128
C_0_15_11 Node0_15_11 GND 4.09921875e-10
R_0_15_12_1 Node0_15_12 Node0_15_13 6033333.333333334
R_0_15_12_3 Node0_15_12 Node1_15_12 22.24128
C_0_15_12 Node0_15_12 GND 4.09921875e-10
R_0_15_13_1 Node0_15_13 Node0_15_14 6033333.333333334
R_0_15_13_3 Node0_15_13 Node1_15_13 22.24128
C_0_15_13 Node0_15_13 GND 4.09921875e-10
R_0_15_14_1 Node0_15_14 Node0_15_15 6033333.33333333
R_0_15_14_3 Node0_15_14 Node1_15_14 22.24128
C_0_15_14 Node0_15_14 GND 4.09921875e-10
R_0_15_15_3 Node0_15_15 Node1_15_15 22.241279999999975
C_0_15_15 Node0_15_15 GND 4.0992187500000046e-10
R_1_0_0_1 Node1_0_0 Node1_0_1 1407692.307692309
R_1_0_0_2 Node1_0_0 Node1_1_0 1407692.3076923084
R_1_0_0_3 Node1_0_0 Node2_0_0 6.090240000000006
C_1_0_0 Node1_0_0 GND 5.657437499999995e-16
R_1_0_1_1 Node1_0_1 Node1_0_2 1407692.307692309
R_1_0_1_2 Node1_0_1 Node1_1_1 1407692.3076923084
R_1_0_1_3 Node1_0_1 Node2_0_1 6.090240000000006
C_1_0_1 Node1_0_1 GND 5.657437499999995e-16
R_1_0_2_1 Node1_0_2 Node1_0_3 1407692.307692309
R_1_0_2_2 Node1_0_2 Node1_1_2 1407692.3076923084
R_1_0_2_3 Node1_0_2 Node2_0_2 6.090240000000006
C_1_0_2 Node1_0_2 GND 5.657437499999995e-16
R_1_0_3_1 Node1_0_3 Node1_0_4 1407692.307692309
R_1_0_3_2 Node1_0_3 Node1_1_3 1407692.3076923084
R_1_0_3_3 Node1_0_3 Node2_0_3 6.090240000000006
C_1_0_3 Node1_0_3 GND 5.657437499999995e-16
R_1_0_4_1 Node1_0_4 Node1_0_5 1407692.307692309
R_1_0_4_2 Node1_0_4 Node1_1_4 1407692.3076923084
R_1_0_4_3 Node1_0_4 Node2_0_4 6.090240000000006
C_1_0_4 Node1_0_4 GND 5.657437499999995e-16
R_1_0_5_1 Node1_0_5 Node1_0_6 1407692.307692309
R_1_0_5_2 Node1_0_5 Node1_1_5 1407692.3076923084
R_1_0_5_3 Node1_0_5 Node2_0_5 6.090240000000006
C_1_0_5 Node1_0_5 GND 5.657437499999995e-16
R_1_0_6_1 Node1_0_6 Node1_0_7 1407692.307692309
R_1_0_6_2 Node1_0_6 Node1_1_6 1407692.3076923084
R_1_0_6_3 Node1_0_6 Node2_0_6 6.090240000000006
C_1_0_6 Node1_0_6 GND 5.657437499999995e-16
R_1_0_7_1 Node1_0_7 Node1_0_8 1407692.307692309
R_1_0_7_2 Node1_0_7 Node1_1_7 1407692.3076923084
R_1_0_7_3 Node1_0_7 Node2_0_7 6.090240000000006
C_1_0_7 Node1_0_7 GND 5.657437499999995e-16
R_1_0_8_1 Node1_0_8 Node1_0_9 1407692.307692309
R_1_0_8_2 Node1_0_8 Node1_1_8 1407692.3076923084
R_1_0_8_3 Node1_0_8 Node2_0_8 6.090240000000006
C_1_0_8 Node1_0_8 GND 5.657437499999995e-16
R_1_0_9_1 Node1_0_9 Node1_0_10 1407692.307692309
R_1_0_9_2 Node1_0_9 Node1_1_9 1407692.3076923084
R_1_0_9_3 Node1_0_9 Node2_0_9 6.090240000000006
C_1_0_9 Node1_0_9 GND 5.657437499999995e-16
R_1_0_10_1 Node1_0_10 Node1_0_11 1407692.307692309
R_1_0_10_2 Node1_0_10 Node1_1_10 1407692.3076923084
R_1_0_10_3 Node1_0_10 Node2_0_10 6.090240000000006
C_1_0_10 Node1_0_10 GND 5.657437499999995e-16
R_1_0_11_1 Node1_0_11 Node1_0_12 1407692.307692309
R_1_0_11_2 Node1_0_11 Node1_1_11 1407692.3076923084
R_1_0_11_3 Node1_0_11 Node2_0_11 6.090240000000006
C_1_0_11 Node1_0_11 GND 5.657437499999995e-16
R_1_0_12_1 Node1_0_12 Node1_0_13 1407692.307692309
R_1_0_12_2 Node1_0_12 Node1_1_12 1407692.3076923084
R_1_0_12_3 Node1_0_12 Node2_0_12 6.090240000000006
C_1_0_12 Node1_0_12 GND 5.657437499999995e-16
R_1_0_13_1 Node1_0_13 Node1_0_14 1407692.307692309
R_1_0_13_2 Node1_0_13 Node1_1_13 1407692.3076923084
R_1_0_13_3 Node1_0_13 Node2_0_13 6.090240000000006
C_1_0_13 Node1_0_13 GND 5.657437499999995e-16
R_1_0_14_1 Node1_0_14 Node1_0_15 1407692.3076923084
R_1_0_14_2 Node1_0_14 Node1_1_14 1407692.3076923084
R_1_0_14_3 Node1_0_14 Node2_0_14 6.090240000000006
C_1_0_14 Node1_0_14 GND 5.657437499999995e-16
R_1_0_15_2 Node1_0_15 Node1_1_15 1407692.307692307
R_1_0_15_3 Node1_0_15 Node2_0_15 6.0902400000000005
C_1_0_15 Node1_0_15 GND 5.6574375e-16
R_1_1_0_1 Node1_1_0 Node1_1_1 1407692.3076923077
R_1_1_0_2 Node1_1_0 Node1_2_0 1407692.3076923077
R_1_1_0_3 Node1_1_0 Node2_1_0 6.0902400000000005
C_1_1_0 Node1_1_0 GND 5.6574375e-16
R_1_1_1_1 Node1_1_1 Node1_1_2 1407692.3076923077
R_1_1_1_2 Node1_1_1 Node1_2_1 1407692.3076923077
R_1_1_1_3 Node1_1_1 Node2_1_1 6.0902400000000005
C_1_1_1 Node1_1_1 GND 5.6574375e-16
R_1_1_2_1 Node1_1_2 Node1_1_3 1407692.3076923077
R_1_1_2_2 Node1_1_2 Node1_2_2 1407692.3076923077
R_1_1_2_3 Node1_1_2 Node2_1_2 6.0902400000000005
C_1_1_2 Node1_1_2 GND 5.6574375e-16
R_1_1_3_1 Node1_1_3 Node1_1_4 1407692.3076923077
R_1_1_3_2 Node1_1_3 Node1_2_3 1407692.3076923077
R_1_1_3_3 Node1_1_3 Node2_1_3 6.0902400000000005
C_1_1_3 Node1_1_3 GND 5.6574375e-16
R_1_1_4_1 Node1_1_4 Node1_1_5 1407692.3076923077
R_1_1_4_2 Node1_1_4 Node1_2_4 1407692.3076923077
R_1_1_4_3 Node1_1_4 Node2_1_4 6.0902400000000005
C_1_1_4 Node1_1_4 GND 5.6574375e-16
R_1_1_5_1 Node1_1_5 Node1_1_6 1407692.3076923077
R_1_1_5_2 Node1_1_5 Node1_2_5 1407692.3076923077
R_1_1_5_3 Node1_1_5 Node2_1_5 6.0902400000000005
C_1_1_5 Node1_1_5 GND 5.6574375e-16
R_1_1_6_1 Node1_1_6 Node1_1_7 1407692.3076923077
R_1_1_6_2 Node1_1_6 Node1_2_6 1407692.3076923077
R_1_1_6_3 Node1_1_6 Node2_1_6 6.0902400000000005
C_1_1_6 Node1_1_6 GND 5.6574375e-16
R_1_1_7_1 Node1_1_7 Node1_1_8 1407692.3076923077
R_1_1_7_2 Node1_1_7 Node1_2_7 1407692.3076923077
R_1_1_7_3 Node1_1_7 Node2_1_7 6.0902400000000005
C_1_1_7 Node1_1_7 GND 5.6574375e-16
R_1_1_8_1 Node1_1_8 Node1_1_9 1407692.3076923077
R_1_1_8_2 Node1_1_8 Node1_2_8 1407692.3076923077
R_1_1_8_3 Node1_1_8 Node2_1_8 6.0902400000000005
C_1_1_8 Node1_1_8 GND 5.6574375e-16
R_1_1_9_1 Node1_1_9 Node1_1_10 1407692.3076923077
R_1_1_9_2 Node1_1_9 Node1_2_9 1407692.3076923077
R_1_1_9_3 Node1_1_9 Node2_1_9 6.0902400000000005
C_1_1_9 Node1_1_9 GND 5.6574375e-16
R_1_1_10_1 Node1_1_10 Node1_1_11 1407692.3076923077
R_1_1_10_2 Node1_1_10 Node1_2_10 1407692.3076923077
R_1_1_10_3 Node1_1_10 Node2_1_10 6.0902400000000005
C_1_1_10 Node1_1_10 GND 5.6574375e-16
R_1_1_11_1 Node1_1_11 Node1_1_12 1407692.3076923077
R_1_1_11_2 Node1_1_11 Node1_2_11 1407692.3076923077
R_1_1_11_3 Node1_1_11 Node2_1_11 6.0902400000000005
C_1_1_11 Node1_1_11 GND 5.6574375e-16
R_1_1_12_1 Node1_1_12 Node1_1_13 1407692.3076923077
R_1_1_12_2 Node1_1_12 Node1_2_12 1407692.3076923077
R_1_1_12_3 Node1_1_12 Node2_1_12 6.0902400000000005
C_1_1_12 Node1_1_12 GND 5.6574375e-16
R_1_1_13_1 Node1_1_13 Node1_1_14 1407692.3076923077
R_1_1_13_2 Node1_1_13 Node1_2_13 1407692.3076923077
R_1_1_13_3 Node1_1_13 Node2_1_13 6.0902400000000005
C_1_1_13 Node1_1_13 GND 5.6574375e-16
R_1_1_14_1 Node1_1_14 Node1_1_15 1407692.307692307
R_1_1_14_2 Node1_1_14 Node1_2_14 1407692.3076923077
R_1_1_14_3 Node1_1_14 Node2_1_14 6.0902400000000005
C_1_1_14 Node1_1_14 GND 5.6574375e-16
R_1_1_15_2 Node1_1_15 Node1_2_15 1407692.3076923063
R_1_1_15_3 Node1_1_15 Node2_1_15 6.090239999999995
C_1_1_15 Node1_1_15 GND 5.657437500000005e-16
R_1_2_0_1 Node1_2_0 Node1_2_1 1407692.3076923077
R_1_2_0_2 Node1_2_0 Node1_3_0 1407692.3076923077
R_1_2_0_3 Node1_2_0 Node2_2_0 6.0902400000000005
C_1_2_0 Node1_2_0 GND 5.6574375e-16
R_1_2_1_1 Node1_2_1 Node1_2_2 1407692.3076923077
R_1_2_1_2 Node1_2_1 Node1_3_1 1407692.3076923077
R_1_2_1_3 Node1_2_1 Node2_2_1 6.0902400000000005
C_1_2_1 Node1_2_1 GND 5.6574375e-16
R_1_2_2_1 Node1_2_2 Node1_2_3 1407692.3076923077
R_1_2_2_2 Node1_2_2 Node1_3_2 1407692.3076923077
R_1_2_2_3 Node1_2_2 Node2_2_2 6.0902400000000005
C_1_2_2 Node1_2_2 GND 5.6574375e-16
R_1_2_3_1 Node1_2_3 Node1_2_4 1407692.3076923077
R_1_2_3_2 Node1_2_3 Node1_3_3 1407692.3076923077
R_1_2_3_3 Node1_2_3 Node2_2_3 6.0902400000000005
C_1_2_3 Node1_2_3 GND 5.6574375e-16
R_1_2_4_1 Node1_2_4 Node1_2_5 1407692.3076923077
R_1_2_4_2 Node1_2_4 Node1_3_4 1407692.3076923077
R_1_2_4_3 Node1_2_4 Node2_2_4 6.0902400000000005
C_1_2_4 Node1_2_4 GND 5.6574375e-16
R_1_2_5_1 Node1_2_5 Node1_2_6 1407692.3076923077
R_1_2_5_2 Node1_2_5 Node1_3_5 1407692.3076923077
R_1_2_5_3 Node1_2_5 Node2_2_5 6.0902400000000005
C_1_2_5 Node1_2_5 GND 5.6574375e-16
R_1_2_6_1 Node1_2_6 Node1_2_7 1407692.3076923077
R_1_2_6_2 Node1_2_6 Node1_3_6 1407692.3076923077
R_1_2_6_3 Node1_2_6 Node2_2_6 6.0902400000000005
C_1_2_6 Node1_2_6 GND 5.6574375e-16
R_1_2_7_1 Node1_2_7 Node1_2_8 1407692.3076923077
R_1_2_7_2 Node1_2_7 Node1_3_7 1407692.3076923077
R_1_2_7_3 Node1_2_7 Node2_2_7 6.0902400000000005
C_1_2_7 Node1_2_7 GND 5.6574375e-16
R_1_2_8_1 Node1_2_8 Node1_2_9 1407692.3076923077
R_1_2_8_2 Node1_2_8 Node1_3_8 1407692.3076923077
R_1_2_8_3 Node1_2_8 Node2_2_8 6.0902400000000005
C_1_2_8 Node1_2_8 GND 5.6574375e-16
R_1_2_9_1 Node1_2_9 Node1_2_10 1407692.3076923077
R_1_2_9_2 Node1_2_9 Node1_3_9 1407692.3076923077
R_1_2_9_3 Node1_2_9 Node2_2_9 6.0902400000000005
C_1_2_9 Node1_2_9 GND 5.6574375e-16
R_1_2_10_1 Node1_2_10 Node1_2_11 1407692.3076923077
R_1_2_10_2 Node1_2_10 Node1_3_10 1407692.3076923077
R_1_2_10_3 Node1_2_10 Node2_2_10 6.0902400000000005
C_1_2_10 Node1_2_10 GND 5.6574375e-16
R_1_2_11_1 Node1_2_11 Node1_2_12 1407692.3076923077
R_1_2_11_2 Node1_2_11 Node1_3_11 1407692.3076923077
R_1_2_11_3 Node1_2_11 Node2_2_11 6.0902400000000005
C_1_2_11 Node1_2_11 GND 5.6574375e-16
R_1_2_12_1 Node1_2_12 Node1_2_13 1407692.3076923077
R_1_2_12_2 Node1_2_12 Node1_3_12 1407692.3076923077
R_1_2_12_3 Node1_2_12 Node2_2_12 6.0902400000000005
C_1_2_12 Node1_2_12 GND 5.6574375e-16
R_1_2_13_1 Node1_2_13 Node1_2_14 1407692.3076923077
R_1_2_13_2 Node1_2_13 Node1_3_13 1407692.3076923077
R_1_2_13_3 Node1_2_13 Node2_2_13 6.0902400000000005
C_1_2_13 Node1_2_13 GND 5.6574375e-16
R_1_2_14_1 Node1_2_14 Node1_2_15 1407692.307692307
R_1_2_14_2 Node1_2_14 Node1_3_14 1407692.3076923077
R_1_2_14_3 Node1_2_14 Node2_2_14 6.0902400000000005
C_1_2_14 Node1_2_14 GND 5.6574375e-16
R_1_2_15_2 Node1_2_15 Node1_3_15 1407692.3076923063
R_1_2_15_3 Node1_2_15 Node2_2_15 6.090239999999995
C_1_2_15 Node1_2_15 GND 5.657437500000005e-16
R_1_3_0_1 Node1_3_0 Node1_3_1 1407692.3076923077
R_1_3_0_2 Node1_3_0 Node1_4_0 1407692.3076923077
R_1_3_0_3 Node1_3_0 Node2_3_0 6.0902400000000005
C_1_3_0 Node1_3_0 GND 5.6574375e-16
R_1_3_1_1 Node1_3_1 Node1_3_2 1407692.3076923077
R_1_3_1_2 Node1_3_1 Node1_4_1 1407692.3076923077
R_1_3_1_3 Node1_3_1 Node2_3_1 6.0902400000000005
C_1_3_1 Node1_3_1 GND 5.6574375e-16
R_1_3_2_1 Node1_3_2 Node1_3_3 1407692.3076923077
R_1_3_2_2 Node1_3_2 Node1_4_2 1407692.3076923077
R_1_3_2_3 Node1_3_2 Node2_3_2 6.0902400000000005
C_1_3_2 Node1_3_2 GND 5.6574375e-16
R_1_3_3_1 Node1_3_3 Node1_3_4 1407692.3076923077
R_1_3_3_2 Node1_3_3 Node1_4_3 1407692.3076923077
R_1_3_3_3 Node1_3_3 Node2_3_3 6.0902400000000005
C_1_3_3 Node1_3_3 GND 5.6574375e-16
R_1_3_4_1 Node1_3_4 Node1_3_5 1407692.3076923077
R_1_3_4_2 Node1_3_4 Node1_4_4 1407692.3076923077
R_1_3_4_3 Node1_3_4 Node2_3_4 6.0902400000000005
C_1_3_4 Node1_3_4 GND 5.6574375e-16
R_1_3_5_1 Node1_3_5 Node1_3_6 1407692.3076923077
R_1_3_5_2 Node1_3_5 Node1_4_5 1407692.3076923077
R_1_3_5_3 Node1_3_5 Node2_3_5 6.0902400000000005
C_1_3_5 Node1_3_5 GND 5.6574375e-16
R_1_3_6_1 Node1_3_6 Node1_3_7 1407692.3076923077
R_1_3_6_2 Node1_3_6 Node1_4_6 1407692.3076923077
R_1_3_6_3 Node1_3_6 Node2_3_6 6.0902400000000005
C_1_3_6 Node1_3_6 GND 5.6574375e-16
R_1_3_7_1 Node1_3_7 Node1_3_8 1407692.3076923077
R_1_3_7_2 Node1_3_7 Node1_4_7 1407692.3076923077
R_1_3_7_3 Node1_3_7 Node2_3_7 6.0902400000000005
C_1_3_7 Node1_3_7 GND 5.6574375e-16
R_1_3_8_1 Node1_3_8 Node1_3_9 1407692.3076923077
R_1_3_8_2 Node1_3_8 Node1_4_8 1407692.3076923077
R_1_3_8_3 Node1_3_8 Node2_3_8 6.0902400000000005
C_1_3_8 Node1_3_8 GND 5.6574375e-16
R_1_3_9_1 Node1_3_9 Node1_3_10 1407692.3076923077
R_1_3_9_2 Node1_3_9 Node1_4_9 1407692.3076923077
R_1_3_9_3 Node1_3_9 Node2_3_9 6.0902400000000005
C_1_3_9 Node1_3_9 GND 5.6574375e-16
R_1_3_10_1 Node1_3_10 Node1_3_11 1407692.3076923077
R_1_3_10_2 Node1_3_10 Node1_4_10 1407692.3076923077
R_1_3_10_3 Node1_3_10 Node2_3_10 6.0902400000000005
C_1_3_10 Node1_3_10 GND 5.6574375e-16
R_1_3_11_1 Node1_3_11 Node1_3_12 1407692.3076923077
R_1_3_11_2 Node1_3_11 Node1_4_11 1407692.3076923077
R_1_3_11_3 Node1_3_11 Node2_3_11 6.0902400000000005
C_1_3_11 Node1_3_11 GND 5.6574375e-16
R_1_3_12_1 Node1_3_12 Node1_3_13 1407692.3076923077
R_1_3_12_2 Node1_3_12 Node1_4_12 1407692.3076923077
R_1_3_12_3 Node1_3_12 Node2_3_12 6.0902400000000005
C_1_3_12 Node1_3_12 GND 5.6574375e-16
R_1_3_13_1 Node1_3_13 Node1_3_14 1407692.3076923077
R_1_3_13_2 Node1_3_13 Node1_4_13 1407692.3076923077
R_1_3_13_3 Node1_3_13 Node2_3_13 6.0902400000000005
C_1_3_13 Node1_3_13 GND 5.6574375e-16
R_1_3_14_1 Node1_3_14 Node1_3_15 1407692.307692307
R_1_3_14_2 Node1_3_14 Node1_4_14 1407692.3076923077
R_1_3_14_3 Node1_3_14 Node2_3_14 6.0902400000000005
C_1_3_14 Node1_3_14 GND 5.6574375e-16
R_1_3_15_2 Node1_3_15 Node1_4_15 1407692.3076923063
R_1_3_15_3 Node1_3_15 Node2_3_15 6.090239999999995
C_1_3_15 Node1_3_15 GND 5.657437500000005e-16
R_1_4_0_1 Node1_4_0 Node1_4_1 1407692.3076923077
R_1_4_0_2 Node1_4_0 Node1_5_0 1407692.3076923077
R_1_4_0_3 Node1_4_0 Node2_4_0 6.0902400000000005
C_1_4_0 Node1_4_0 GND 5.6574375e-16
R_1_4_1_1 Node1_4_1 Node1_4_2 1407692.3076923077
R_1_4_1_2 Node1_4_1 Node1_5_1 1407692.3076923077
R_1_4_1_3 Node1_4_1 Node2_4_1 6.0902400000000005
C_1_4_1 Node1_4_1 GND 5.6574375e-16
R_1_4_2_1 Node1_4_2 Node1_4_3 1407692.3076923077
R_1_4_2_2 Node1_4_2 Node1_5_2 1407692.3076923077
R_1_4_2_3 Node1_4_2 Node2_4_2 6.0902400000000005
C_1_4_2 Node1_4_2 GND 5.6574375e-16
R_1_4_3_1 Node1_4_3 Node1_4_4 1407692.3076923077
R_1_4_3_2 Node1_4_3 Node1_5_3 1407692.3076923077
R_1_4_3_3 Node1_4_3 Node2_4_3 6.0902400000000005
C_1_4_3 Node1_4_3 GND 5.6574375e-16
R_1_4_4_1 Node1_4_4 Node1_4_5 1407692.3076923077
R_1_4_4_2 Node1_4_4 Node1_5_4 1407692.3076923077
R_1_4_4_3 Node1_4_4 Node2_4_4 6.0902400000000005
C_1_4_4 Node1_4_4 GND 5.6574375e-16
R_1_4_5_1 Node1_4_5 Node1_4_6 1407692.3076923077
R_1_4_5_2 Node1_4_5 Node1_5_5 1407692.3076923077
R_1_4_5_3 Node1_4_5 Node2_4_5 6.0902400000000005
C_1_4_5 Node1_4_5 GND 5.6574375e-16
R_1_4_6_1 Node1_4_6 Node1_4_7 1407692.3076923077
R_1_4_6_2 Node1_4_6 Node1_5_6 1407692.3076923077
R_1_4_6_3 Node1_4_6 Node2_4_6 6.0902400000000005
C_1_4_6 Node1_4_6 GND 5.6574375e-16
R_1_4_7_1 Node1_4_7 Node1_4_8 1407692.3076923077
R_1_4_7_2 Node1_4_7 Node1_5_7 1407692.3076923077
R_1_4_7_3 Node1_4_7 Node2_4_7 6.0902400000000005
C_1_4_7 Node1_4_7 GND 5.6574375e-16
R_1_4_8_1 Node1_4_8 Node1_4_9 1407692.3076923077
R_1_4_8_2 Node1_4_8 Node1_5_8 1407692.3076923077
R_1_4_8_3 Node1_4_8 Node2_4_8 6.0902400000000005
C_1_4_8 Node1_4_8 GND 5.6574375e-16
R_1_4_9_1 Node1_4_9 Node1_4_10 1407692.3076923077
R_1_4_9_2 Node1_4_9 Node1_5_9 1407692.3076923077
R_1_4_9_3 Node1_4_9 Node2_4_9 6.0902400000000005
C_1_4_9 Node1_4_9 GND 5.6574375e-16
R_1_4_10_1 Node1_4_10 Node1_4_11 1407692.3076923077
R_1_4_10_2 Node1_4_10 Node1_5_10 1407692.3076923077
R_1_4_10_3 Node1_4_10 Node2_4_10 6.0902400000000005
C_1_4_10 Node1_4_10 GND 5.6574375e-16
R_1_4_11_1 Node1_4_11 Node1_4_12 1407692.3076923077
R_1_4_11_2 Node1_4_11 Node1_5_11 1407692.3076923077
R_1_4_11_3 Node1_4_11 Node2_4_11 6.0902400000000005
C_1_4_11 Node1_4_11 GND 5.6574375e-16
R_1_4_12_1 Node1_4_12 Node1_4_13 1407692.3076923077
R_1_4_12_2 Node1_4_12 Node1_5_12 1407692.3076923077
R_1_4_12_3 Node1_4_12 Node2_4_12 6.0902400000000005
C_1_4_12 Node1_4_12 GND 5.6574375e-16
R_1_4_13_1 Node1_4_13 Node1_4_14 1407692.3076923077
R_1_4_13_2 Node1_4_13 Node1_5_13 1407692.3076923077
R_1_4_13_3 Node1_4_13 Node2_4_13 6.0902400000000005
C_1_4_13 Node1_4_13 GND 5.6574375e-16
R_1_4_14_1 Node1_4_14 Node1_4_15 1407692.307692307
R_1_4_14_2 Node1_4_14 Node1_5_14 1407692.3076923077
R_1_4_14_3 Node1_4_14 Node2_4_14 6.0902400000000005
C_1_4_14 Node1_4_14 GND 5.6574375e-16
R_1_4_15_2 Node1_4_15 Node1_5_15 1407692.3076923063
R_1_4_15_3 Node1_4_15 Node2_4_15 6.090239999999995
C_1_4_15 Node1_4_15 GND 5.657437500000005e-16
R_1_5_0_1 Node1_5_0 Node1_5_1 1407692.3076923077
R_1_5_0_2 Node1_5_0 Node1_6_0 1407692.3076923077
R_1_5_0_3 Node1_5_0 Node2_5_0 6.0902400000000005
C_1_5_0 Node1_5_0 GND 5.6574375e-16
R_1_5_1_1 Node1_5_1 Node1_5_2 1407692.3076923077
R_1_5_1_2 Node1_5_1 Node1_6_1 1407692.3076923077
R_1_5_1_3 Node1_5_1 Node2_5_1 6.0902400000000005
C_1_5_1 Node1_5_1 GND 5.6574375e-16
R_1_5_2_1 Node1_5_2 Node1_5_3 1407692.3076923077
R_1_5_2_2 Node1_5_2 Node1_6_2 1407692.3076923077
R_1_5_2_3 Node1_5_2 Node2_5_2 6.0902400000000005
C_1_5_2 Node1_5_2 GND 5.6574375e-16
R_1_5_3_1 Node1_5_3 Node1_5_4 1407692.3076923077
R_1_5_3_2 Node1_5_3 Node1_6_3 1407692.3076923077
R_1_5_3_3 Node1_5_3 Node2_5_3 6.0902400000000005
C_1_5_3 Node1_5_3 GND 5.6574375e-16
R_1_5_4_1 Node1_5_4 Node1_5_5 1407692.3076923077
R_1_5_4_2 Node1_5_4 Node1_6_4 1407692.3076923077
R_1_5_4_3 Node1_5_4 Node2_5_4 6.0902400000000005
C_1_5_4 Node1_5_4 GND 5.6574375e-16
R_1_5_5_1 Node1_5_5 Node1_5_6 1407692.3076923077
R_1_5_5_2 Node1_5_5 Node1_6_5 1407692.3076923077
R_1_5_5_3 Node1_5_5 Node2_5_5 6.0902400000000005
C_1_5_5 Node1_5_5 GND 5.6574375e-16
R_1_5_6_1 Node1_5_6 Node1_5_7 1407692.3076923077
R_1_5_6_2 Node1_5_6 Node1_6_6 1407692.3076923077
R_1_5_6_3 Node1_5_6 Node2_5_6 6.0902400000000005
C_1_5_6 Node1_5_6 GND 5.6574375e-16
R_1_5_7_1 Node1_5_7 Node1_5_8 1407692.3076923077
R_1_5_7_2 Node1_5_7 Node1_6_7 1407692.3076923077
R_1_5_7_3 Node1_5_7 Node2_5_7 6.0902400000000005
C_1_5_7 Node1_5_7 GND 5.6574375e-16
R_1_5_8_1 Node1_5_8 Node1_5_9 1407692.3076923077
R_1_5_8_2 Node1_5_8 Node1_6_8 1407692.3076923077
R_1_5_8_3 Node1_5_8 Node2_5_8 6.0902400000000005
C_1_5_8 Node1_5_8 GND 5.6574375e-16
R_1_5_9_1 Node1_5_9 Node1_5_10 1407692.3076923077
R_1_5_9_2 Node1_5_9 Node1_6_9 1407692.3076923073
R_1_5_9_3 Node1_5_9 Node2_5_9 6.0902400000000005
C_1_5_9 Node1_5_9 GND 5.6574375e-16
R_1_5_10_1 Node1_5_10 Node1_5_11 1407692.3076923077
R_1_5_10_2 Node1_5_10 Node1_6_10 1407692.3076923077
R_1_5_10_3 Node1_5_10 Node2_5_10 6.0902400000000005
C_1_5_10 Node1_5_10 GND 5.6574375e-16
R_1_5_11_1 Node1_5_11 Node1_5_12 1407692.3076923077
R_1_5_11_2 Node1_5_11 Node1_6_11 1407692.3076923077
R_1_5_11_3 Node1_5_11 Node2_5_11 6.0902400000000005
C_1_5_11 Node1_5_11 GND 5.6574375e-16
R_1_5_12_1 Node1_5_12 Node1_5_13 1407692.3076923077
R_1_5_12_2 Node1_5_12 Node1_6_12 1407692.3076923077
R_1_5_12_3 Node1_5_12 Node2_5_12 6.0902400000000005
C_1_5_12 Node1_5_12 GND 5.6574375e-16
R_1_5_13_1 Node1_5_13 Node1_5_14 1407692.3076923077
R_1_5_13_2 Node1_5_13 Node1_6_13 1407692.3076923077
R_1_5_13_3 Node1_5_13 Node2_5_13 6.0902400000000005
C_1_5_13 Node1_5_13 GND 5.6574375e-16
R_1_5_14_1 Node1_5_14 Node1_5_15 1407692.307692307
R_1_5_14_2 Node1_5_14 Node1_6_14 1407692.3076923077
R_1_5_14_3 Node1_5_14 Node2_5_14 6.0902400000000005
C_1_5_14 Node1_5_14 GND 5.6574375e-16
R_1_5_15_2 Node1_5_15 Node1_6_15 1407692.3076923063
R_1_5_15_3 Node1_5_15 Node2_5_15 6.090239999999995
C_1_5_15 Node1_5_15 GND 5.657437500000005e-16
R_1_6_0_1 Node1_6_0 Node1_6_1 1407692.3076923077
R_1_6_0_2 Node1_6_0 Node1_7_0 1407692.3076923077
R_1_6_0_3 Node1_6_0 Node2_6_0 6.09024
C_1_6_0 Node1_6_0 GND 5.6574375e-16
R_1_6_1_1 Node1_6_1 Node1_6_2 1407692.3076923077
R_1_6_1_2 Node1_6_1 Node1_7_1 1407692.3076923077
R_1_6_1_3 Node1_6_1 Node2_6_1 6.0902400000000005
C_1_6_1 Node1_6_1 GND 5.6574375e-16
R_1_6_2_1 Node1_6_2 Node1_6_3 1407692.3076923077
R_1_6_2_2 Node1_6_2 Node1_7_2 1407692.3076923077
R_1_6_2_3 Node1_6_2 Node2_6_2 6.0902400000000005
C_1_6_2 Node1_6_2 GND 5.6574375e-16
R_1_6_3_1 Node1_6_3 Node1_6_4 1407692.3076923077
R_1_6_3_2 Node1_6_3 Node1_7_3 1407692.3076923077
R_1_6_3_3 Node1_6_3 Node2_6_3 6.0902400000000005
C_1_6_3 Node1_6_3 GND 5.6574375e-16
R_1_6_4_1 Node1_6_4 Node1_6_5 1407692.3076923077
R_1_6_4_2 Node1_6_4 Node1_7_4 1407692.3076923077
R_1_6_4_3 Node1_6_4 Node2_6_4 6.0902400000000005
C_1_6_4 Node1_6_4 GND 5.6574375e-16
R_1_6_5_1 Node1_6_5 Node1_6_6 1407692.3076923077
R_1_6_5_2 Node1_6_5 Node1_7_5 1407692.3076923077
R_1_6_5_3 Node1_6_5 Node2_6_5 6.0902400000000005
C_1_6_5 Node1_6_5 GND 5.6574375e-16
R_1_6_6_1 Node1_6_6 Node1_6_7 1407692.3076923077
R_1_6_6_2 Node1_6_6 Node1_7_6 1407692.3076923077
R_1_6_6_3 Node1_6_6 Node2_6_6 6.09024
C_1_6_6 Node1_6_6 GND 5.657437500000001e-16
R_1_6_7_1 Node1_6_7 Node1_6_8 1407692.3076923077
R_1_6_7_2 Node1_6_7 Node1_7_7 1407692.3076923077
R_1_6_7_3 Node1_6_7 Node2_6_7 6.0902400000000005
C_1_6_7 Node1_6_7 GND 5.6574375e-16
R_1_6_8_1 Node1_6_8 Node1_6_9 1407692.3076923073
R_1_6_8_2 Node1_6_8 Node1_7_8 1407692.3076923077
R_1_6_8_3 Node1_6_8 Node2_6_8 6.0902400000000005
C_1_6_8 Node1_6_8 GND 5.6574375e-16
R_1_6_9_1 Node1_6_9 Node1_6_10 1407692.3076923073
R_1_6_9_2 Node1_6_9 Node1_7_9 1407692.3076923066
R_1_6_9_3 Node1_6_9 Node2_6_9 6.090239999999998
C_1_6_9 Node1_6_9 GND 5.657437500000003e-16
R_1_6_10_1 Node1_6_10 Node1_6_11 1407692.3076923077
R_1_6_10_2 Node1_6_10 Node1_7_10 1407692.3076923077
R_1_6_10_3 Node1_6_10 Node2_6_10 6.0902400000000005
C_1_6_10 Node1_6_10 GND 5.6574375e-16
R_1_6_11_1 Node1_6_11 Node1_6_12 1407692.3076923077
R_1_6_11_2 Node1_6_11 Node1_7_11 1407692.3076923077
R_1_6_11_3 Node1_6_11 Node2_6_11 6.0902400000000005
C_1_6_11 Node1_6_11 GND 5.6574375e-16
R_1_6_12_1 Node1_6_12 Node1_6_13 1407692.3076923077
R_1_6_12_2 Node1_6_12 Node1_7_12 1407692.3076923077
R_1_6_12_3 Node1_6_12 Node2_6_12 6.0902400000000005
C_1_6_12 Node1_6_12 GND 5.6574375e-16
R_1_6_13_1 Node1_6_13 Node1_6_14 1407692.3076923077
R_1_6_13_2 Node1_6_13 Node1_7_13 1407692.3076923077
R_1_6_13_3 Node1_6_13 Node2_6_13 6.0902400000000005
C_1_6_13 Node1_6_13 GND 5.6574375e-16
R_1_6_14_1 Node1_6_14 Node1_6_15 1407692.307692307
R_1_6_14_2 Node1_6_14 Node1_7_14 1407692.3076923077
R_1_6_14_3 Node1_6_14 Node2_6_14 6.0902400000000005
C_1_6_14 Node1_6_14 GND 5.6574375e-16
R_1_6_15_2 Node1_6_15 Node1_7_15 1407692.3076923063
R_1_6_15_3 Node1_6_15 Node2_6_15 6.090239999999995
C_1_6_15 Node1_6_15 GND 5.657437500000005e-16
R_1_7_0_1 Node1_7_0 Node1_7_1 1407692.3076923077
R_1_7_0_2 Node1_7_0 Node1_8_0 1407692.3076923077
R_1_7_0_3 Node1_7_0 Node2_7_0 6.0902400000000005
C_1_7_0 Node1_7_0 GND 5.6574375e-16
R_1_7_1_1 Node1_7_1 Node1_7_2 1407692.3076923077
R_1_7_1_2 Node1_7_1 Node1_8_1 1407692.3076923077
R_1_7_1_3 Node1_7_1 Node2_7_1 6.0902400000000005
C_1_7_1 Node1_7_1 GND 5.6574375e-16
R_1_7_2_1 Node1_7_2 Node1_7_3 1407692.3076923077
R_1_7_2_2 Node1_7_2 Node1_8_2 1407692.3076923077
R_1_7_2_3 Node1_7_2 Node2_7_2 6.0902400000000005
C_1_7_2 Node1_7_2 GND 5.6574375e-16
R_1_7_3_1 Node1_7_3 Node1_7_4 1407692.3076923077
R_1_7_3_2 Node1_7_3 Node1_8_3 1407692.3076923077
R_1_7_3_3 Node1_7_3 Node2_7_3 6.0902400000000005
C_1_7_3 Node1_7_3 GND 5.6574375e-16
R_1_7_4_1 Node1_7_4 Node1_7_5 1407692.3076923077
R_1_7_4_2 Node1_7_4 Node1_8_4 1407692.3076923077
R_1_7_4_3 Node1_7_4 Node2_7_4 6.0902400000000005
C_1_7_4 Node1_7_4 GND 5.6574375e-16
R_1_7_5_1 Node1_7_5 Node1_7_6 1407692.3076923077
R_1_7_5_2 Node1_7_5 Node1_8_5 1407692.3076923077
R_1_7_5_3 Node1_7_5 Node2_7_5 6.0902400000000005
C_1_7_5 Node1_7_5 GND 5.6574375e-16
R_1_7_6_1 Node1_7_6 Node1_7_7 1407692.3076923077
R_1_7_6_2 Node1_7_6 Node1_8_6 1407692.3076923077
R_1_7_6_3 Node1_7_6 Node2_7_6 6.09024
C_1_7_6 Node1_7_6 GND 5.6574375e-16
R_1_7_7_1 Node1_7_7 Node1_7_8 1407692.3076923077
R_1_7_7_2 Node1_7_7 Node1_8_7 1407692.3076923077
R_1_7_7_3 Node1_7_7 Node2_7_7 6.0902400000000005
C_1_7_7 Node1_7_7 GND 5.6574375e-16
R_1_7_8_1 Node1_7_8 Node1_7_9 1407692.307692307
R_1_7_8_2 Node1_7_8 Node1_8_8 1407692.3076923077
R_1_7_8_3 Node1_7_8 Node2_7_8 6.0902400000000005
C_1_7_8 Node1_7_8 GND 5.6574375e-16
R_1_7_9_1 Node1_7_9 Node1_7_10 1407692.307692307
R_1_7_9_2 Node1_7_9 Node1_8_9 1407692.3076923063
R_1_7_9_3 Node1_7_9 Node2_7_9 6.090239999999995
C_1_7_9 Node1_7_9 GND 5.657437500000005e-16
R_1_7_10_1 Node1_7_10 Node1_7_11 1407692.3076923077
R_1_7_10_2 Node1_7_10 Node1_8_10 1407692.3076923077
R_1_7_10_3 Node1_7_10 Node2_7_10 6.0902400000000005
C_1_7_10 Node1_7_10 GND 5.6574375e-16
R_1_7_11_1 Node1_7_11 Node1_7_12 1407692.3076923077
R_1_7_11_2 Node1_7_11 Node1_8_11 1407692.3076923077
R_1_7_11_3 Node1_7_11 Node2_7_11 6.0902400000000005
C_1_7_11 Node1_7_11 GND 5.6574375e-16
R_1_7_12_1 Node1_7_12 Node1_7_13 1407692.3076923077
R_1_7_12_2 Node1_7_12 Node1_8_12 1407692.3076923077
R_1_7_12_3 Node1_7_12 Node2_7_12 6.0902400000000005
C_1_7_12 Node1_7_12 GND 5.6574375e-16
R_1_7_13_1 Node1_7_13 Node1_7_14 1407692.3076923077
R_1_7_13_2 Node1_7_13 Node1_8_13 1407692.3076923077
R_1_7_13_3 Node1_7_13 Node2_7_13 6.0902400000000005
C_1_7_13 Node1_7_13 GND 5.6574375e-16
R_1_7_14_1 Node1_7_14 Node1_7_15 1407692.307692307
R_1_7_14_2 Node1_7_14 Node1_8_14 1407692.3076923077
R_1_7_14_3 Node1_7_14 Node2_7_14 6.0902400000000005
C_1_7_14 Node1_7_14 GND 5.6574375e-16
R_1_7_15_2 Node1_7_15 Node1_8_15 1407692.3076923063
R_1_7_15_3 Node1_7_15 Node2_7_15 6.090239999999995
C_1_7_15 Node1_7_15 GND 5.657437500000005e-16
R_1_8_0_1 Node1_8_0 Node1_8_1 1407692.3076923077
R_1_8_0_2 Node1_8_0 Node1_9_0 1407692.3076923082
R_1_8_0_3 Node1_8_0 Node2_8_0 6.0902400000000005
C_1_8_0 Node1_8_0 GND 5.6574375e-16
R_1_8_1_1 Node1_8_1 Node1_8_2 1407692.3076923077
R_1_8_1_2 Node1_8_1 Node1_9_1 1407692.3076923084
R_1_8_1_3 Node1_8_1 Node2_8_1 6.0902400000000005
C_1_8_1 Node1_8_1 GND 5.6574375e-16
R_1_8_2_1 Node1_8_2 Node1_8_3 1407692.3076923077
R_1_8_2_2 Node1_8_2 Node1_9_2 1407692.3076923084
R_1_8_2_3 Node1_8_2 Node2_8_2 6.0902400000000005
C_1_8_2 Node1_8_2 GND 5.6574375e-16
R_1_8_3_1 Node1_8_3 Node1_8_4 1407692.3076923077
R_1_8_3_2 Node1_8_3 Node1_9_3 1407692.3076923084
R_1_8_3_3 Node1_8_3 Node2_8_3 6.0902400000000005
C_1_8_3 Node1_8_3 GND 5.6574375e-16
R_1_8_4_1 Node1_8_4 Node1_8_5 1407692.3076923077
R_1_8_4_2 Node1_8_4 Node1_9_4 1407692.3076923084
R_1_8_4_3 Node1_8_4 Node2_8_4 6.0902400000000005
C_1_8_4 Node1_8_4 GND 5.6574375e-16
R_1_8_5_1 Node1_8_5 Node1_8_6 1407692.3076923077
R_1_8_5_2 Node1_8_5 Node1_9_5 1407692.3076923084
R_1_8_5_3 Node1_8_5 Node2_8_5 6.0902400000000005
C_1_8_5 Node1_8_5 GND 5.6574375e-16
R_1_8_6_1 Node1_8_6 Node1_8_7 1407692.3076923077
R_1_8_6_2 Node1_8_6 Node1_9_6 1407692.3076923084
R_1_8_6_3 Node1_8_6 Node2_8_6 6.09024
C_1_8_6 Node1_8_6 GND 5.6574375e-16
R_1_8_7_1 Node1_8_7 Node1_8_8 1407692.3076923077
R_1_8_7_2 Node1_8_7 Node1_9_7 1407692.3076923084
R_1_8_7_3 Node1_8_7 Node2_8_7 6.0902400000000005
C_1_8_7 Node1_8_7 GND 5.6574375e-16
R_1_8_8_1 Node1_8_8 Node1_8_9 1407692.307692307
R_1_8_8_2 Node1_8_8 Node1_9_8 1407692.3076923084
R_1_8_8_3 Node1_8_8 Node2_8_8 6.0902400000000005
C_1_8_8 Node1_8_8 GND 5.6574375e-16
R_1_8_9_1 Node1_8_9 Node1_8_10 1407692.307692307
R_1_8_9_2 Node1_8_9 Node1_9_9 1407692.3076923075
R_1_8_9_3 Node1_8_9 Node2_8_9 6.090239999999995
C_1_8_9 Node1_8_9 GND 5.657437500000005e-16
R_1_8_10_1 Node1_8_10 Node1_8_11 1407692.3076923077
R_1_8_10_2 Node1_8_10 Node1_9_10 1407692.3076923084
R_1_8_10_3 Node1_8_10 Node2_8_10 6.0902400000000005
C_1_8_10 Node1_8_10 GND 5.6574375e-16
R_1_8_11_1 Node1_8_11 Node1_8_12 1407692.3076923077
R_1_8_11_2 Node1_8_11 Node1_9_11 1407692.3076923084
R_1_8_11_3 Node1_8_11 Node2_8_11 6.0902400000000005
C_1_8_11 Node1_8_11 GND 5.6574375e-16
R_1_8_12_1 Node1_8_12 Node1_8_13 1407692.3076923077
R_1_8_12_2 Node1_8_12 Node1_9_12 1407692.3076923084
R_1_8_12_3 Node1_8_12 Node2_8_12 6.0902400000000005
C_1_8_12 Node1_8_12 GND 5.6574375e-16
R_1_8_13_1 Node1_8_13 Node1_8_14 1407692.3076923077
R_1_8_13_2 Node1_8_13 Node1_9_13 1407692.3076923084
R_1_8_13_3 Node1_8_13 Node2_8_13 6.0902400000000005
C_1_8_13 Node1_8_13 GND 5.6574375e-16
R_1_8_14_1 Node1_8_14 Node1_8_15 1407692.307692307
R_1_8_14_2 Node1_8_14 Node1_9_14 1407692.3076923084
R_1_8_14_3 Node1_8_14 Node2_8_14 6.0902400000000005
C_1_8_14 Node1_8_14 GND 5.6574375e-16
R_1_8_15_2 Node1_8_15 Node1_9_15 1407692.307692307
R_1_8_15_3 Node1_8_15 Node2_8_15 6.090239999999995
C_1_8_15 Node1_8_15 GND 5.657437500000005e-16
R_1_9_0_1 Node1_9_0 Node1_9_1 1407692.307692309
R_1_9_0_2 Node1_9_0 Node1_10_0 1407692.3076923082
R_1_9_0_3 Node1_9_0 Node2_9_0 6.090240000000006
C_1_9_0 Node1_9_0 GND 5.657437499999995e-16
R_1_9_1_1 Node1_9_1 Node1_9_2 1407692.307692309
R_1_9_1_2 Node1_9_1 Node1_10_1 1407692.3076923084
R_1_9_1_3 Node1_9_1 Node2_9_1 6.090240000000006
C_1_9_1 Node1_9_1 GND 5.657437499999995e-16
R_1_9_2_1 Node1_9_2 Node1_9_3 1407692.307692309
R_1_9_2_2 Node1_9_2 Node1_10_2 1407692.3076923084
R_1_9_2_3 Node1_9_2 Node2_9_2 6.090240000000006
C_1_9_2 Node1_9_2 GND 5.657437499999995e-16
R_1_9_3_1 Node1_9_3 Node1_9_4 1407692.307692309
R_1_9_3_2 Node1_9_3 Node1_10_3 1407692.3076923084
R_1_9_3_3 Node1_9_3 Node2_9_3 6.090240000000006
C_1_9_3 Node1_9_3 GND 5.657437499999995e-16
R_1_9_4_1 Node1_9_4 Node1_9_5 1407692.307692309
R_1_9_4_2 Node1_9_4 Node1_10_4 1407692.3076923084
R_1_9_4_3 Node1_9_4 Node2_9_4 6.090240000000006
C_1_9_4 Node1_9_4 GND 5.657437499999995e-16
R_1_9_5_1 Node1_9_5 Node1_9_6 1407692.307692309
R_1_9_5_2 Node1_9_5 Node1_10_5 1407692.3076923084
R_1_9_5_3 Node1_9_5 Node2_9_5 6.090240000000006
C_1_9_5 Node1_9_5 GND 5.657437499999995e-16
R_1_9_6_1 Node1_9_6 Node1_9_7 1407692.307692309
R_1_9_6_2 Node1_9_6 Node1_10_6 1407692.3076923084
R_1_9_6_3 Node1_9_6 Node2_9_6 6.090240000000006
C_1_9_6 Node1_9_6 GND 5.657437499999995e-16
R_1_9_7_1 Node1_9_7 Node1_9_8 1407692.307692309
R_1_9_7_2 Node1_9_7 Node1_10_7 1407692.3076923084
R_1_9_7_3 Node1_9_7 Node2_9_7 6.090240000000006
C_1_9_7 Node1_9_7 GND 5.657437499999995e-16
R_1_9_8_1 Node1_9_8 Node1_9_9 1407692.3076923087
R_1_9_8_2 Node1_9_8 Node1_10_8 1407692.3076923084
R_1_9_8_3 Node1_9_8 Node2_9_8 6.090240000000006
C_1_9_8 Node1_9_8 GND 5.657437499999995e-16
R_1_9_9_1 Node1_9_9 Node1_9_10 1407692.3076923087
R_1_9_9_2 Node1_9_9 Node1_10_9 1407692.307692308
R_1_9_9_3 Node1_9_9 Node2_9_9 6.090240000000002
C_1_9_9 Node1_9_9 GND 5.657437499999999e-16
R_1_9_10_1 Node1_9_10 Node1_9_11 1407692.307692309
R_1_9_10_2 Node1_9_10 Node1_10_10 1407692.3076923084
R_1_9_10_3 Node1_9_10 Node2_9_10 6.090240000000006
C_1_9_10 Node1_9_10 GND 5.657437499999995e-16
R_1_9_11_1 Node1_9_11 Node1_9_12 1407692.307692309
R_1_9_11_2 Node1_9_11 Node1_10_11 1407692.3076923084
R_1_9_11_3 Node1_9_11 Node2_9_11 6.090240000000006
C_1_9_11 Node1_9_11 GND 5.657437499999995e-16
R_1_9_12_1 Node1_9_12 Node1_9_13 1407692.307692309
R_1_9_12_2 Node1_9_12 Node1_10_12 1407692.3076923084
R_1_9_12_3 Node1_9_12 Node2_9_12 6.090240000000006
C_1_9_12 Node1_9_12 GND 5.657437499999995e-16
R_1_9_13_1 Node1_9_13 Node1_9_14 1407692.307692309
R_1_9_13_2 Node1_9_13 Node1_10_13 1407692.3076923084
R_1_9_13_3 Node1_9_13 Node2_9_13 6.090240000000006
C_1_9_13 Node1_9_13 GND 5.657437499999995e-16
R_1_9_14_1 Node1_9_14 Node1_9_15 1407692.3076923084
R_1_9_14_2 Node1_9_14 Node1_10_14 1407692.3076923084
R_1_9_14_3 Node1_9_14 Node2_9_14 6.090240000000006
C_1_9_14 Node1_9_14 GND 5.657437499999995e-16
R_1_9_15_2 Node1_9_15 Node1_10_15 1407692.307692307
R_1_9_15_3 Node1_9_15 Node2_9_15 6.0902400000000005
C_1_9_15 Node1_9_15 GND 5.6574375e-16
R_1_10_0_1 Node1_10_0 Node1_10_1 1407692.3076923077
R_1_10_0_2 Node1_10_0 Node1_11_0 1407692.3076923077
R_1_10_0_3 Node1_10_0 Node2_10_0 6.0902400000000005
C_1_10_0 Node1_10_0 GND 5.6574375e-16
R_1_10_1_1 Node1_10_1 Node1_10_2 1407692.3076923077
R_1_10_1_2 Node1_10_1 Node1_11_1 1407692.3076923077
R_1_10_1_3 Node1_10_1 Node2_10_1 6.0902400000000005
C_1_10_1 Node1_10_1 GND 5.6574375e-16
R_1_10_2_1 Node1_10_2 Node1_10_3 1407692.3076923077
R_1_10_2_2 Node1_10_2 Node1_11_2 1407692.3076923077
R_1_10_2_3 Node1_10_2 Node2_10_2 6.0902400000000005
C_1_10_2 Node1_10_2 GND 5.6574375e-16
R_1_10_3_1 Node1_10_3 Node1_10_4 1407692.3076923077
R_1_10_3_2 Node1_10_3 Node1_11_3 1407692.3076923077
R_1_10_3_3 Node1_10_3 Node2_10_3 6.0902400000000005
C_1_10_3 Node1_10_3 GND 5.6574375e-16
R_1_10_4_1 Node1_10_4 Node1_10_5 1407692.3076923077
R_1_10_4_2 Node1_10_4 Node1_11_4 1407692.3076923077
R_1_10_4_3 Node1_10_4 Node2_10_4 6.0902400000000005
C_1_10_4 Node1_10_4 GND 5.6574375e-16
R_1_10_5_1 Node1_10_5 Node1_10_6 1407692.3076923077
R_1_10_5_2 Node1_10_5 Node1_11_5 1407692.3076923077
R_1_10_5_3 Node1_10_5 Node2_10_5 6.0902400000000005
C_1_10_5 Node1_10_5 GND 5.6574375e-16
R_1_10_6_1 Node1_10_6 Node1_10_7 1407692.3076923077
R_1_10_6_2 Node1_10_6 Node1_11_6 1407692.3076923077
R_1_10_6_3 Node1_10_6 Node2_10_6 6.0902400000000005
C_1_10_6 Node1_10_6 GND 5.6574375e-16
R_1_10_7_1 Node1_10_7 Node1_10_8 1407692.3076923077
R_1_10_7_2 Node1_10_7 Node1_11_7 1407692.3076923077
R_1_10_7_3 Node1_10_7 Node2_10_7 6.0902400000000005
C_1_10_7 Node1_10_7 GND 5.6574375e-16
R_1_10_8_1 Node1_10_8 Node1_10_9 1407692.3076923077
R_1_10_8_2 Node1_10_8 Node1_11_8 1407692.3076923077
R_1_10_8_3 Node1_10_8 Node2_10_8 6.0902400000000005
C_1_10_8 Node1_10_8 GND 5.6574375e-16
R_1_10_9_1 Node1_10_9 Node1_10_10 1407692.3076923077
R_1_10_9_2 Node1_10_9 Node1_11_9 1407692.3076923077
R_1_10_9_3 Node1_10_9 Node2_10_9 6.0902400000000005
C_1_10_9 Node1_10_9 GND 5.6574375e-16
R_1_10_10_1 Node1_10_10 Node1_10_11 1407692.3076923077
R_1_10_10_2 Node1_10_10 Node1_11_10 1407692.3076923077
R_1_10_10_3 Node1_10_10 Node2_10_10 6.0902400000000005
C_1_10_10 Node1_10_10 GND 5.6574375e-16
R_1_10_11_1 Node1_10_11 Node1_10_12 1407692.3076923077
R_1_10_11_2 Node1_10_11 Node1_11_11 1407692.3076923077
R_1_10_11_3 Node1_10_11 Node2_10_11 6.0902400000000005
C_1_10_11 Node1_10_11 GND 5.6574375e-16
R_1_10_12_1 Node1_10_12 Node1_10_13 1407692.3076923077
R_1_10_12_2 Node1_10_12 Node1_11_12 1407692.3076923077
R_1_10_12_3 Node1_10_12 Node2_10_12 6.0902400000000005
C_1_10_12 Node1_10_12 GND 5.6574375e-16
R_1_10_13_1 Node1_10_13 Node1_10_14 1407692.3076923077
R_1_10_13_2 Node1_10_13 Node1_11_13 1407692.3076923077
R_1_10_13_3 Node1_10_13 Node2_10_13 6.0902400000000005
C_1_10_13 Node1_10_13 GND 5.6574375e-16
R_1_10_14_1 Node1_10_14 Node1_10_15 1407692.307692307
R_1_10_14_2 Node1_10_14 Node1_11_14 1407692.3076923077
R_1_10_14_3 Node1_10_14 Node2_10_14 6.0902400000000005
C_1_10_14 Node1_10_14 GND 5.6574375e-16
R_1_10_15_2 Node1_10_15 Node1_11_15 1407692.3076923063
R_1_10_15_3 Node1_10_15 Node2_10_15 6.090239999999995
C_1_10_15 Node1_10_15 GND 5.657437500000005e-16
R_1_11_0_1 Node1_11_0 Node1_11_1 1407692.3076923077
R_1_11_0_2 Node1_11_0 Node1_12_0 1407692.3076923077
R_1_11_0_3 Node1_11_0 Node2_11_0 6.0902400000000005
C_1_11_0 Node1_11_0 GND 5.6574375e-16
R_1_11_1_1 Node1_11_1 Node1_11_2 1407692.3076923077
R_1_11_1_2 Node1_11_1 Node1_12_1 1407692.3076923077
R_1_11_1_3 Node1_11_1 Node2_11_1 6.0902400000000005
C_1_11_1 Node1_11_1 GND 5.6574375e-16
R_1_11_2_1 Node1_11_2 Node1_11_3 1407692.3076923077
R_1_11_2_2 Node1_11_2 Node1_12_2 1407692.3076923077
R_1_11_2_3 Node1_11_2 Node2_11_2 6.0902400000000005
C_1_11_2 Node1_11_2 GND 5.6574375e-16
R_1_11_3_1 Node1_11_3 Node1_11_4 1407692.3076923077
R_1_11_3_2 Node1_11_3 Node1_12_3 1407692.3076923077
R_1_11_3_3 Node1_11_3 Node2_11_3 6.0902400000000005
C_1_11_3 Node1_11_3 GND 5.6574375e-16
R_1_11_4_1 Node1_11_4 Node1_11_5 1407692.3076923077
R_1_11_4_2 Node1_11_4 Node1_12_4 1407692.3076923077
R_1_11_4_3 Node1_11_4 Node2_11_4 6.0902400000000005
C_1_11_4 Node1_11_4 GND 5.6574375e-16
R_1_11_5_1 Node1_11_5 Node1_11_6 1407692.3076923077
R_1_11_5_2 Node1_11_5 Node1_12_5 1407692.3076923077
R_1_11_5_3 Node1_11_5 Node2_11_5 6.0902400000000005
C_1_11_5 Node1_11_5 GND 5.6574375e-16
R_1_11_6_1 Node1_11_6 Node1_11_7 1407692.3076923077
R_1_11_6_2 Node1_11_6 Node1_12_6 1407692.3076923077
R_1_11_6_3 Node1_11_6 Node2_11_6 6.0902400000000005
C_1_11_6 Node1_11_6 GND 5.6574375e-16
R_1_11_7_1 Node1_11_7 Node1_11_8 1407692.3076923077
R_1_11_7_2 Node1_11_7 Node1_12_7 1407692.3076923077
R_1_11_7_3 Node1_11_7 Node2_11_7 6.0902400000000005
C_1_11_7 Node1_11_7 GND 5.6574375e-16
R_1_11_8_1 Node1_11_8 Node1_11_9 1407692.3076923077
R_1_11_8_2 Node1_11_8 Node1_12_8 1407692.3076923077
R_1_11_8_3 Node1_11_8 Node2_11_8 6.0902400000000005
C_1_11_8 Node1_11_8 GND 5.6574375e-16
R_1_11_9_1 Node1_11_9 Node1_11_10 1407692.3076923077
R_1_11_9_2 Node1_11_9 Node1_12_9 1407692.3076923077
R_1_11_9_3 Node1_11_9 Node2_11_9 6.0902400000000005
C_1_11_9 Node1_11_9 GND 5.6574375e-16
R_1_11_10_1 Node1_11_10 Node1_11_11 1407692.3076923077
R_1_11_10_2 Node1_11_10 Node1_12_10 1407692.3076923077
R_1_11_10_3 Node1_11_10 Node2_11_10 6.0902400000000005
C_1_11_10 Node1_11_10 GND 5.6574375e-16
R_1_11_11_1 Node1_11_11 Node1_11_12 1407692.3076923077
R_1_11_11_2 Node1_11_11 Node1_12_11 1407692.3076923077
R_1_11_11_3 Node1_11_11 Node2_11_11 6.0902400000000005
C_1_11_11 Node1_11_11 GND 5.6574375e-16
R_1_11_12_1 Node1_11_12 Node1_11_13 1407692.3076923077
R_1_11_12_2 Node1_11_12 Node1_12_12 1407692.3076923077
R_1_11_12_3 Node1_11_12 Node2_11_12 6.0902400000000005
C_1_11_12 Node1_11_12 GND 5.6574375e-16
R_1_11_13_1 Node1_11_13 Node1_11_14 1407692.3076923077
R_1_11_13_2 Node1_11_13 Node1_12_13 1407692.3076923077
R_1_11_13_3 Node1_11_13 Node2_11_13 6.0902400000000005
C_1_11_13 Node1_11_13 GND 5.6574375e-16
R_1_11_14_1 Node1_11_14 Node1_11_15 1407692.307692307
R_1_11_14_2 Node1_11_14 Node1_12_14 1407692.3076923077
R_1_11_14_3 Node1_11_14 Node2_11_14 6.0902400000000005
C_1_11_14 Node1_11_14 GND 5.6574375e-16
R_1_11_15_2 Node1_11_15 Node1_12_15 1407692.3076923063
R_1_11_15_3 Node1_11_15 Node2_11_15 6.090239999999995
C_1_11_15 Node1_11_15 GND 5.657437500000005e-16
R_1_12_0_1 Node1_12_0 Node1_12_1 1407692.3076923077
R_1_12_0_2 Node1_12_0 Node1_13_0 1407692.3076923077
R_1_12_0_3 Node1_12_0 Node2_12_0 6.0902400000000005
C_1_12_0 Node1_12_0 GND 5.6574375e-16
R_1_12_1_1 Node1_12_1 Node1_12_2 1407692.3076923077
R_1_12_1_2 Node1_12_1 Node1_13_1 1407692.3076923077
R_1_12_1_3 Node1_12_1 Node2_12_1 6.0902400000000005
C_1_12_1 Node1_12_1 GND 5.6574375e-16
R_1_12_2_1 Node1_12_2 Node1_12_3 1407692.3076923077
R_1_12_2_2 Node1_12_2 Node1_13_2 1407692.3076923077
R_1_12_2_3 Node1_12_2 Node2_12_2 6.0902400000000005
C_1_12_2 Node1_12_2 GND 5.6574375e-16
R_1_12_3_1 Node1_12_3 Node1_12_4 1407692.3076923077
R_1_12_3_2 Node1_12_3 Node1_13_3 1407692.3076923077
R_1_12_3_3 Node1_12_3 Node2_12_3 6.0902400000000005
C_1_12_3 Node1_12_3 GND 5.6574375e-16
R_1_12_4_1 Node1_12_4 Node1_12_5 1407692.3076923077
R_1_12_4_2 Node1_12_4 Node1_13_4 1407692.3076923077
R_1_12_4_3 Node1_12_4 Node2_12_4 6.0902400000000005
C_1_12_4 Node1_12_4 GND 5.6574375e-16
R_1_12_5_1 Node1_12_5 Node1_12_6 1407692.3076923077
R_1_12_5_2 Node1_12_5 Node1_13_5 1407692.3076923077
R_1_12_5_3 Node1_12_5 Node2_12_5 6.0902400000000005
C_1_12_5 Node1_12_5 GND 5.6574375e-16
R_1_12_6_1 Node1_12_6 Node1_12_7 1407692.3076923077
R_1_12_6_2 Node1_12_6 Node1_13_6 1407692.3076923077
R_1_12_6_3 Node1_12_6 Node2_12_6 6.0902400000000005
C_1_12_6 Node1_12_6 GND 5.6574375e-16
R_1_12_7_1 Node1_12_7 Node1_12_8 1407692.3076923077
R_1_12_7_2 Node1_12_7 Node1_13_7 1407692.3076923077
R_1_12_7_3 Node1_12_7 Node2_12_7 6.0902400000000005
C_1_12_7 Node1_12_7 GND 5.6574375e-16
R_1_12_8_1 Node1_12_8 Node1_12_9 1407692.3076923077
R_1_12_8_2 Node1_12_8 Node1_13_8 1407692.3076923077
R_1_12_8_3 Node1_12_8 Node2_12_8 6.0902400000000005
C_1_12_8 Node1_12_8 GND 5.6574375e-16
R_1_12_9_1 Node1_12_9 Node1_12_10 1407692.3076923077
R_1_12_9_2 Node1_12_9 Node1_13_9 1407692.3076923077
R_1_12_9_3 Node1_12_9 Node2_12_9 6.0902400000000005
C_1_12_9 Node1_12_9 GND 5.6574375e-16
R_1_12_10_1 Node1_12_10 Node1_12_11 1407692.3076923077
R_1_12_10_2 Node1_12_10 Node1_13_10 1407692.3076923077
R_1_12_10_3 Node1_12_10 Node2_12_10 6.0902400000000005
C_1_12_10 Node1_12_10 GND 5.6574375e-16
R_1_12_11_1 Node1_12_11 Node1_12_12 1407692.3076923077
R_1_12_11_2 Node1_12_11 Node1_13_11 1407692.3076923077
R_1_12_11_3 Node1_12_11 Node2_12_11 6.0902400000000005
C_1_12_11 Node1_12_11 GND 5.6574375e-16
R_1_12_12_1 Node1_12_12 Node1_12_13 1407692.3076923077
R_1_12_12_2 Node1_12_12 Node1_13_12 1407692.3076923077
R_1_12_12_3 Node1_12_12 Node2_12_12 6.0902400000000005
C_1_12_12 Node1_12_12 GND 5.6574375e-16
R_1_12_13_1 Node1_12_13 Node1_12_14 1407692.3076923077
R_1_12_13_2 Node1_12_13 Node1_13_13 1407692.3076923077
R_1_12_13_3 Node1_12_13 Node2_12_13 6.0902400000000005
C_1_12_13 Node1_12_13 GND 5.6574375e-16
R_1_12_14_1 Node1_12_14 Node1_12_15 1407692.307692307
R_1_12_14_2 Node1_12_14 Node1_13_14 1407692.3076923077
R_1_12_14_3 Node1_12_14 Node2_12_14 6.0902400000000005
C_1_12_14 Node1_12_14 GND 5.6574375e-16
R_1_12_15_2 Node1_12_15 Node1_13_15 1407692.3076923063
R_1_12_15_3 Node1_12_15 Node2_12_15 6.090239999999995
C_1_12_15 Node1_12_15 GND 5.657437500000005e-16
R_1_13_0_1 Node1_13_0 Node1_13_1 1407692.3076923077
R_1_13_0_2 Node1_13_0 Node1_14_0 1407692.3076923077
R_1_13_0_3 Node1_13_0 Node2_13_0 6.0902400000000005
C_1_13_0 Node1_13_0 GND 5.6574375e-16
R_1_13_1_1 Node1_13_1 Node1_13_2 1407692.3076923077
R_1_13_1_2 Node1_13_1 Node1_14_1 1407692.3076923077
R_1_13_1_3 Node1_13_1 Node2_13_1 6.0902400000000005
C_1_13_1 Node1_13_1 GND 5.6574375e-16
R_1_13_2_1 Node1_13_2 Node1_13_3 1407692.3076923077
R_1_13_2_2 Node1_13_2 Node1_14_2 1407692.3076923077
R_1_13_2_3 Node1_13_2 Node2_13_2 6.0902400000000005
C_1_13_2 Node1_13_2 GND 5.6574375e-16
R_1_13_3_1 Node1_13_3 Node1_13_4 1407692.3076923077
R_1_13_3_2 Node1_13_3 Node1_14_3 1407692.3076923077
R_1_13_3_3 Node1_13_3 Node2_13_3 6.0902400000000005
C_1_13_3 Node1_13_3 GND 5.6574375e-16
R_1_13_4_1 Node1_13_4 Node1_13_5 1407692.3076923077
R_1_13_4_2 Node1_13_4 Node1_14_4 1407692.3076923077
R_1_13_4_3 Node1_13_4 Node2_13_4 6.0902400000000005
C_1_13_4 Node1_13_4 GND 5.6574375e-16
R_1_13_5_1 Node1_13_5 Node1_13_6 1407692.3076923077
R_1_13_5_2 Node1_13_5 Node1_14_5 1407692.3076923077
R_1_13_5_3 Node1_13_5 Node2_13_5 6.0902400000000005
C_1_13_5 Node1_13_5 GND 5.6574375e-16
R_1_13_6_1 Node1_13_6 Node1_13_7 1407692.3076923077
R_1_13_6_2 Node1_13_6 Node1_14_6 1407692.3076923077
R_1_13_6_3 Node1_13_6 Node2_13_6 6.0902400000000005
C_1_13_6 Node1_13_6 GND 5.6574375e-16
R_1_13_7_1 Node1_13_7 Node1_13_8 1407692.3076923077
R_1_13_7_2 Node1_13_7 Node1_14_7 1407692.3076923077
R_1_13_7_3 Node1_13_7 Node2_13_7 6.0902400000000005
C_1_13_7 Node1_13_7 GND 5.6574375e-16
R_1_13_8_1 Node1_13_8 Node1_13_9 1407692.3076923077
R_1_13_8_2 Node1_13_8 Node1_14_8 1407692.3076923077
R_1_13_8_3 Node1_13_8 Node2_13_8 6.0902400000000005
C_1_13_8 Node1_13_8 GND 5.6574375e-16
R_1_13_9_1 Node1_13_9 Node1_13_10 1407692.3076923077
R_1_13_9_2 Node1_13_9 Node1_14_9 1407692.3076923077
R_1_13_9_3 Node1_13_9 Node2_13_9 6.0902400000000005
C_1_13_9 Node1_13_9 GND 5.6574375e-16
R_1_13_10_1 Node1_13_10 Node1_13_11 1407692.3076923077
R_1_13_10_2 Node1_13_10 Node1_14_10 1407692.3076923077
R_1_13_10_3 Node1_13_10 Node2_13_10 6.0902400000000005
C_1_13_10 Node1_13_10 GND 5.6574375e-16
R_1_13_11_1 Node1_13_11 Node1_13_12 1407692.3076923077
R_1_13_11_2 Node1_13_11 Node1_14_11 1407692.3076923077
R_1_13_11_3 Node1_13_11 Node2_13_11 6.0902400000000005
C_1_13_11 Node1_13_11 GND 5.6574375e-16
R_1_13_12_1 Node1_13_12 Node1_13_13 1407692.3076923077
R_1_13_12_2 Node1_13_12 Node1_14_12 1407692.3076923077
R_1_13_12_3 Node1_13_12 Node2_13_12 6.0902400000000005
C_1_13_12 Node1_13_12 GND 5.6574375e-16
R_1_13_13_1 Node1_13_13 Node1_13_14 1407692.3076923077
R_1_13_13_2 Node1_13_13 Node1_14_13 1407692.3076923077
R_1_13_13_3 Node1_13_13 Node2_13_13 6.0902400000000005
C_1_13_13 Node1_13_13 GND 5.6574375e-16
R_1_13_14_1 Node1_13_14 Node1_13_15 1407692.307692307
R_1_13_14_2 Node1_13_14 Node1_14_14 1407692.3076923077
R_1_13_14_3 Node1_13_14 Node2_13_14 6.0902400000000005
C_1_13_14 Node1_13_14 GND 5.6574375e-16
R_1_13_15_2 Node1_13_15 Node1_14_15 1407692.3076923063
R_1_13_15_3 Node1_13_15 Node2_13_15 6.090239999999995
C_1_13_15 Node1_13_15 GND 5.657437500000005e-16
R_1_14_0_1 Node1_14_0 Node1_14_1 1407692.3076923077
R_1_14_0_2 Node1_14_0 Node1_15_0 1407692.3076923077
R_1_14_0_3 Node1_14_0 Node2_14_0 6.0902400000000005
C_1_14_0 Node1_14_0 GND 5.6574375e-16
R_1_14_1_1 Node1_14_1 Node1_14_2 1407692.3076923077
R_1_14_1_2 Node1_14_1 Node1_15_1 1407692.3076923077
R_1_14_1_3 Node1_14_1 Node2_14_1 6.0902400000000005
C_1_14_1 Node1_14_1 GND 5.6574375e-16
R_1_14_2_1 Node1_14_2 Node1_14_3 1407692.3076923077
R_1_14_2_2 Node1_14_2 Node1_15_2 1407692.3076923077
R_1_14_2_3 Node1_14_2 Node2_14_2 6.0902400000000005
C_1_14_2 Node1_14_2 GND 5.6574375e-16
R_1_14_3_1 Node1_14_3 Node1_14_4 1407692.3076923077
R_1_14_3_2 Node1_14_3 Node1_15_3 1407692.3076923077
R_1_14_3_3 Node1_14_3 Node2_14_3 6.0902400000000005
C_1_14_3 Node1_14_3 GND 5.6574375e-16
R_1_14_4_1 Node1_14_4 Node1_14_5 1407692.3076923077
R_1_14_4_2 Node1_14_4 Node1_15_4 1407692.3076923077
R_1_14_4_3 Node1_14_4 Node2_14_4 6.0902400000000005
C_1_14_4 Node1_14_4 GND 5.6574375e-16
R_1_14_5_1 Node1_14_5 Node1_14_6 1407692.3076923077
R_1_14_5_2 Node1_14_5 Node1_15_5 1407692.3076923077
R_1_14_5_3 Node1_14_5 Node2_14_5 6.0902400000000005
C_1_14_5 Node1_14_5 GND 5.6574375e-16
R_1_14_6_1 Node1_14_6 Node1_14_7 1407692.3076923077
R_1_14_6_2 Node1_14_6 Node1_15_6 1407692.3076923077
R_1_14_6_3 Node1_14_6 Node2_14_6 6.0902400000000005
C_1_14_6 Node1_14_6 GND 5.6574375e-16
R_1_14_7_1 Node1_14_7 Node1_14_8 1407692.3076923077
R_1_14_7_2 Node1_14_7 Node1_15_7 1407692.3076923077
R_1_14_7_3 Node1_14_7 Node2_14_7 6.0902400000000005
C_1_14_7 Node1_14_7 GND 5.6574375e-16
R_1_14_8_1 Node1_14_8 Node1_14_9 1407692.3076923077
R_1_14_8_2 Node1_14_8 Node1_15_8 1407692.3076923077
R_1_14_8_3 Node1_14_8 Node2_14_8 6.0902400000000005
C_1_14_8 Node1_14_8 GND 5.6574375e-16
R_1_14_9_1 Node1_14_9 Node1_14_10 1407692.3076923077
R_1_14_9_2 Node1_14_9 Node1_15_9 1407692.3076923077
R_1_14_9_3 Node1_14_9 Node2_14_9 6.0902400000000005
C_1_14_9 Node1_14_9 GND 5.6574375e-16
R_1_14_10_1 Node1_14_10 Node1_14_11 1407692.3076923077
R_1_14_10_2 Node1_14_10 Node1_15_10 1407692.3076923077
R_1_14_10_3 Node1_14_10 Node2_14_10 6.0902400000000005
C_1_14_10 Node1_14_10 GND 5.6574375e-16
R_1_14_11_1 Node1_14_11 Node1_14_12 1407692.3076923077
R_1_14_11_2 Node1_14_11 Node1_15_11 1407692.3076923077
R_1_14_11_3 Node1_14_11 Node2_14_11 6.0902400000000005
C_1_14_11 Node1_14_11 GND 5.6574375e-16
R_1_14_12_1 Node1_14_12 Node1_14_13 1407692.3076923077
R_1_14_12_2 Node1_14_12 Node1_15_12 1407692.3076923077
R_1_14_12_3 Node1_14_12 Node2_14_12 6.0902400000000005
C_1_14_12 Node1_14_12 GND 5.6574375e-16
R_1_14_13_1 Node1_14_13 Node1_14_14 1407692.3076923077
R_1_14_13_2 Node1_14_13 Node1_15_13 1407692.3076923077
R_1_14_13_3 Node1_14_13 Node2_14_13 6.0902400000000005
C_1_14_13 Node1_14_13 GND 5.6574375e-16
R_1_14_14_1 Node1_14_14 Node1_14_15 1407692.307692307
R_1_14_14_2 Node1_14_14 Node1_15_14 1407692.3076923077
R_1_14_14_3 Node1_14_14 Node2_14_14 6.0902400000000005
C_1_14_14 Node1_14_14 GND 5.6574375e-16
R_1_14_15_2 Node1_14_15 Node1_15_15 1407692.3076923063
R_1_14_15_3 Node1_14_15 Node2_14_15 6.090239999999995
C_1_14_15 Node1_14_15 GND 5.657437500000005e-16
R_1_15_0_1 Node1_15_0 Node1_15_1 1407692.3076923077
R_1_15_0_3 Node1_15_0 Node2_15_0 6.0902400000000005
C_1_15_0 Node1_15_0 GND 5.6574375e-16
R_1_15_1_1 Node1_15_1 Node1_15_2 1407692.3076923077
R_1_15_1_3 Node1_15_1 Node2_15_1 6.0902400000000005
C_1_15_1 Node1_15_1 GND 5.6574375e-16
R_1_15_2_1 Node1_15_2 Node1_15_3 1407692.3076923077
R_1_15_2_3 Node1_15_2 Node2_15_2 6.0902400000000005
C_1_15_2 Node1_15_2 GND 5.6574375e-16
R_1_15_3_1 Node1_15_3 Node1_15_4 1407692.3076923077
R_1_15_3_3 Node1_15_3 Node2_15_3 6.0902400000000005
C_1_15_3 Node1_15_3 GND 5.6574375e-16
R_1_15_4_1 Node1_15_4 Node1_15_5 1407692.3076923077
R_1_15_4_3 Node1_15_4 Node2_15_4 6.0902400000000005
C_1_15_4 Node1_15_4 GND 5.6574375e-16
R_1_15_5_1 Node1_15_5 Node1_15_6 1407692.3076923077
R_1_15_5_3 Node1_15_5 Node2_15_5 6.0902400000000005
C_1_15_5 Node1_15_5 GND 5.6574375e-16
R_1_15_6_1 Node1_15_6 Node1_15_7 1407692.3076923077
R_1_15_6_3 Node1_15_6 Node2_15_6 6.0902400000000005
C_1_15_6 Node1_15_6 GND 5.6574375e-16
R_1_15_7_1 Node1_15_7 Node1_15_8 1407692.3076923077
R_1_15_7_3 Node1_15_7 Node2_15_7 6.0902400000000005
C_1_15_7 Node1_15_7 GND 5.6574375e-16
R_1_15_8_1 Node1_15_8 Node1_15_9 1407692.3076923077
R_1_15_8_3 Node1_15_8 Node2_15_8 6.0902400000000005
C_1_15_8 Node1_15_8 GND 5.6574375e-16
R_1_15_9_1 Node1_15_9 Node1_15_10 1407692.3076923077
R_1_15_9_3 Node1_15_9 Node2_15_9 6.0902400000000005
C_1_15_9 Node1_15_9 GND 5.6574375e-16
R_1_15_10_1 Node1_15_10 Node1_15_11 1407692.3076923077
R_1_15_10_3 Node1_15_10 Node2_15_10 6.0902400000000005
C_1_15_10 Node1_15_10 GND 5.6574375e-16
R_1_15_11_1 Node1_15_11 Node1_15_12 1407692.3076923077
R_1_15_11_3 Node1_15_11 Node2_15_11 6.0902400000000005
C_1_15_11 Node1_15_11 GND 5.6574375e-16
R_1_15_12_1 Node1_15_12 Node1_15_13 1407692.3076923077
R_1_15_12_3 Node1_15_12 Node2_15_12 6.0902400000000005
C_1_15_12 Node1_15_12 GND 5.6574375e-16
R_1_15_13_1 Node1_15_13 Node1_15_14 1407692.3076923077
R_1_15_13_3 Node1_15_13 Node2_15_13 6.0902400000000005
C_1_15_13 Node1_15_13 GND 5.6574375e-16
R_1_15_14_1 Node1_15_14 Node1_15_15 1407692.307692307
R_1_15_14_3 Node1_15_14 Node2_15_14 6.0902400000000005
C_1_15_14 Node1_15_14 GND 5.6574375e-16
R_1_15_15_3 Node1_15_15 Node2_15_15 6.090239999999993
C_1_15_15 Node1_15_15 GND 5.657437500000006e-16
R_2_0_0_1 Node2_0_0 Node2_0_1 8517647.058823539
R_2_0_0_2 Node2_0_0 Node2_1_0 8517647.058823535
R_2_0_0_3 Node2_0_0 Node3_0_0 15.754240000000014
C_2_0_0 Node2_0_0 GND 2.9036132812499977e-10
R_2_0_1_1 Node2_0_1 Node2_0_2 8517647.058823539
R_2_0_1_2 Node2_0_1 Node2_1_1 8517647.058823535
R_2_0_1_3 Node2_0_1 Node3_0_1 15.754240000000014
C_2_0_1 Node2_0_1 GND 2.9036132812499977e-10
R_2_0_2_1 Node2_0_2 Node2_0_3 8517647.058823539
R_2_0_2_2 Node2_0_2 Node2_1_2 8517647.058823535
R_2_0_2_3 Node2_0_2 Node3_0_2 15.754240000000014
C_2_0_2 Node2_0_2 GND 2.9036132812499977e-10
R_2_0_3_1 Node2_0_3 Node2_0_4 8517647.058823539
R_2_0_3_2 Node2_0_3 Node2_1_3 8517647.058823535
R_2_0_3_3 Node2_0_3 Node3_0_3 15.754240000000014
C_2_0_3 Node2_0_3 GND 2.9036132812499977e-10
R_2_0_4_1 Node2_0_4 Node2_0_5 8517647.058823539
R_2_0_4_2 Node2_0_4 Node2_1_4 8517647.058823535
R_2_0_4_3 Node2_0_4 Node3_0_4 15.754240000000014
C_2_0_4 Node2_0_4 GND 2.9036132812499977e-10
R_2_0_5_1 Node2_0_5 Node2_0_6 8517647.058823539
R_2_0_5_2 Node2_0_5 Node2_1_5 8517647.058823535
R_2_0_5_3 Node2_0_5 Node3_0_5 15.754240000000014
C_2_0_5 Node2_0_5 GND 2.9036132812499977e-10
R_2_0_6_1 Node2_0_6 Node2_0_7 8517647.058823539
R_2_0_6_2 Node2_0_6 Node2_1_6 8517647.058823535
R_2_0_6_3 Node2_0_6 Node3_0_6 15.754240000000014
C_2_0_6 Node2_0_6 GND 2.9036132812499977e-10
R_2_0_7_1 Node2_0_7 Node2_0_8 8517647.058823539
R_2_0_7_2 Node2_0_7 Node2_1_7 8517647.058823535
R_2_0_7_3 Node2_0_7 Node3_0_7 15.754240000000014
C_2_0_7 Node2_0_7 GND 2.9036132812499977e-10
R_2_0_8_1 Node2_0_8 Node2_0_9 8517647.058823539
R_2_0_8_2 Node2_0_8 Node2_1_8 8517647.058823535
R_2_0_8_3 Node2_0_8 Node3_0_8 15.754240000000014
C_2_0_8 Node2_0_8 GND 2.9036132812499977e-10
R_2_0_9_1 Node2_0_9 Node2_0_10 8517647.058823539
R_2_0_9_2 Node2_0_9 Node2_1_9 8517647.058823535
R_2_0_9_3 Node2_0_9 Node3_0_9 15.754240000000014
C_2_0_9 Node2_0_9 GND 2.9036132812499977e-10
R_2_0_10_1 Node2_0_10 Node2_0_11 8517647.058823539
R_2_0_10_2 Node2_0_10 Node2_1_10 8517647.058823535
R_2_0_10_3 Node2_0_10 Node3_0_10 15.754240000000014
C_2_0_10 Node2_0_10 GND 2.9036132812499977e-10
R_2_0_11_1 Node2_0_11 Node2_0_12 8517647.058823539
R_2_0_11_2 Node2_0_11 Node2_1_11 8517647.058823535
R_2_0_11_3 Node2_0_11 Node3_0_11 15.754240000000014
C_2_0_11 Node2_0_11 GND 2.9036132812499977e-10
R_2_0_12_1 Node2_0_12 Node2_0_13 8517647.058823539
R_2_0_12_2 Node2_0_12 Node2_1_12 8517647.058823535
R_2_0_12_3 Node2_0_12 Node3_0_12 15.754240000000014
C_2_0_12 Node2_0_12 GND 2.9036132812499977e-10
R_2_0_13_1 Node2_0_13 Node2_0_14 8517647.058823539
R_2_0_13_2 Node2_0_13 Node2_1_13 8517647.058823535
R_2_0_13_3 Node2_0_13 Node3_0_13 15.754240000000014
C_2_0_13 Node2_0_13 GND 2.9036132812499977e-10
R_2_0_14_1 Node2_0_14 Node2_0_15 8517647.058823535
R_2_0_14_2 Node2_0_14 Node2_1_14 8517647.058823535
R_2_0_14_3 Node2_0_14 Node3_0_14 15.754240000000014
C_2_0_14 Node2_0_14 GND 2.9036132812499977e-10
R_2_0_15_2 Node2_0_15 Node2_1_15 8517647.058823528
R_2_0_15_3 Node2_0_15 Node3_0_15 15.75424
C_2_0_15 Node2_0_15 GND 2.9036132812500003e-10
R_2_1_0_1 Node2_1_0 Node2_1_1 8517647.058823531
R_2_1_0_2 Node2_1_0 Node2_2_0 8517647.058823531
R_2_1_0_3 Node2_1_0 Node3_1_0 15.75424
C_2_1_0 Node2_1_0 GND 2.9036132812500003e-10
R_2_1_1_1 Node2_1_1 Node2_1_2 8517647.058823531
R_2_1_1_2 Node2_1_1 Node2_2_1 8517647.058823531
R_2_1_1_3 Node2_1_1 Node3_1_1 15.75424
C_2_1_1 Node2_1_1 GND 2.9036132812500003e-10
R_2_1_2_1 Node2_1_2 Node2_1_3 8517647.058823531
R_2_1_2_2 Node2_1_2 Node2_2_2 8517647.058823531
R_2_1_2_3 Node2_1_2 Node3_1_2 15.75424
C_2_1_2 Node2_1_2 GND 2.9036132812500003e-10
R_2_1_3_1 Node2_1_3 Node2_1_4 8517647.058823531
R_2_1_3_2 Node2_1_3 Node2_2_3 8517647.058823531
R_2_1_3_3 Node2_1_3 Node3_1_3 15.75424
C_2_1_3 Node2_1_3 GND 2.9036132812500003e-10
R_2_1_4_1 Node2_1_4 Node2_1_5 8517647.058823531
R_2_1_4_2 Node2_1_4 Node2_2_4 8517647.058823531
R_2_1_4_3 Node2_1_4 Node3_1_4 15.75424
C_2_1_4 Node2_1_4 GND 2.9036132812500003e-10
R_2_1_5_1 Node2_1_5 Node2_1_6 8517647.058823531
R_2_1_5_2 Node2_1_5 Node2_2_5 8517647.058823531
R_2_1_5_3 Node2_1_5 Node3_1_5 15.75424
C_2_1_5 Node2_1_5 GND 2.9036132812500003e-10
R_2_1_6_1 Node2_1_6 Node2_1_7 8517647.058823531
R_2_1_6_2 Node2_1_6 Node2_2_6 8517647.058823531
R_2_1_6_3 Node2_1_6 Node3_1_6 15.75424
C_2_1_6 Node2_1_6 GND 2.9036132812500003e-10
R_2_1_7_1 Node2_1_7 Node2_1_8 8517647.058823531
R_2_1_7_2 Node2_1_7 Node2_2_7 8517647.058823531
R_2_1_7_3 Node2_1_7 Node3_1_7 15.75424
C_2_1_7 Node2_1_7 GND 2.9036132812500003e-10
R_2_1_8_1 Node2_1_8 Node2_1_9 8517647.058823531
R_2_1_8_2 Node2_1_8 Node2_2_8 8517647.058823531
R_2_1_8_3 Node2_1_8 Node3_1_8 15.75424
C_2_1_8 Node2_1_8 GND 2.9036132812500003e-10
R_2_1_9_1 Node2_1_9 Node2_1_10 8517647.058823531
R_2_1_9_2 Node2_1_9 Node2_2_9 8517647.058823531
R_2_1_9_3 Node2_1_9 Node3_1_9 15.75424
C_2_1_9 Node2_1_9 GND 2.9036132812500003e-10
R_2_1_10_1 Node2_1_10 Node2_1_11 8517647.058823531
R_2_1_10_2 Node2_1_10 Node2_2_10 8517647.058823531
R_2_1_10_3 Node2_1_10 Node3_1_10 15.75424
C_2_1_10 Node2_1_10 GND 2.9036132812500003e-10
R_2_1_11_1 Node2_1_11 Node2_1_12 8517647.058823531
R_2_1_11_2 Node2_1_11 Node2_2_11 8517647.058823531
R_2_1_11_3 Node2_1_11 Node3_1_11 15.75424
C_2_1_11 Node2_1_11 GND 2.9036132812500003e-10
R_2_1_12_1 Node2_1_12 Node2_1_13 8517647.058823531
R_2_1_12_2 Node2_1_12 Node2_2_12 8517647.058823531
R_2_1_12_3 Node2_1_12 Node3_1_12 15.75424
C_2_1_12 Node2_1_12 GND 2.9036132812500003e-10
R_2_1_13_1 Node2_1_13 Node2_1_14 8517647.058823531
R_2_1_13_2 Node2_1_13 Node2_2_13 8517647.058823531
R_2_1_13_3 Node2_1_13 Node3_1_13 15.75424
C_2_1_13 Node2_1_13 GND 2.9036132812500003e-10
R_2_1_14_1 Node2_1_14 Node2_1_15 8517647.058823528
R_2_1_14_2 Node2_1_14 Node2_2_14 8517647.058823531
R_2_1_14_3 Node2_1_14 Node3_1_14 15.75424
C_2_1_14 Node2_1_14 GND 2.9036132812500003e-10
R_2_1_15_2 Node2_1_15 Node2_2_15 8517647.058823524
R_2_1_15_3 Node2_1_15 Node3_1_15 15.754239999999987
C_2_1_15 Node2_1_15 GND 2.903613281250003e-10
R_2_2_0_1 Node2_2_0 Node2_2_1 8517647.058823531
R_2_2_0_2 Node2_2_0 Node2_3_0 8517647.058823531
R_2_2_0_3 Node2_2_0 Node3_2_0 15.75424
C_2_2_0 Node2_2_0 GND 2.9036132812500003e-10
R_2_2_1_1 Node2_2_1 Node2_2_2 8517647.058823531
R_2_2_1_2 Node2_2_1 Node2_3_1 8517647.058823531
R_2_2_1_3 Node2_2_1 Node3_2_1 15.75424
C_2_2_1 Node2_2_1 GND 2.9036132812500003e-10
R_2_2_2_1 Node2_2_2 Node2_2_3 8517647.058823531
R_2_2_2_2 Node2_2_2 Node2_3_2 8517647.058823531
R_2_2_2_3 Node2_2_2 Node3_2_2 15.75424
C_2_2_2 Node2_2_2 GND 2.9036132812500003e-10
R_2_2_3_1 Node2_2_3 Node2_2_4 8517647.058823531
R_2_2_3_2 Node2_2_3 Node2_3_3 8517647.058823531
R_2_2_3_3 Node2_2_3 Node3_2_3 15.75424
C_2_2_3 Node2_2_3 GND 2.9036132812500003e-10
R_2_2_4_1 Node2_2_4 Node2_2_5 8517647.058823531
R_2_2_4_2 Node2_2_4 Node2_3_4 8517647.058823531
R_2_2_4_3 Node2_2_4 Node3_2_4 15.75424
C_2_2_4 Node2_2_4 GND 2.9036132812500003e-10
R_2_2_5_1 Node2_2_5 Node2_2_6 8517647.058823531
R_2_2_5_2 Node2_2_5 Node2_3_5 8517647.058823531
R_2_2_5_3 Node2_2_5 Node3_2_5 15.75424
C_2_2_5 Node2_2_5 GND 2.9036132812500003e-10
R_2_2_6_1 Node2_2_6 Node2_2_7 8517647.058823531
R_2_2_6_2 Node2_2_6 Node2_3_6 8517647.058823531
R_2_2_6_3 Node2_2_6 Node3_2_6 15.75424
C_2_2_6 Node2_2_6 GND 2.9036132812500003e-10
R_2_2_7_1 Node2_2_7 Node2_2_8 8517647.058823531
R_2_2_7_2 Node2_2_7 Node2_3_7 8517647.058823531
R_2_2_7_3 Node2_2_7 Node3_2_7 15.75424
C_2_2_7 Node2_2_7 GND 2.9036132812500003e-10
R_2_2_8_1 Node2_2_8 Node2_2_9 8517647.058823531
R_2_2_8_2 Node2_2_8 Node2_3_8 8517647.058823531
R_2_2_8_3 Node2_2_8 Node3_2_8 15.75424
C_2_2_8 Node2_2_8 GND 2.9036132812500003e-10
R_2_2_9_1 Node2_2_9 Node2_2_10 8517647.058823531
R_2_2_9_2 Node2_2_9 Node2_3_9 8517647.058823531
R_2_2_9_3 Node2_2_9 Node3_2_9 15.75424
C_2_2_9 Node2_2_9 GND 2.9036132812500003e-10
R_2_2_10_1 Node2_2_10 Node2_2_11 8517647.058823531
R_2_2_10_2 Node2_2_10 Node2_3_10 8517647.058823531
R_2_2_10_3 Node2_2_10 Node3_2_10 15.75424
C_2_2_10 Node2_2_10 GND 2.9036132812500003e-10
R_2_2_11_1 Node2_2_11 Node2_2_12 8517647.058823531
R_2_2_11_2 Node2_2_11 Node2_3_11 8517647.058823531
R_2_2_11_3 Node2_2_11 Node3_2_11 15.75424
C_2_2_11 Node2_2_11 GND 2.9036132812500003e-10
R_2_2_12_1 Node2_2_12 Node2_2_13 8517647.058823531
R_2_2_12_2 Node2_2_12 Node2_3_12 8517647.058823531
R_2_2_12_3 Node2_2_12 Node3_2_12 15.75424
C_2_2_12 Node2_2_12 GND 2.9036132812500003e-10
R_2_2_13_1 Node2_2_13 Node2_2_14 8517647.058823531
R_2_2_13_2 Node2_2_13 Node2_3_13 8517647.058823531
R_2_2_13_3 Node2_2_13 Node3_2_13 15.75424
C_2_2_13 Node2_2_13 GND 2.9036132812500003e-10
R_2_2_14_1 Node2_2_14 Node2_2_15 8517647.058823528
R_2_2_14_2 Node2_2_14 Node2_3_14 8517647.058823531
R_2_2_14_3 Node2_2_14 Node3_2_14 15.75424
C_2_2_14 Node2_2_14 GND 2.9036132812500003e-10
R_2_2_15_2 Node2_2_15 Node2_3_15 8517647.058823524
R_2_2_15_3 Node2_2_15 Node3_2_15 15.754239999999987
C_2_2_15 Node2_2_15 GND 2.903613281250003e-10
R_2_3_0_1 Node2_3_0 Node2_3_1 8517647.058823531
R_2_3_0_2 Node2_3_0 Node2_4_0 8517647.058823531
R_2_3_0_3 Node2_3_0 Node3_3_0 15.75424
C_2_3_0 Node2_3_0 GND 2.9036132812500003e-10
R_2_3_1_1 Node2_3_1 Node2_3_2 8517647.058823531
R_2_3_1_2 Node2_3_1 Node2_4_1 8517647.058823531
R_2_3_1_3 Node2_3_1 Node3_3_1 15.75424
C_2_3_1 Node2_3_1 GND 2.9036132812500003e-10
R_2_3_2_1 Node2_3_2 Node2_3_3 8517647.058823531
R_2_3_2_2 Node2_3_2 Node2_4_2 8517647.058823531
R_2_3_2_3 Node2_3_2 Node3_3_2 15.75424
C_2_3_2 Node2_3_2 GND 2.9036132812500003e-10
R_2_3_3_1 Node2_3_3 Node2_3_4 8517647.058823531
R_2_3_3_2 Node2_3_3 Node2_4_3 8517647.058823531
R_2_3_3_3 Node2_3_3 Node3_3_3 15.75424
C_2_3_3 Node2_3_3 GND 2.9036132812500003e-10
R_2_3_4_1 Node2_3_4 Node2_3_5 8517647.058823531
R_2_3_4_2 Node2_3_4 Node2_4_4 8517647.058823531
R_2_3_4_3 Node2_3_4 Node3_3_4 15.75424
C_2_3_4 Node2_3_4 GND 2.9036132812500003e-10
R_2_3_5_1 Node2_3_5 Node2_3_6 8517647.058823531
R_2_3_5_2 Node2_3_5 Node2_4_5 8517647.058823531
R_2_3_5_3 Node2_3_5 Node3_3_5 15.75424
C_2_3_5 Node2_3_5 GND 2.9036132812500003e-10
R_2_3_6_1 Node2_3_6 Node2_3_7 8517647.058823531
R_2_3_6_2 Node2_3_6 Node2_4_6 8517647.058823531
R_2_3_6_3 Node2_3_6 Node3_3_6 15.75424
C_2_3_6 Node2_3_6 GND 2.9036132812500003e-10
R_2_3_7_1 Node2_3_7 Node2_3_8 8517647.058823531
R_2_3_7_2 Node2_3_7 Node2_4_7 8517647.058823531
R_2_3_7_3 Node2_3_7 Node3_3_7 15.75424
C_2_3_7 Node2_3_7 GND 2.9036132812500003e-10
R_2_3_8_1 Node2_3_8 Node2_3_9 8517647.058823531
R_2_3_8_2 Node2_3_8 Node2_4_8 8517647.058823531
R_2_3_8_3 Node2_3_8 Node3_3_8 15.75424
C_2_3_8 Node2_3_8 GND 2.9036132812500003e-10
R_2_3_9_1 Node2_3_9 Node2_3_10 8517647.058823531
R_2_3_9_2 Node2_3_9 Node2_4_9 8517647.058823531
R_2_3_9_3 Node2_3_9 Node3_3_9 15.75424
C_2_3_9 Node2_3_9 GND 2.9036132812500003e-10
R_2_3_10_1 Node2_3_10 Node2_3_11 8517647.058823531
R_2_3_10_2 Node2_3_10 Node2_4_10 8517647.058823531
R_2_3_10_3 Node2_3_10 Node3_3_10 15.75424
C_2_3_10 Node2_3_10 GND 2.9036132812500003e-10
R_2_3_11_1 Node2_3_11 Node2_3_12 8517647.058823531
R_2_3_11_2 Node2_3_11 Node2_4_11 8517647.058823531
R_2_3_11_3 Node2_3_11 Node3_3_11 15.75424
C_2_3_11 Node2_3_11 GND 2.9036132812500003e-10
R_2_3_12_1 Node2_3_12 Node2_3_13 8517647.058823531
R_2_3_12_2 Node2_3_12 Node2_4_12 8517647.058823531
R_2_3_12_3 Node2_3_12 Node3_3_12 15.75424
C_2_3_12 Node2_3_12 GND 2.9036132812500003e-10
R_2_3_13_1 Node2_3_13 Node2_3_14 8517647.058823531
R_2_3_13_2 Node2_3_13 Node2_4_13 8517647.058823531
R_2_3_13_3 Node2_3_13 Node3_3_13 15.75424
C_2_3_13 Node2_3_13 GND 2.9036132812500003e-10
R_2_3_14_1 Node2_3_14 Node2_3_15 8517647.058823528
R_2_3_14_2 Node2_3_14 Node2_4_14 8517647.058823531
R_2_3_14_3 Node2_3_14 Node3_3_14 15.75424
C_2_3_14 Node2_3_14 GND 2.9036132812500003e-10
R_2_3_15_2 Node2_3_15 Node2_4_15 8517647.058823524
R_2_3_15_3 Node2_3_15 Node3_3_15 15.754239999999987
C_2_3_15 Node2_3_15 GND 2.903613281250003e-10
R_2_4_0_1 Node2_4_0 Node2_4_1 8517647.058823531
R_2_4_0_2 Node2_4_0 Node2_5_0 8517647.058823531
R_2_4_0_3 Node2_4_0 Node3_4_0 15.75424
C_2_4_0 Node2_4_0 GND 2.9036132812500003e-10
R_2_4_1_1 Node2_4_1 Node2_4_2 8517647.058823531
R_2_4_1_2 Node2_4_1 Node2_5_1 8517647.058823531
R_2_4_1_3 Node2_4_1 Node3_4_1 15.75424
C_2_4_1 Node2_4_1 GND 2.9036132812500003e-10
R_2_4_2_1 Node2_4_2 Node2_4_3 8517647.058823531
R_2_4_2_2 Node2_4_2 Node2_5_2 8517647.058823531
R_2_4_2_3 Node2_4_2 Node3_4_2 15.75424
C_2_4_2 Node2_4_2 GND 2.9036132812500003e-10
R_2_4_3_1 Node2_4_3 Node2_4_4 8517647.058823531
R_2_4_3_2 Node2_4_3 Node2_5_3 8517647.058823531
R_2_4_3_3 Node2_4_3 Node3_4_3 15.75424
C_2_4_3 Node2_4_3 GND 2.9036132812500003e-10
R_2_4_4_1 Node2_4_4 Node2_4_5 8517647.058823531
R_2_4_4_2 Node2_4_4 Node2_5_4 8517647.058823531
R_2_4_4_3 Node2_4_4 Node3_4_4 15.75424
C_2_4_4 Node2_4_4 GND 2.9036132812500003e-10
R_2_4_5_1 Node2_4_5 Node2_4_6 8517647.058823531
R_2_4_5_2 Node2_4_5 Node2_5_5 8517647.058823531
R_2_4_5_3 Node2_4_5 Node3_4_5 15.75424
C_2_4_5 Node2_4_5 GND 2.9036132812500003e-10
R_2_4_6_1 Node2_4_6 Node2_4_7 8517647.058823531
R_2_4_6_2 Node2_4_6 Node2_5_6 8517647.058823531
R_2_4_6_3 Node2_4_6 Node3_4_6 15.75424
C_2_4_6 Node2_4_6 GND 2.9036132812500003e-10
R_2_4_7_1 Node2_4_7 Node2_4_8 8517647.058823531
R_2_4_7_2 Node2_4_7 Node2_5_7 8517647.058823531
R_2_4_7_3 Node2_4_7 Node3_4_7 15.75424
C_2_4_7 Node2_4_7 GND 2.9036132812500003e-10
R_2_4_8_1 Node2_4_8 Node2_4_9 8517647.058823531
R_2_4_8_2 Node2_4_8 Node2_5_8 8517647.058823531
R_2_4_8_3 Node2_4_8 Node3_4_8 15.75424
C_2_4_8 Node2_4_8 GND 2.9036132812500003e-10
R_2_4_9_1 Node2_4_9 Node2_4_10 8517647.058823531
R_2_4_9_2 Node2_4_9 Node2_5_9 8517647.058823531
R_2_4_9_3 Node2_4_9 Node3_4_9 15.75424
C_2_4_9 Node2_4_9 GND 2.9036132812500003e-10
R_2_4_10_1 Node2_4_10 Node2_4_11 8517647.058823531
R_2_4_10_2 Node2_4_10 Node2_5_10 8517647.058823531
R_2_4_10_3 Node2_4_10 Node3_4_10 15.75424
C_2_4_10 Node2_4_10 GND 2.9036132812500003e-10
R_2_4_11_1 Node2_4_11 Node2_4_12 8517647.058823531
R_2_4_11_2 Node2_4_11 Node2_5_11 8517647.058823531
R_2_4_11_3 Node2_4_11 Node3_4_11 15.75424
C_2_4_11 Node2_4_11 GND 2.9036132812500003e-10
R_2_4_12_1 Node2_4_12 Node2_4_13 8517647.058823531
R_2_4_12_2 Node2_4_12 Node2_5_12 8517647.058823531
R_2_4_12_3 Node2_4_12 Node3_4_12 15.75424
C_2_4_12 Node2_4_12 GND 2.9036132812500003e-10
R_2_4_13_1 Node2_4_13 Node2_4_14 8517647.058823531
R_2_4_13_2 Node2_4_13 Node2_5_13 8517647.058823531
R_2_4_13_3 Node2_4_13 Node3_4_13 15.75424
C_2_4_13 Node2_4_13 GND 2.9036132812500003e-10
R_2_4_14_1 Node2_4_14 Node2_4_15 8517647.058823528
R_2_4_14_2 Node2_4_14 Node2_5_14 8517647.058823531
R_2_4_14_3 Node2_4_14 Node3_4_14 15.75424
C_2_4_14 Node2_4_14 GND 2.9036132812500003e-10
R_2_4_15_2 Node2_4_15 Node2_5_15 8517647.058823524
R_2_4_15_3 Node2_4_15 Node3_4_15 15.754239999999987
C_2_4_15 Node2_4_15 GND 2.903613281250003e-10
R_2_5_0_1 Node2_5_0 Node2_5_1 8517647.058823531
R_2_5_0_2 Node2_5_0 Node2_6_0 8517647.058823531
R_2_5_0_3 Node2_5_0 Node3_5_0 15.75424
C_2_5_0 Node2_5_0 GND 2.9036132812500003e-10
R_2_5_1_1 Node2_5_1 Node2_5_2 8517647.058823531
R_2_5_1_2 Node2_5_1 Node2_6_1 8517647.058823533
R_2_5_1_3 Node2_5_1 Node3_5_1 15.75424
C_2_5_1 Node2_5_1 GND 2.9036132812500003e-10
R_2_5_2_1 Node2_5_2 Node2_5_3 8517647.058823531
R_2_5_2_2 Node2_5_2 Node2_6_2 8517647.058823533
R_2_5_2_3 Node2_5_2 Node3_5_2 15.75424
C_2_5_2 Node2_5_2 GND 2.9036132812500003e-10
R_2_5_3_1 Node2_5_3 Node2_5_4 8517647.058823531
R_2_5_3_2 Node2_5_3 Node2_6_3 8517647.058823533
R_2_5_3_3 Node2_5_3 Node3_5_3 15.75424
C_2_5_3 Node2_5_3 GND 2.9036132812500003e-10
R_2_5_4_1 Node2_5_4 Node2_5_5 8517647.058823531
R_2_5_4_2 Node2_5_4 Node2_6_4 8517647.058823533
R_2_5_4_3 Node2_5_4 Node3_5_4 15.75424
C_2_5_4 Node2_5_4 GND 2.9036132812500003e-10
R_2_5_5_1 Node2_5_5 Node2_5_6 8517647.058823531
R_2_5_5_2 Node2_5_5 Node2_6_5 8517647.058823533
R_2_5_5_3 Node2_5_5 Node3_5_5 15.75424
C_2_5_5 Node2_5_5 GND 2.9036132812500003e-10
R_2_5_6_1 Node2_5_6 Node2_5_7 8517647.058823531
R_2_5_6_2 Node2_5_6 Node2_6_6 8517647.058823531
R_2_5_6_3 Node2_5_6 Node3_5_6 15.75424
C_2_5_6 Node2_5_6 GND 2.9036132812500003e-10
R_2_5_7_1 Node2_5_7 Node2_5_8 8517647.058823531
R_2_5_7_2 Node2_5_7 Node2_6_7 8517647.058823533
R_2_5_7_3 Node2_5_7 Node3_5_7 15.75424
C_2_5_7 Node2_5_7 GND 2.9036132812500003e-10
R_2_5_8_1 Node2_5_8 Node2_5_9 8517647.058823531
R_2_5_8_2 Node2_5_8 Node2_6_8 8517647.058823533
R_2_5_8_3 Node2_5_8 Node3_5_8 15.75424
C_2_5_8 Node2_5_8 GND 2.9036132812500003e-10
R_2_5_9_1 Node2_5_9 Node2_5_10 8517647.058823531
R_2_5_9_2 Node2_5_9 Node2_6_9 8517647.05882353
R_2_5_9_3 Node2_5_9 Node3_5_9 15.75424
C_2_5_9 Node2_5_9 GND 2.9036132812500003e-10
R_2_5_10_1 Node2_5_10 Node2_5_11 8517647.058823531
R_2_5_10_2 Node2_5_10 Node2_6_10 8517647.058823533
R_2_5_10_3 Node2_5_10 Node3_5_10 15.75424
C_2_5_10 Node2_5_10 GND 2.9036132812500003e-10
R_2_5_11_1 Node2_5_11 Node2_5_12 8517647.058823531
R_2_5_11_2 Node2_5_11 Node2_6_11 8517647.058823533
R_2_5_11_3 Node2_5_11 Node3_5_11 15.75424
C_2_5_11 Node2_5_11 GND 2.9036132812500003e-10
R_2_5_12_1 Node2_5_12 Node2_5_13 8517647.058823531
R_2_5_12_2 Node2_5_12 Node2_6_12 8517647.058823533
R_2_5_12_3 Node2_5_12 Node3_5_12 15.75424
C_2_5_12 Node2_5_12 GND 2.9036132812500003e-10
R_2_5_13_1 Node2_5_13 Node2_5_14 8517647.058823531
R_2_5_13_2 Node2_5_13 Node2_6_13 8517647.058823533
R_2_5_13_3 Node2_5_13 Node3_5_13 15.75424
C_2_5_13 Node2_5_13 GND 2.9036132812500003e-10
R_2_5_14_1 Node2_5_14 Node2_5_15 8517647.058823528
R_2_5_14_2 Node2_5_14 Node2_6_14 8517647.058823533
R_2_5_14_3 Node2_5_14 Node3_5_14 15.75424
C_2_5_14 Node2_5_14 GND 2.9036132812500003e-10
R_2_5_15_2 Node2_5_15 Node2_6_15 8517647.058823524
R_2_5_15_3 Node2_5_15 Node3_5_15 15.754239999999987
C_2_5_15 Node2_5_15 GND 2.903613281250003e-10
R_2_6_0_1 Node2_6_0 Node2_6_1 8517647.058823533
R_2_6_0_2 Node2_6_0 Node2_7_0 8517647.058823531
R_2_6_0_3 Node2_6_0 Node3_6_0 15.75424
C_2_6_0 Node2_6_0 GND 2.9036132812500003e-10
R_2_6_1_1 Node2_6_1 Node2_6_2 8517647.058823533
R_2_6_1_2 Node2_6_1 Node2_7_1 8517647.058823533
R_2_6_1_3 Node2_6_1 Node3_6_1 15.75424
C_2_6_1 Node2_6_1 GND 2.9036132812500003e-10
R_2_6_2_1 Node2_6_2 Node2_6_3 8517647.058823533
R_2_6_2_2 Node2_6_2 Node2_7_2 8517647.058823533
R_2_6_2_3 Node2_6_2 Node3_6_2 15.75424
C_2_6_2 Node2_6_2 GND 2.9036132812500003e-10
R_2_6_3_1 Node2_6_3 Node2_6_4 8517647.058823533
R_2_6_3_2 Node2_6_3 Node2_7_3 8517647.058823533
R_2_6_3_3 Node2_6_3 Node3_6_3 15.75424
C_2_6_3 Node2_6_3 GND 2.9036132812500003e-10
R_2_6_4_1 Node2_6_4 Node2_6_5 8517647.058823533
R_2_6_4_2 Node2_6_4 Node2_7_4 8517647.058823533
R_2_6_4_3 Node2_6_4 Node3_6_4 15.75424
C_2_6_4 Node2_6_4 GND 2.9036132812500003e-10
R_2_6_5_1 Node2_6_5 Node2_6_6 8517647.058823533
R_2_6_5_2 Node2_6_5 Node2_7_5 8517647.058823533
R_2_6_5_3 Node2_6_5 Node3_6_5 15.75424
C_2_6_5 Node2_6_5 GND 2.9036132812500003e-10
R_2_6_6_1 Node2_6_6 Node2_6_7 8517647.058823533
R_2_6_6_2 Node2_6_6 Node2_7_6 8517647.058823531
R_2_6_6_3 Node2_6_6 Node3_6_6 15.754239999999998
C_2_6_6 Node2_6_6 GND 2.903613281250001e-10
R_2_6_7_1 Node2_6_7 Node2_6_8 8517647.058823533
R_2_6_7_2 Node2_6_7 Node2_7_7 8517647.058823533
R_2_6_7_3 Node2_6_7 Node3_6_7 15.75424
C_2_6_7 Node2_6_7 GND 2.9036132812500003e-10
R_2_6_8_1 Node2_6_8 Node2_6_9 8517647.05882353
R_2_6_8_2 Node2_6_8 Node2_7_8 8517647.058823533
R_2_6_8_3 Node2_6_8 Node3_6_8 15.75424
C_2_6_8 Node2_6_8 GND 2.9036132812500003e-10
R_2_6_9_1 Node2_6_9 Node2_6_10 8517647.05882353
R_2_6_9_2 Node2_6_9 Node2_7_9 8517647.058823526
R_2_6_9_3 Node2_6_9 Node3_6_9 15.75423999999999
C_2_6_9 Node2_6_9 GND 2.903613281250002e-10
R_2_6_10_1 Node2_6_10 Node2_6_11 8517647.058823533
R_2_6_10_2 Node2_6_10 Node2_7_10 8517647.058823533
R_2_6_10_3 Node2_6_10 Node3_6_10 15.75424
C_2_6_10 Node2_6_10 GND 2.9036132812500003e-10
R_2_6_11_1 Node2_6_11 Node2_6_12 8517647.058823533
R_2_6_11_2 Node2_6_11 Node2_7_11 8517647.058823533
R_2_6_11_3 Node2_6_11 Node3_6_11 15.75424
C_2_6_11 Node2_6_11 GND 2.9036132812500003e-10
R_2_6_12_1 Node2_6_12 Node2_6_13 8517647.058823533
R_2_6_12_2 Node2_6_12 Node2_7_12 8517647.058823533
R_2_6_12_3 Node2_6_12 Node3_6_12 15.75424
C_2_6_12 Node2_6_12 GND 2.9036132812500003e-10
R_2_6_13_1 Node2_6_13 Node2_6_14 8517647.058823533
R_2_6_13_2 Node2_6_13 Node2_7_13 8517647.058823533
R_2_6_13_3 Node2_6_13 Node3_6_13 15.75424
C_2_6_13 Node2_6_13 GND 2.9036132812500003e-10
R_2_6_14_1 Node2_6_14 Node2_6_15 8517647.05882353
R_2_6_14_2 Node2_6_14 Node2_7_14 8517647.058823533
R_2_6_14_3 Node2_6_14 Node3_6_14 15.75424
C_2_6_14 Node2_6_14 GND 2.9036132812500003e-10
R_2_6_15_2 Node2_6_15 Node2_7_15 8517647.058823524
R_2_6_15_3 Node2_6_15 Node3_6_15 15.754239999999987
C_2_6_15 Node2_6_15 GND 2.903613281250003e-10
R_2_7_0_1 Node2_7_0 Node2_7_1 8517647.058823531
R_2_7_0_2 Node2_7_0 Node2_8_0 8517647.058823531
R_2_7_0_3 Node2_7_0 Node3_7_0 15.75424
C_2_7_0 Node2_7_0 GND 2.9036132812500003e-10
R_2_7_1_1 Node2_7_1 Node2_7_2 8517647.058823531
R_2_7_1_2 Node2_7_1 Node2_8_1 8517647.058823531
R_2_7_1_3 Node2_7_1 Node3_7_1 15.75424
C_2_7_1 Node2_7_1 GND 2.9036132812500003e-10
R_2_7_2_1 Node2_7_2 Node2_7_3 8517647.058823531
R_2_7_2_2 Node2_7_2 Node2_8_2 8517647.058823531
R_2_7_2_3 Node2_7_2 Node3_7_2 15.75424
C_2_7_2 Node2_7_2 GND 2.9036132812500003e-10
R_2_7_3_1 Node2_7_3 Node2_7_4 8517647.058823531
R_2_7_3_2 Node2_7_3 Node2_8_3 8517647.058823531
R_2_7_3_3 Node2_7_3 Node3_7_3 15.75424
C_2_7_3 Node2_7_3 GND 2.9036132812500003e-10
R_2_7_4_1 Node2_7_4 Node2_7_5 8517647.058823531
R_2_7_4_2 Node2_7_4 Node2_8_4 8517647.058823531
R_2_7_4_3 Node2_7_4 Node3_7_4 15.75424
C_2_7_4 Node2_7_4 GND 2.9036132812500003e-10
R_2_7_5_1 Node2_7_5 Node2_7_6 8517647.058823531
R_2_7_5_2 Node2_7_5 Node2_8_5 8517647.058823531
R_2_7_5_3 Node2_7_5 Node3_7_5 15.75424
C_2_7_5 Node2_7_5 GND 2.9036132812500003e-10
R_2_7_6_1 Node2_7_6 Node2_7_7 8517647.058823531
R_2_7_6_2 Node2_7_6 Node2_8_6 8517647.058823531
R_2_7_6_3 Node2_7_6 Node3_7_6 15.75424
C_2_7_6 Node2_7_6 GND 2.9036132812500003e-10
R_2_7_7_1 Node2_7_7 Node2_7_8 8517647.058823531
R_2_7_7_2 Node2_7_7 Node2_8_7 8517647.058823531
R_2_7_7_3 Node2_7_7 Node3_7_7 15.75424
C_2_7_7 Node2_7_7 GND 2.9036132812500003e-10
R_2_7_8_1 Node2_7_8 Node2_7_9 8517647.05882353
R_2_7_8_2 Node2_7_8 Node2_8_8 8517647.058823531
R_2_7_8_3 Node2_7_8 Node3_7_8 15.75424
C_2_7_8 Node2_7_8 GND 2.9036132812500003e-10
R_2_7_9_1 Node2_7_9 Node2_7_10 8517647.05882353
R_2_7_9_2 Node2_7_9 Node2_8_9 8517647.058823526
R_2_7_9_3 Node2_7_9 Node3_7_9 15.754239999999987
C_2_7_9 Node2_7_9 GND 2.903613281250003e-10
R_2_7_10_1 Node2_7_10 Node2_7_11 8517647.058823531
R_2_7_10_2 Node2_7_10 Node2_8_10 8517647.058823531
R_2_7_10_3 Node2_7_10 Node3_7_10 15.75424
C_2_7_10 Node2_7_10 GND 2.9036132812500003e-10
R_2_7_11_1 Node2_7_11 Node2_7_12 8517647.058823531
R_2_7_11_2 Node2_7_11 Node2_8_11 8517647.058823531
R_2_7_11_3 Node2_7_11 Node3_7_11 15.75424
C_2_7_11 Node2_7_11 GND 2.9036132812500003e-10
R_2_7_12_1 Node2_7_12 Node2_7_13 8517647.058823531
R_2_7_12_2 Node2_7_12 Node2_8_12 8517647.058823531
R_2_7_12_3 Node2_7_12 Node3_7_12 15.75424
C_2_7_12 Node2_7_12 GND 2.9036132812500003e-10
R_2_7_13_1 Node2_7_13 Node2_7_14 8517647.058823531
R_2_7_13_2 Node2_7_13 Node2_8_13 8517647.058823531
R_2_7_13_3 Node2_7_13 Node3_7_13 15.75424
C_2_7_13 Node2_7_13 GND 2.9036132812500003e-10
R_2_7_14_1 Node2_7_14 Node2_7_15 8517647.058823528
R_2_7_14_2 Node2_7_14 Node2_8_14 8517647.058823531
R_2_7_14_3 Node2_7_14 Node3_7_14 15.75424
C_2_7_14 Node2_7_14 GND 2.9036132812500003e-10
R_2_7_15_2 Node2_7_15 Node2_8_15 8517647.058823524
R_2_7_15_3 Node2_7_15 Node3_7_15 15.754239999999987
C_2_7_15 Node2_7_15 GND 2.903613281250003e-10
R_2_8_0_1 Node2_8_0 Node2_8_1 8517647.058823531
R_2_8_0_2 Node2_8_0 Node2_9_0 8517647.058823535
R_2_8_0_3 Node2_8_0 Node3_8_0 15.75424
C_2_8_0 Node2_8_0 GND 2.9036132812500003e-10
R_2_8_1_1 Node2_8_1 Node2_8_2 8517647.058823531
R_2_8_1_2 Node2_8_1 Node2_9_1 8517647.058823535
R_2_8_1_3 Node2_8_1 Node3_8_1 15.75424
C_2_8_1 Node2_8_1 GND 2.9036132812500003e-10
R_2_8_2_1 Node2_8_2 Node2_8_3 8517647.058823531
R_2_8_2_2 Node2_8_2 Node2_9_2 8517647.058823535
R_2_8_2_3 Node2_8_2 Node3_8_2 15.75424
C_2_8_2 Node2_8_2 GND 2.9036132812500003e-10
R_2_8_3_1 Node2_8_3 Node2_8_4 8517647.058823531
R_2_8_3_2 Node2_8_3 Node2_9_3 8517647.058823535
R_2_8_3_3 Node2_8_3 Node3_8_3 15.75424
C_2_8_3 Node2_8_3 GND 2.9036132812500003e-10
R_2_8_4_1 Node2_8_4 Node2_8_5 8517647.058823531
R_2_8_4_2 Node2_8_4 Node2_9_4 8517647.058823535
R_2_8_4_3 Node2_8_4 Node3_8_4 15.75424
C_2_8_4 Node2_8_4 GND 2.9036132812500003e-10
R_2_8_5_1 Node2_8_5 Node2_8_6 8517647.058823531
R_2_8_5_2 Node2_8_5 Node2_9_5 8517647.058823535
R_2_8_5_3 Node2_8_5 Node3_8_5 15.75424
C_2_8_5 Node2_8_5 GND 2.9036132812500003e-10
R_2_8_6_1 Node2_8_6 Node2_8_7 8517647.058823531
R_2_8_6_2 Node2_8_6 Node2_9_6 8517647.058823535
R_2_8_6_3 Node2_8_6 Node3_8_6 15.75424
C_2_8_6 Node2_8_6 GND 2.9036132812500003e-10
R_2_8_7_1 Node2_8_7 Node2_8_8 8517647.058823531
R_2_8_7_2 Node2_8_7 Node2_9_7 8517647.058823535
R_2_8_7_3 Node2_8_7 Node3_8_7 15.75424
C_2_8_7 Node2_8_7 GND 2.9036132812500003e-10
R_2_8_8_1 Node2_8_8 Node2_8_9 8517647.05882353
R_2_8_8_2 Node2_8_8 Node2_9_8 8517647.058823535
R_2_8_8_3 Node2_8_8 Node3_8_8 15.75424
C_2_8_8 Node2_8_8 GND 2.9036132812500003e-10
R_2_8_9_1 Node2_8_9 Node2_8_10 8517647.05882353
R_2_8_9_2 Node2_8_9 Node2_9_9 8517647.05882353
R_2_8_9_3 Node2_8_9 Node3_8_9 15.754239999999987
C_2_8_9 Node2_8_9 GND 2.903613281250003e-10
R_2_8_10_1 Node2_8_10 Node2_8_11 8517647.058823531
R_2_8_10_2 Node2_8_10 Node2_9_10 8517647.058823535
R_2_8_10_3 Node2_8_10 Node3_8_10 15.75424
C_2_8_10 Node2_8_10 GND 2.9036132812500003e-10
R_2_8_11_1 Node2_8_11 Node2_8_12 8517647.058823531
R_2_8_11_2 Node2_8_11 Node2_9_11 8517647.058823535
R_2_8_11_3 Node2_8_11 Node3_8_11 15.75424
C_2_8_11 Node2_8_11 GND 2.9036132812500003e-10
R_2_8_12_1 Node2_8_12 Node2_8_13 8517647.058823531
R_2_8_12_2 Node2_8_12 Node2_9_12 8517647.058823535
R_2_8_12_3 Node2_8_12 Node3_8_12 15.75424
C_2_8_12 Node2_8_12 GND 2.9036132812500003e-10
R_2_8_13_1 Node2_8_13 Node2_8_14 8517647.058823531
R_2_8_13_2 Node2_8_13 Node2_9_13 8517647.058823535
R_2_8_13_3 Node2_8_13 Node3_8_13 15.75424
C_2_8_13 Node2_8_13 GND 2.9036132812500003e-10
R_2_8_14_1 Node2_8_14 Node2_8_15 8517647.058823528
R_2_8_14_2 Node2_8_14 Node2_9_14 8517647.058823535
R_2_8_14_3 Node2_8_14 Node3_8_14 15.75424
C_2_8_14 Node2_8_14 GND 2.9036132812500003e-10
R_2_8_15_2 Node2_8_15 Node2_9_15 8517647.058823528
R_2_8_15_3 Node2_8_15 Node3_8_15 15.754239999999987
C_2_8_15 Node2_8_15 GND 2.903613281250003e-10
R_2_9_0_1 Node2_9_0 Node2_9_1 8517647.058823539
R_2_9_0_2 Node2_9_0 Node2_10_0 8517647.058823535
R_2_9_0_3 Node2_9_0 Node3_9_0 15.754240000000014
C_2_9_0 Node2_9_0 GND 2.903613281249998e-10
R_2_9_1_1 Node2_9_1 Node2_9_2 8517647.058823539
R_2_9_1_2 Node2_9_1 Node2_10_1 8517647.058823535
R_2_9_1_3 Node2_9_1 Node3_9_1 15.754240000000014
C_2_9_1 Node2_9_1 GND 2.9036132812499977e-10
R_2_9_2_1 Node2_9_2 Node2_9_3 8517647.058823539
R_2_9_2_2 Node2_9_2 Node2_10_2 8517647.058823535
R_2_9_2_3 Node2_9_2 Node3_9_2 15.754240000000014
C_2_9_2 Node2_9_2 GND 2.9036132812499977e-10
R_2_9_3_1 Node2_9_3 Node2_9_4 8517647.058823539
R_2_9_3_2 Node2_9_3 Node2_10_3 8517647.058823535
R_2_9_3_3 Node2_9_3 Node3_9_3 15.754240000000014
C_2_9_3 Node2_9_3 GND 2.9036132812499977e-10
R_2_9_4_1 Node2_9_4 Node2_9_5 8517647.058823539
R_2_9_4_2 Node2_9_4 Node2_10_4 8517647.058823535
R_2_9_4_3 Node2_9_4 Node3_9_4 15.754240000000014
C_2_9_4 Node2_9_4 GND 2.9036132812499977e-10
R_2_9_5_1 Node2_9_5 Node2_9_6 8517647.058823539
R_2_9_5_2 Node2_9_5 Node2_10_5 8517647.058823535
R_2_9_5_3 Node2_9_5 Node3_9_5 15.754240000000014
C_2_9_5 Node2_9_5 GND 2.9036132812499977e-10
R_2_9_6_1 Node2_9_6 Node2_9_7 8517647.058823539
R_2_9_6_2 Node2_9_6 Node2_10_6 8517647.058823535
R_2_9_6_3 Node2_9_6 Node3_9_6 15.754240000000014
C_2_9_6 Node2_9_6 GND 2.9036132812499977e-10
R_2_9_7_1 Node2_9_7 Node2_9_8 8517647.058823539
R_2_9_7_2 Node2_9_7 Node2_10_7 8517647.058823535
R_2_9_7_3 Node2_9_7 Node3_9_7 15.754240000000014
C_2_9_7 Node2_9_7 GND 2.9036132812499977e-10
R_2_9_8_1 Node2_9_8 Node2_9_9 8517647.058823537
R_2_9_8_2 Node2_9_8 Node2_10_8 8517647.058823535
R_2_9_8_3 Node2_9_8 Node3_9_8 15.754240000000014
C_2_9_8 Node2_9_8 GND 2.9036132812499977e-10
R_2_9_9_1 Node2_9_9 Node2_9_10 8517647.058823537
R_2_9_9_2 Node2_9_9 Node2_10_9 8517647.058823533
R_2_9_9_3 Node2_9_9 Node3_9_9 15.754240000000003
C_2_9_9 Node2_9_9 GND 2.903613281249999e-10
R_2_9_10_1 Node2_9_10 Node2_9_11 8517647.058823539
R_2_9_10_2 Node2_9_10 Node2_10_10 8517647.058823535
R_2_9_10_3 Node2_9_10 Node3_9_10 15.754240000000014
C_2_9_10 Node2_9_10 GND 2.9036132812499977e-10
R_2_9_11_1 Node2_9_11 Node2_9_12 8517647.058823539
R_2_9_11_2 Node2_9_11 Node2_10_11 8517647.058823535
R_2_9_11_3 Node2_9_11 Node3_9_11 15.754240000000014
C_2_9_11 Node2_9_11 GND 2.9036132812499977e-10
R_2_9_12_1 Node2_9_12 Node2_9_13 8517647.058823539
R_2_9_12_2 Node2_9_12 Node2_10_12 8517647.058823535
R_2_9_12_3 Node2_9_12 Node3_9_12 15.754240000000014
C_2_9_12 Node2_9_12 GND 2.9036132812499977e-10
R_2_9_13_1 Node2_9_13 Node2_9_14 8517647.058823539
R_2_9_13_2 Node2_9_13 Node2_10_13 8517647.058823535
R_2_9_13_3 Node2_9_13 Node3_9_13 15.754240000000014
C_2_9_13 Node2_9_13 GND 2.9036132812499977e-10
R_2_9_14_1 Node2_9_14 Node2_9_15 8517647.058823535
R_2_9_14_2 Node2_9_14 Node2_10_14 8517647.058823535
R_2_9_14_3 Node2_9_14 Node3_9_14 15.754240000000014
C_2_9_14 Node2_9_14 GND 2.9036132812499977e-10
R_2_9_15_2 Node2_9_15 Node2_10_15 8517647.058823528
R_2_9_15_3 Node2_9_15 Node3_9_15 15.75424
C_2_9_15 Node2_9_15 GND 2.9036132812500003e-10
R_2_10_0_1 Node2_10_0 Node2_10_1 8517647.058823531
R_2_10_0_2 Node2_10_0 Node2_11_0 8517647.058823531
R_2_10_0_3 Node2_10_0 Node3_10_0 15.75424
C_2_10_0 Node2_10_0 GND 2.9036132812500003e-10
R_2_10_1_1 Node2_10_1 Node2_10_2 8517647.058823531
R_2_10_1_2 Node2_10_1 Node2_11_1 8517647.058823531
R_2_10_1_3 Node2_10_1 Node3_10_1 15.75424
C_2_10_1 Node2_10_1 GND 2.9036132812500003e-10
R_2_10_2_1 Node2_10_2 Node2_10_3 8517647.058823531
R_2_10_2_2 Node2_10_2 Node2_11_2 8517647.058823531
R_2_10_2_3 Node2_10_2 Node3_10_2 15.75424
C_2_10_2 Node2_10_2 GND 2.9036132812500003e-10
R_2_10_3_1 Node2_10_3 Node2_10_4 8517647.058823531
R_2_10_3_2 Node2_10_3 Node2_11_3 8517647.058823531
R_2_10_3_3 Node2_10_3 Node3_10_3 15.75424
C_2_10_3 Node2_10_3 GND 2.9036132812500003e-10
R_2_10_4_1 Node2_10_4 Node2_10_5 8517647.058823531
R_2_10_4_2 Node2_10_4 Node2_11_4 8517647.058823531
R_2_10_4_3 Node2_10_4 Node3_10_4 15.75424
C_2_10_4 Node2_10_4 GND 2.9036132812500003e-10
R_2_10_5_1 Node2_10_5 Node2_10_6 8517647.058823531
R_2_10_5_2 Node2_10_5 Node2_11_5 8517647.058823531
R_2_10_5_3 Node2_10_5 Node3_10_5 15.75424
C_2_10_5 Node2_10_5 GND 2.9036132812500003e-10
R_2_10_6_1 Node2_10_6 Node2_10_7 8517647.058823531
R_2_10_6_2 Node2_10_6 Node2_11_6 8517647.058823531
R_2_10_6_3 Node2_10_6 Node3_10_6 15.75424
C_2_10_6 Node2_10_6 GND 2.9036132812500003e-10
R_2_10_7_1 Node2_10_7 Node2_10_8 8517647.058823531
R_2_10_7_2 Node2_10_7 Node2_11_7 8517647.058823531
R_2_10_7_3 Node2_10_7 Node3_10_7 15.75424
C_2_10_7 Node2_10_7 GND 2.9036132812500003e-10
R_2_10_8_1 Node2_10_8 Node2_10_9 8517647.058823531
R_2_10_8_2 Node2_10_8 Node2_11_8 8517647.058823531
R_2_10_8_3 Node2_10_8 Node3_10_8 15.75424
C_2_10_8 Node2_10_8 GND 2.9036132812500003e-10
R_2_10_9_1 Node2_10_9 Node2_10_10 8517647.058823531
R_2_10_9_2 Node2_10_9 Node2_11_9 8517647.058823531
R_2_10_9_3 Node2_10_9 Node3_10_9 15.75424
C_2_10_9 Node2_10_9 GND 2.9036132812500003e-10
R_2_10_10_1 Node2_10_10 Node2_10_11 8517647.058823531
R_2_10_10_2 Node2_10_10 Node2_11_10 8517647.058823531
R_2_10_10_3 Node2_10_10 Node3_10_10 15.75424
C_2_10_10 Node2_10_10 GND 2.9036132812500003e-10
R_2_10_11_1 Node2_10_11 Node2_10_12 8517647.058823531
R_2_10_11_2 Node2_10_11 Node2_11_11 8517647.058823531
R_2_10_11_3 Node2_10_11 Node3_10_11 15.75424
C_2_10_11 Node2_10_11 GND 2.9036132812500003e-10
R_2_10_12_1 Node2_10_12 Node2_10_13 8517647.058823531
R_2_10_12_2 Node2_10_12 Node2_11_12 8517647.058823531
R_2_10_12_3 Node2_10_12 Node3_10_12 15.75424
C_2_10_12 Node2_10_12 GND 2.9036132812500003e-10
R_2_10_13_1 Node2_10_13 Node2_10_14 8517647.058823531
R_2_10_13_2 Node2_10_13 Node2_11_13 8517647.058823531
R_2_10_13_3 Node2_10_13 Node3_10_13 15.75424
C_2_10_13 Node2_10_13 GND 2.9036132812500003e-10
R_2_10_14_1 Node2_10_14 Node2_10_15 8517647.058823528
R_2_10_14_2 Node2_10_14 Node2_11_14 8517647.058823531
R_2_10_14_3 Node2_10_14 Node3_10_14 15.75424
C_2_10_14 Node2_10_14 GND 2.9036132812500003e-10
R_2_10_15_2 Node2_10_15 Node2_11_15 8517647.058823524
R_2_10_15_3 Node2_10_15 Node3_10_15 15.754239999999987
C_2_10_15 Node2_10_15 GND 2.903613281250003e-10
R_2_11_0_1 Node2_11_0 Node2_11_1 8517647.058823531
R_2_11_0_2 Node2_11_0 Node2_12_0 8517647.058823531
R_2_11_0_3 Node2_11_0 Node3_11_0 15.75424
C_2_11_0 Node2_11_0 GND 2.9036132812500003e-10
R_2_11_1_1 Node2_11_1 Node2_11_2 8517647.058823531
R_2_11_1_2 Node2_11_1 Node2_12_1 8517647.058823531
R_2_11_1_3 Node2_11_1 Node3_11_1 15.75424
C_2_11_1 Node2_11_1 GND 2.9036132812500003e-10
R_2_11_2_1 Node2_11_2 Node2_11_3 8517647.058823531
R_2_11_2_2 Node2_11_2 Node2_12_2 8517647.058823531
R_2_11_2_3 Node2_11_2 Node3_11_2 15.75424
C_2_11_2 Node2_11_2 GND 2.9036132812500003e-10
R_2_11_3_1 Node2_11_3 Node2_11_4 8517647.058823531
R_2_11_3_2 Node2_11_3 Node2_12_3 8517647.058823531
R_2_11_3_3 Node2_11_3 Node3_11_3 15.75424
C_2_11_3 Node2_11_3 GND 2.9036132812500003e-10
R_2_11_4_1 Node2_11_4 Node2_11_5 8517647.058823531
R_2_11_4_2 Node2_11_4 Node2_12_4 8517647.058823531
R_2_11_4_3 Node2_11_4 Node3_11_4 15.75424
C_2_11_4 Node2_11_4 GND 2.9036132812500003e-10
R_2_11_5_1 Node2_11_5 Node2_11_6 8517647.058823531
R_2_11_5_2 Node2_11_5 Node2_12_5 8517647.058823531
R_2_11_5_3 Node2_11_5 Node3_11_5 15.75424
C_2_11_5 Node2_11_5 GND 2.9036132812500003e-10
R_2_11_6_1 Node2_11_6 Node2_11_7 8517647.058823531
R_2_11_6_2 Node2_11_6 Node2_12_6 8517647.058823531
R_2_11_6_3 Node2_11_6 Node3_11_6 15.75424
C_2_11_6 Node2_11_6 GND 2.9036132812500003e-10
R_2_11_7_1 Node2_11_7 Node2_11_8 8517647.058823531
R_2_11_7_2 Node2_11_7 Node2_12_7 8517647.058823531
R_2_11_7_3 Node2_11_7 Node3_11_7 15.75424
C_2_11_7 Node2_11_7 GND 2.9036132812500003e-10
R_2_11_8_1 Node2_11_8 Node2_11_9 8517647.058823531
R_2_11_8_2 Node2_11_8 Node2_12_8 8517647.058823531
R_2_11_8_3 Node2_11_8 Node3_11_8 15.75424
C_2_11_8 Node2_11_8 GND 2.9036132812500003e-10
R_2_11_9_1 Node2_11_9 Node2_11_10 8517647.058823531
R_2_11_9_2 Node2_11_9 Node2_12_9 8517647.058823531
R_2_11_9_3 Node2_11_9 Node3_11_9 15.75424
C_2_11_9 Node2_11_9 GND 2.9036132812500003e-10
R_2_11_10_1 Node2_11_10 Node2_11_11 8517647.058823531
R_2_11_10_2 Node2_11_10 Node2_12_10 8517647.058823531
R_2_11_10_3 Node2_11_10 Node3_11_10 15.75424
C_2_11_10 Node2_11_10 GND 2.9036132812500003e-10
R_2_11_11_1 Node2_11_11 Node2_11_12 8517647.058823531
R_2_11_11_2 Node2_11_11 Node2_12_11 8517647.058823531
R_2_11_11_3 Node2_11_11 Node3_11_11 15.75424
C_2_11_11 Node2_11_11 GND 2.9036132812500003e-10
R_2_11_12_1 Node2_11_12 Node2_11_13 8517647.058823531
R_2_11_12_2 Node2_11_12 Node2_12_12 8517647.058823531
R_2_11_12_3 Node2_11_12 Node3_11_12 15.75424
C_2_11_12 Node2_11_12 GND 2.9036132812500003e-10
R_2_11_13_1 Node2_11_13 Node2_11_14 8517647.058823531
R_2_11_13_2 Node2_11_13 Node2_12_13 8517647.058823531
R_2_11_13_3 Node2_11_13 Node3_11_13 15.75424
C_2_11_13 Node2_11_13 GND 2.9036132812500003e-10
R_2_11_14_1 Node2_11_14 Node2_11_15 8517647.058823528
R_2_11_14_2 Node2_11_14 Node2_12_14 8517647.058823531
R_2_11_14_3 Node2_11_14 Node3_11_14 15.75424
C_2_11_14 Node2_11_14 GND 2.9036132812500003e-10
R_2_11_15_2 Node2_11_15 Node2_12_15 8517647.058823524
R_2_11_15_3 Node2_11_15 Node3_11_15 15.754239999999987
C_2_11_15 Node2_11_15 GND 2.903613281250003e-10
R_2_12_0_1 Node2_12_0 Node2_12_1 8517647.058823531
R_2_12_0_2 Node2_12_0 Node2_13_0 8517647.058823531
R_2_12_0_3 Node2_12_0 Node3_12_0 15.75424
C_2_12_0 Node2_12_0 GND 2.9036132812500003e-10
R_2_12_1_1 Node2_12_1 Node2_12_2 8517647.058823531
R_2_12_1_2 Node2_12_1 Node2_13_1 8517647.058823531
R_2_12_1_3 Node2_12_1 Node3_12_1 15.75424
C_2_12_1 Node2_12_1 GND 2.9036132812500003e-10
R_2_12_2_1 Node2_12_2 Node2_12_3 8517647.058823531
R_2_12_2_2 Node2_12_2 Node2_13_2 8517647.058823531
R_2_12_2_3 Node2_12_2 Node3_12_2 15.75424
C_2_12_2 Node2_12_2 GND 2.9036132812500003e-10
R_2_12_3_1 Node2_12_3 Node2_12_4 8517647.058823531
R_2_12_3_2 Node2_12_3 Node2_13_3 8517647.058823531
R_2_12_3_3 Node2_12_3 Node3_12_3 15.75424
C_2_12_3 Node2_12_3 GND 2.9036132812500003e-10
R_2_12_4_1 Node2_12_4 Node2_12_5 8517647.058823531
R_2_12_4_2 Node2_12_4 Node2_13_4 8517647.058823531
R_2_12_4_3 Node2_12_4 Node3_12_4 15.75424
C_2_12_4 Node2_12_4 GND 2.9036132812500003e-10
R_2_12_5_1 Node2_12_5 Node2_12_6 8517647.058823531
R_2_12_5_2 Node2_12_5 Node2_13_5 8517647.058823531
R_2_12_5_3 Node2_12_5 Node3_12_5 15.75424
C_2_12_5 Node2_12_5 GND 2.9036132812500003e-10
R_2_12_6_1 Node2_12_6 Node2_12_7 8517647.058823531
R_2_12_6_2 Node2_12_6 Node2_13_6 8517647.058823531
R_2_12_6_3 Node2_12_6 Node3_12_6 15.75424
C_2_12_6 Node2_12_6 GND 2.9036132812500003e-10
R_2_12_7_1 Node2_12_7 Node2_12_8 8517647.058823531
R_2_12_7_2 Node2_12_7 Node2_13_7 8517647.058823531
R_2_12_7_3 Node2_12_7 Node3_12_7 15.75424
C_2_12_7 Node2_12_7 GND 2.9036132812500003e-10
R_2_12_8_1 Node2_12_8 Node2_12_9 8517647.058823531
R_2_12_8_2 Node2_12_8 Node2_13_8 8517647.058823531
R_2_12_8_3 Node2_12_8 Node3_12_8 15.75424
C_2_12_8 Node2_12_8 GND 2.9036132812500003e-10
R_2_12_9_1 Node2_12_9 Node2_12_10 8517647.058823531
R_2_12_9_2 Node2_12_9 Node2_13_9 8517647.058823531
R_2_12_9_3 Node2_12_9 Node3_12_9 15.75424
C_2_12_9 Node2_12_9 GND 2.9036132812500003e-10
R_2_12_10_1 Node2_12_10 Node2_12_11 8517647.058823531
R_2_12_10_2 Node2_12_10 Node2_13_10 8517647.058823531
R_2_12_10_3 Node2_12_10 Node3_12_10 15.75424
C_2_12_10 Node2_12_10 GND 2.9036132812500003e-10
R_2_12_11_1 Node2_12_11 Node2_12_12 8517647.058823531
R_2_12_11_2 Node2_12_11 Node2_13_11 8517647.058823531
R_2_12_11_3 Node2_12_11 Node3_12_11 15.75424
C_2_12_11 Node2_12_11 GND 2.9036132812500003e-10
R_2_12_12_1 Node2_12_12 Node2_12_13 8517647.058823531
R_2_12_12_2 Node2_12_12 Node2_13_12 8517647.058823531
R_2_12_12_3 Node2_12_12 Node3_12_12 15.75424
C_2_12_12 Node2_12_12 GND 2.9036132812500003e-10
R_2_12_13_1 Node2_12_13 Node2_12_14 8517647.058823531
R_2_12_13_2 Node2_12_13 Node2_13_13 8517647.058823531
R_2_12_13_3 Node2_12_13 Node3_12_13 15.75424
C_2_12_13 Node2_12_13 GND 2.9036132812500003e-10
R_2_12_14_1 Node2_12_14 Node2_12_15 8517647.058823528
R_2_12_14_2 Node2_12_14 Node2_13_14 8517647.058823531
R_2_12_14_3 Node2_12_14 Node3_12_14 15.75424
C_2_12_14 Node2_12_14 GND 2.9036132812500003e-10
R_2_12_15_2 Node2_12_15 Node2_13_15 8517647.058823524
R_2_12_15_3 Node2_12_15 Node3_12_15 15.754239999999987
C_2_12_15 Node2_12_15 GND 2.903613281250003e-10
R_2_13_0_1 Node2_13_0 Node2_13_1 8517647.058823531
R_2_13_0_2 Node2_13_0 Node2_14_0 8517647.058823531
R_2_13_0_3 Node2_13_0 Node3_13_0 15.75424
C_2_13_0 Node2_13_0 GND 2.9036132812500003e-10
R_2_13_1_1 Node2_13_1 Node2_13_2 8517647.058823531
R_2_13_1_2 Node2_13_1 Node2_14_1 8517647.058823531
R_2_13_1_3 Node2_13_1 Node3_13_1 15.75424
C_2_13_1 Node2_13_1 GND 2.9036132812500003e-10
R_2_13_2_1 Node2_13_2 Node2_13_3 8517647.058823531
R_2_13_2_2 Node2_13_2 Node2_14_2 8517647.058823531
R_2_13_2_3 Node2_13_2 Node3_13_2 15.75424
C_2_13_2 Node2_13_2 GND 2.9036132812500003e-10
R_2_13_3_1 Node2_13_3 Node2_13_4 8517647.058823531
R_2_13_3_2 Node2_13_3 Node2_14_3 8517647.058823531
R_2_13_3_3 Node2_13_3 Node3_13_3 15.75424
C_2_13_3 Node2_13_3 GND 2.9036132812500003e-10
R_2_13_4_1 Node2_13_4 Node2_13_5 8517647.058823531
R_2_13_4_2 Node2_13_4 Node2_14_4 8517647.058823531
R_2_13_4_3 Node2_13_4 Node3_13_4 15.75424
C_2_13_4 Node2_13_4 GND 2.9036132812500003e-10
R_2_13_5_1 Node2_13_5 Node2_13_6 8517647.058823531
R_2_13_5_2 Node2_13_5 Node2_14_5 8517647.058823531
R_2_13_5_3 Node2_13_5 Node3_13_5 15.75424
C_2_13_5 Node2_13_5 GND 2.9036132812500003e-10
R_2_13_6_1 Node2_13_6 Node2_13_7 8517647.058823531
R_2_13_6_2 Node2_13_6 Node2_14_6 8517647.058823531
R_2_13_6_3 Node2_13_6 Node3_13_6 15.75424
C_2_13_6 Node2_13_6 GND 2.9036132812500003e-10
R_2_13_7_1 Node2_13_7 Node2_13_8 8517647.058823531
R_2_13_7_2 Node2_13_7 Node2_14_7 8517647.058823531
R_2_13_7_3 Node2_13_7 Node3_13_7 15.75424
C_2_13_7 Node2_13_7 GND 2.9036132812500003e-10
R_2_13_8_1 Node2_13_8 Node2_13_9 8517647.058823531
R_2_13_8_2 Node2_13_8 Node2_14_8 8517647.058823531
R_2_13_8_3 Node2_13_8 Node3_13_8 15.75424
C_2_13_8 Node2_13_8 GND 2.9036132812500003e-10
R_2_13_9_1 Node2_13_9 Node2_13_10 8517647.058823531
R_2_13_9_2 Node2_13_9 Node2_14_9 8517647.058823531
R_2_13_9_3 Node2_13_9 Node3_13_9 15.75424
C_2_13_9 Node2_13_9 GND 2.9036132812500003e-10
R_2_13_10_1 Node2_13_10 Node2_13_11 8517647.058823531
R_2_13_10_2 Node2_13_10 Node2_14_10 8517647.058823531
R_2_13_10_3 Node2_13_10 Node3_13_10 15.75424
C_2_13_10 Node2_13_10 GND 2.9036132812500003e-10
R_2_13_11_1 Node2_13_11 Node2_13_12 8517647.058823531
R_2_13_11_2 Node2_13_11 Node2_14_11 8517647.058823531
R_2_13_11_3 Node2_13_11 Node3_13_11 15.75424
C_2_13_11 Node2_13_11 GND 2.9036132812500003e-10
R_2_13_12_1 Node2_13_12 Node2_13_13 8517647.058823531
R_2_13_12_2 Node2_13_12 Node2_14_12 8517647.058823531
R_2_13_12_3 Node2_13_12 Node3_13_12 15.75424
C_2_13_12 Node2_13_12 GND 2.9036132812500003e-10
R_2_13_13_1 Node2_13_13 Node2_13_14 8517647.058823531
R_2_13_13_2 Node2_13_13 Node2_14_13 8517647.058823531
R_2_13_13_3 Node2_13_13 Node3_13_13 15.75424
C_2_13_13 Node2_13_13 GND 2.9036132812500003e-10
R_2_13_14_1 Node2_13_14 Node2_13_15 8517647.058823528
R_2_13_14_2 Node2_13_14 Node2_14_14 8517647.058823531
R_2_13_14_3 Node2_13_14 Node3_13_14 15.75424
C_2_13_14 Node2_13_14 GND 2.9036132812500003e-10
R_2_13_15_2 Node2_13_15 Node2_14_15 8517647.058823524
R_2_13_15_3 Node2_13_15 Node3_13_15 15.754239999999987
C_2_13_15 Node2_13_15 GND 2.903613281250003e-10
R_2_14_0_1 Node2_14_0 Node2_14_1 8517647.058823531
R_2_14_0_2 Node2_14_0 Node2_15_0 8517647.058823531
R_2_14_0_3 Node2_14_0 Node3_14_0 15.75424
C_2_14_0 Node2_14_0 GND 2.9036132812500003e-10
R_2_14_1_1 Node2_14_1 Node2_14_2 8517647.058823531
R_2_14_1_2 Node2_14_1 Node2_15_1 8517647.058823531
R_2_14_1_3 Node2_14_1 Node3_14_1 15.75424
C_2_14_1 Node2_14_1 GND 2.9036132812500003e-10
R_2_14_2_1 Node2_14_2 Node2_14_3 8517647.058823531
R_2_14_2_2 Node2_14_2 Node2_15_2 8517647.058823531
R_2_14_2_3 Node2_14_2 Node3_14_2 15.75424
C_2_14_2 Node2_14_2 GND 2.9036132812500003e-10
R_2_14_3_1 Node2_14_3 Node2_14_4 8517647.058823531
R_2_14_3_2 Node2_14_3 Node2_15_3 8517647.058823531
R_2_14_3_3 Node2_14_3 Node3_14_3 15.75424
C_2_14_3 Node2_14_3 GND 2.9036132812500003e-10
R_2_14_4_1 Node2_14_4 Node2_14_5 8517647.058823531
R_2_14_4_2 Node2_14_4 Node2_15_4 8517647.058823531
R_2_14_4_3 Node2_14_4 Node3_14_4 15.75424
C_2_14_4 Node2_14_4 GND 2.9036132812500003e-10
R_2_14_5_1 Node2_14_5 Node2_14_6 8517647.058823531
R_2_14_5_2 Node2_14_5 Node2_15_5 8517647.058823531
R_2_14_5_3 Node2_14_5 Node3_14_5 15.75424
C_2_14_5 Node2_14_5 GND 2.9036132812500003e-10
R_2_14_6_1 Node2_14_6 Node2_14_7 8517647.058823531
R_2_14_6_2 Node2_14_6 Node2_15_6 8517647.058823531
R_2_14_6_3 Node2_14_6 Node3_14_6 15.75424
C_2_14_6 Node2_14_6 GND 2.9036132812500003e-10
R_2_14_7_1 Node2_14_7 Node2_14_8 8517647.058823531
R_2_14_7_2 Node2_14_7 Node2_15_7 8517647.058823531
R_2_14_7_3 Node2_14_7 Node3_14_7 15.75424
C_2_14_7 Node2_14_7 GND 2.9036132812500003e-10
R_2_14_8_1 Node2_14_8 Node2_14_9 8517647.058823531
R_2_14_8_2 Node2_14_8 Node2_15_8 8517647.058823531
R_2_14_8_3 Node2_14_8 Node3_14_8 15.75424
C_2_14_8 Node2_14_8 GND 2.9036132812500003e-10
R_2_14_9_1 Node2_14_9 Node2_14_10 8517647.058823531
R_2_14_9_2 Node2_14_9 Node2_15_9 8517647.058823531
R_2_14_9_3 Node2_14_9 Node3_14_9 15.75424
C_2_14_9 Node2_14_9 GND 2.9036132812500003e-10
R_2_14_10_1 Node2_14_10 Node2_14_11 8517647.058823531
R_2_14_10_2 Node2_14_10 Node2_15_10 8517647.058823531
R_2_14_10_3 Node2_14_10 Node3_14_10 15.75424
C_2_14_10 Node2_14_10 GND 2.9036132812500003e-10
R_2_14_11_1 Node2_14_11 Node2_14_12 8517647.058823531
R_2_14_11_2 Node2_14_11 Node2_15_11 8517647.058823531
R_2_14_11_3 Node2_14_11 Node3_14_11 15.75424
C_2_14_11 Node2_14_11 GND 2.9036132812500003e-10
R_2_14_12_1 Node2_14_12 Node2_14_13 8517647.058823531
R_2_14_12_2 Node2_14_12 Node2_15_12 8517647.058823531
R_2_14_12_3 Node2_14_12 Node3_14_12 15.75424
C_2_14_12 Node2_14_12 GND 2.9036132812500003e-10
R_2_14_13_1 Node2_14_13 Node2_14_14 8517647.058823531
R_2_14_13_2 Node2_14_13 Node2_15_13 8517647.058823531
R_2_14_13_3 Node2_14_13 Node3_14_13 15.75424
C_2_14_13 Node2_14_13 GND 2.9036132812500003e-10
R_2_14_14_1 Node2_14_14 Node2_14_15 8517647.058823528
R_2_14_14_2 Node2_14_14 Node2_15_14 8517647.058823531
R_2_14_14_3 Node2_14_14 Node3_14_14 15.75424
C_2_14_14 Node2_14_14 GND 2.9036132812500003e-10
R_2_14_15_2 Node2_14_15 Node2_15_15 8517647.058823522
R_2_14_15_3 Node2_14_15 Node3_14_15 15.754239999999987
C_2_14_15 Node2_14_15 GND 2.903613281250003e-10
R_2_15_0_1 Node2_15_0 Node2_15_1 8517647.058823531
R_2_15_0_3 Node2_15_0 Node3_15_0 15.75424
C_2_15_0 Node2_15_0 GND 2.9036132812500003e-10
R_2_15_1_1 Node2_15_1 Node2_15_2 8517647.058823531
R_2_15_1_3 Node2_15_1 Node3_15_1 15.75424
C_2_15_1 Node2_15_1 GND 2.9036132812500003e-10
R_2_15_2_1 Node2_15_2 Node2_15_3 8517647.058823531
R_2_15_2_3 Node2_15_2 Node3_15_2 15.75424
C_2_15_2 Node2_15_2 GND 2.9036132812500003e-10
R_2_15_3_1 Node2_15_3 Node2_15_4 8517647.058823531
R_2_15_3_3 Node2_15_3 Node3_15_3 15.75424
C_2_15_3 Node2_15_3 GND 2.9036132812500003e-10
R_2_15_4_1 Node2_15_4 Node2_15_5 8517647.058823531
R_2_15_4_3 Node2_15_4 Node3_15_4 15.75424
C_2_15_4 Node2_15_4 GND 2.9036132812500003e-10
R_2_15_5_1 Node2_15_5 Node2_15_6 8517647.058823531
R_2_15_5_3 Node2_15_5 Node3_15_5 15.75424
C_2_15_5 Node2_15_5 GND 2.9036132812500003e-10
R_2_15_6_1 Node2_15_6 Node2_15_7 8517647.058823531
R_2_15_6_3 Node2_15_6 Node3_15_6 15.75424
C_2_15_6 Node2_15_6 GND 2.9036132812500003e-10
R_2_15_7_1 Node2_15_7 Node2_15_8 8517647.058823531
R_2_15_7_3 Node2_15_7 Node3_15_7 15.75424
C_2_15_7 Node2_15_7 GND 2.9036132812500003e-10
R_2_15_8_1 Node2_15_8 Node2_15_9 8517647.058823531
R_2_15_8_3 Node2_15_8 Node3_15_8 15.75424
C_2_15_8 Node2_15_8 GND 2.9036132812500003e-10
R_2_15_9_1 Node2_15_9 Node2_15_10 8517647.058823531
R_2_15_9_3 Node2_15_9 Node3_15_9 15.75424
C_2_15_9 Node2_15_9 GND 2.9036132812500003e-10
R_2_15_10_1 Node2_15_10 Node2_15_11 8517647.058823531
R_2_15_10_3 Node2_15_10 Node3_15_10 15.75424
C_2_15_10 Node2_15_10 GND 2.9036132812500003e-10
R_2_15_11_1 Node2_15_11 Node2_15_12 8517647.058823531
R_2_15_11_3 Node2_15_11 Node3_15_11 15.75424
C_2_15_11 Node2_15_11 GND 2.9036132812500003e-10
R_2_15_12_1 Node2_15_12 Node2_15_13 8517647.058823531
R_2_15_12_3 Node2_15_12 Node3_15_12 15.75424
C_2_15_12 Node2_15_12 GND 2.9036132812500003e-10
R_2_15_13_1 Node2_15_13 Node2_15_14 8517647.058823531
R_2_15_13_3 Node2_15_13 Node3_15_13 15.75424
C_2_15_13 Node2_15_13 GND 2.9036132812500003e-10
R_2_15_14_1 Node2_15_14 Node2_15_15 8517647.058823526
R_2_15_14_3 Node2_15_14 Node3_15_14 15.75424
C_2_15_14 Node2_15_14 GND 2.9036132812500003e-10
R_2_15_15_3 Node2_15_15 Node3_15_15 15.754239999999983
C_2_15_15 Node2_15_15 GND 2.9036132812500034e-10
R_3_0_0_1 Node3_0_0 Node3_0_1 90588.23529411775
R_3_0_0_2 Node3_0_0 Node3_1_0 90588.23529411771
R_3_0_0_3 Node3_0_0 Node4_0_0 0.16755200000000015
C_3_0_0 Node3_0_0 GND 1.9174804687499983e-10
R_3_0_1_1 Node3_0_1 Node3_0_2 90588.23529411775
R_3_0_1_2 Node3_0_1 Node3_1_1 90588.23529411771
R_3_0_1_3 Node3_0_1 Node4_0_1 0.16755200000000015
C_3_0_1 Node3_0_1 GND 1.9174804687499983e-10
R_3_0_2_1 Node3_0_2 Node3_0_3 90588.23529411775
R_3_0_2_2 Node3_0_2 Node3_1_2 90588.23529411771
R_3_0_2_3 Node3_0_2 Node4_0_2 0.16755200000000015
C_3_0_2 Node3_0_2 GND 1.9174804687499983e-10
R_3_0_3_1 Node3_0_3 Node3_0_4 90588.23529411775
R_3_0_3_2 Node3_0_3 Node3_1_3 90588.23529411771
R_3_0_3_3 Node3_0_3 Node4_0_3 0.16755200000000015
C_3_0_3 Node3_0_3 GND 1.9174804687499983e-10
R_3_0_4_1 Node3_0_4 Node3_0_5 90588.23529411775
R_3_0_4_2 Node3_0_4 Node3_1_4 90588.23529411771
R_3_0_4_3 Node3_0_4 Node4_0_4 0.16755200000000015
C_3_0_4 Node3_0_4 GND 1.9174804687499983e-10
R_3_0_5_1 Node3_0_5 Node3_0_6 90588.23529411775
R_3_0_5_2 Node3_0_5 Node3_1_5 90588.23529411771
R_3_0_5_3 Node3_0_5 Node4_0_5 0.16755200000000015
C_3_0_5 Node3_0_5 GND 1.9174804687499983e-10
R_3_0_6_1 Node3_0_6 Node3_0_7 90588.23529411775
R_3_0_6_2 Node3_0_6 Node3_1_6 90588.23529411771
R_3_0_6_3 Node3_0_6 Node4_0_6 0.16755200000000015
C_3_0_6 Node3_0_6 GND 1.9174804687499983e-10
R_3_0_7_1 Node3_0_7 Node3_0_8 90588.23529411775
R_3_0_7_2 Node3_0_7 Node3_1_7 90588.23529411771
R_3_0_7_3 Node3_0_7 Node4_0_7 0.16755200000000015
C_3_0_7 Node3_0_7 GND 1.9174804687499983e-10
R_3_0_8_1 Node3_0_8 Node3_0_9 90588.23529411775
R_3_0_8_2 Node3_0_8 Node3_1_8 90588.23529411771
R_3_0_8_3 Node3_0_8 Node4_0_8 0.16755200000000015
C_3_0_8 Node3_0_8 GND 1.9174804687499983e-10
R_3_0_9_1 Node3_0_9 Node3_0_10 90588.23529411775
R_3_0_9_2 Node3_0_9 Node3_1_9 90588.23529411771
R_3_0_9_3 Node3_0_9 Node4_0_9 0.16755200000000015
C_3_0_9 Node3_0_9 GND 1.9174804687499983e-10
R_3_0_10_1 Node3_0_10 Node3_0_11 90588.23529411775
R_3_0_10_2 Node3_0_10 Node3_1_10 90588.23529411771
R_3_0_10_3 Node3_0_10 Node4_0_10 0.16755200000000015
C_3_0_10 Node3_0_10 GND 1.9174804687499983e-10
R_3_0_11_1 Node3_0_11 Node3_0_12 90588.23529411775
R_3_0_11_2 Node3_0_11 Node3_1_11 90588.23529411771
R_3_0_11_3 Node3_0_11 Node4_0_11 0.16755200000000015
C_3_0_11 Node3_0_11 GND 1.9174804687499983e-10
R_3_0_12_1 Node3_0_12 Node3_0_13 90588.23529411775
R_3_0_12_2 Node3_0_12 Node3_1_12 90588.23529411771
R_3_0_12_3 Node3_0_12 Node4_0_12 0.16755200000000015
C_3_0_12 Node3_0_12 GND 1.9174804687499983e-10
R_3_0_13_1 Node3_0_13 Node3_0_14 90588.23529411775
R_3_0_13_2 Node3_0_13 Node3_1_13 90588.23529411771
R_3_0_13_3 Node3_0_13 Node4_0_13 0.16755200000000015
C_3_0_13 Node3_0_13 GND 1.9174804687499983e-10
R_3_0_14_1 Node3_0_14 Node3_0_15 90588.23529411771
R_3_0_14_2 Node3_0_14 Node3_1_14 90588.23529411771
R_3_0_14_3 Node3_0_14 Node4_0_14 0.16755200000000015
C_3_0_14 Node3_0_14 GND 1.9174804687499983e-10
R_3_0_15_2 Node3_0_15 Node3_1_15 90588.23529411762
R_3_0_15_3 Node3_0_15 Node4_0_15 0.167552
C_3_0_15 Node3_0_15 GND 1.91748046875e-10
R_3_1_0_1 Node3_1_0 Node3_1_1 90588.23529411767
R_3_1_0_2 Node3_1_0 Node3_2_0 90588.23529411767
R_3_1_0_3 Node3_1_0 Node4_1_0 0.167552
C_3_1_0 Node3_1_0 GND 1.91748046875e-10
R_3_1_1_1 Node3_1_1 Node3_1_2 90588.23529411767
R_3_1_1_2 Node3_1_1 Node3_2_1 90588.23529411767
R_3_1_1_3 Node3_1_1 Node4_1_1 0.167552
C_3_1_1 Node3_1_1 GND 1.91748046875e-10
R_3_1_2_1 Node3_1_2 Node3_1_3 90588.23529411767
R_3_1_2_2 Node3_1_2 Node3_2_2 90588.23529411767
R_3_1_2_3 Node3_1_2 Node4_1_2 0.167552
C_3_1_2 Node3_1_2 GND 1.91748046875e-10
R_3_1_3_1 Node3_1_3 Node3_1_4 90588.23529411767
R_3_1_3_2 Node3_1_3 Node3_2_3 90588.23529411767
R_3_1_3_3 Node3_1_3 Node4_1_3 0.167552
C_3_1_3 Node3_1_3 GND 1.91748046875e-10
R_3_1_4_1 Node3_1_4 Node3_1_5 90588.23529411767
R_3_1_4_2 Node3_1_4 Node3_2_4 90588.23529411767
R_3_1_4_3 Node3_1_4 Node4_1_4 0.167552
C_3_1_4 Node3_1_4 GND 1.91748046875e-10
R_3_1_5_1 Node3_1_5 Node3_1_6 90588.23529411767
R_3_1_5_2 Node3_1_5 Node3_2_5 90588.23529411767
R_3_1_5_3 Node3_1_5 Node4_1_5 0.167552
C_3_1_5 Node3_1_5 GND 1.91748046875e-10
R_3_1_6_1 Node3_1_6 Node3_1_7 90588.23529411767
R_3_1_6_2 Node3_1_6 Node3_2_6 90588.23529411767
R_3_1_6_3 Node3_1_6 Node4_1_6 0.167552
C_3_1_6 Node3_1_6 GND 1.91748046875e-10
R_3_1_7_1 Node3_1_7 Node3_1_8 90588.23529411767
R_3_1_7_2 Node3_1_7 Node3_2_7 90588.23529411767
R_3_1_7_3 Node3_1_7 Node4_1_7 0.167552
C_3_1_7 Node3_1_7 GND 1.91748046875e-10
R_3_1_8_1 Node3_1_8 Node3_1_9 90588.23529411767
R_3_1_8_2 Node3_1_8 Node3_2_8 90588.23529411767
R_3_1_8_3 Node3_1_8 Node4_1_8 0.167552
C_3_1_8 Node3_1_8 GND 1.91748046875e-10
R_3_1_9_1 Node3_1_9 Node3_1_10 90588.23529411767
R_3_1_9_2 Node3_1_9 Node3_2_9 90588.23529411767
R_3_1_9_3 Node3_1_9 Node4_1_9 0.167552
C_3_1_9 Node3_1_9 GND 1.91748046875e-10
R_3_1_10_1 Node3_1_10 Node3_1_11 90588.23529411767
R_3_1_10_2 Node3_1_10 Node3_2_10 90588.23529411767
R_3_1_10_3 Node3_1_10 Node4_1_10 0.167552
C_3_1_10 Node3_1_10 GND 1.91748046875e-10
R_3_1_11_1 Node3_1_11 Node3_1_12 90588.23529411767
R_3_1_11_2 Node3_1_11 Node3_2_11 90588.23529411767
R_3_1_11_3 Node3_1_11 Node4_1_11 0.167552
C_3_1_11 Node3_1_11 GND 1.91748046875e-10
R_3_1_12_1 Node3_1_12 Node3_1_13 90588.23529411767
R_3_1_12_2 Node3_1_12 Node3_2_12 90588.23529411767
R_3_1_12_3 Node3_1_12 Node4_1_12 0.167552
C_3_1_12 Node3_1_12 GND 1.91748046875e-10
R_3_1_13_1 Node3_1_13 Node3_1_14 90588.23529411767
R_3_1_13_2 Node3_1_13 Node3_2_13 90588.23529411767
R_3_1_13_3 Node3_1_13 Node4_1_13 0.167552
C_3_1_13 Node3_1_13 GND 1.91748046875e-10
R_3_1_14_1 Node3_1_14 Node3_1_15 90588.23529411762
R_3_1_14_2 Node3_1_14 Node3_2_14 90588.23529411767
R_3_1_14_3 Node3_1_14 Node4_1_14 0.167552
C_3_1_14 Node3_1_14 GND 1.91748046875e-10
R_3_1_15_2 Node3_1_15 Node3_2_15 90588.23529411759
R_3_1_15_3 Node3_1_15 Node4_1_15 0.16755199999999984
C_3_1_15 Node3_1_15 GND 1.917480468750002e-10
R_3_2_0_1 Node3_2_0 Node3_2_1 90588.23529411767
R_3_2_0_2 Node3_2_0 Node3_3_0 90588.23529411767
R_3_2_0_3 Node3_2_0 Node4_2_0 0.167552
C_3_2_0 Node3_2_0 GND 1.91748046875e-10
R_3_2_1_1 Node3_2_1 Node3_2_2 90588.23529411767
R_3_2_1_2 Node3_2_1 Node3_3_1 90588.23529411767
R_3_2_1_3 Node3_2_1 Node4_2_1 0.167552
C_3_2_1 Node3_2_1 GND 1.91748046875e-10
R_3_2_2_1 Node3_2_2 Node3_2_3 90588.23529411767
R_3_2_2_2 Node3_2_2 Node3_3_2 90588.23529411767
R_3_2_2_3 Node3_2_2 Node4_2_2 0.167552
C_3_2_2 Node3_2_2 GND 1.91748046875e-10
R_3_2_3_1 Node3_2_3 Node3_2_4 90588.23529411767
R_3_2_3_2 Node3_2_3 Node3_3_3 90588.23529411767
R_3_2_3_3 Node3_2_3 Node4_2_3 0.167552
C_3_2_3 Node3_2_3 GND 1.91748046875e-10
R_3_2_4_1 Node3_2_4 Node3_2_5 90588.23529411767
R_3_2_4_2 Node3_2_4 Node3_3_4 90588.23529411767
R_3_2_4_3 Node3_2_4 Node4_2_4 0.167552
C_3_2_4 Node3_2_4 GND 1.91748046875e-10
R_3_2_5_1 Node3_2_5 Node3_2_6 90588.23529411767
R_3_2_5_2 Node3_2_5 Node3_3_5 90588.23529411767
R_3_2_5_3 Node3_2_5 Node4_2_5 0.167552
C_3_2_5 Node3_2_5 GND 1.91748046875e-10
R_3_2_6_1 Node3_2_6 Node3_2_7 90588.23529411767
R_3_2_6_2 Node3_2_6 Node3_3_6 90588.23529411767
R_3_2_6_3 Node3_2_6 Node4_2_6 0.167552
C_3_2_6 Node3_2_6 GND 1.91748046875e-10
R_3_2_7_1 Node3_2_7 Node3_2_8 90588.23529411767
R_3_2_7_2 Node3_2_7 Node3_3_7 90588.23529411767
R_3_2_7_3 Node3_2_7 Node4_2_7 0.167552
C_3_2_7 Node3_2_7 GND 1.91748046875e-10
R_3_2_8_1 Node3_2_8 Node3_2_9 90588.23529411767
R_3_2_8_2 Node3_2_8 Node3_3_8 90588.23529411767
R_3_2_8_3 Node3_2_8 Node4_2_8 0.167552
C_3_2_8 Node3_2_8 GND 1.91748046875e-10
R_3_2_9_1 Node3_2_9 Node3_2_10 90588.23529411767
R_3_2_9_2 Node3_2_9 Node3_3_9 90588.23529411767
R_3_2_9_3 Node3_2_9 Node4_2_9 0.167552
C_3_2_9 Node3_2_9 GND 1.91748046875e-10
R_3_2_10_1 Node3_2_10 Node3_2_11 90588.23529411767
R_3_2_10_2 Node3_2_10 Node3_3_10 90588.23529411767
R_3_2_10_3 Node3_2_10 Node4_2_10 0.167552
C_3_2_10 Node3_2_10 GND 1.91748046875e-10
R_3_2_11_1 Node3_2_11 Node3_2_12 90588.23529411767
R_3_2_11_2 Node3_2_11 Node3_3_11 90588.23529411767
R_3_2_11_3 Node3_2_11 Node4_2_11 0.167552
C_3_2_11 Node3_2_11 GND 1.91748046875e-10
R_3_2_12_1 Node3_2_12 Node3_2_13 90588.23529411767
R_3_2_12_2 Node3_2_12 Node3_3_12 90588.23529411767
R_3_2_12_3 Node3_2_12 Node4_2_12 0.167552
C_3_2_12 Node3_2_12 GND 1.91748046875e-10
R_3_2_13_1 Node3_2_13 Node3_2_14 90588.23529411767
R_3_2_13_2 Node3_2_13 Node3_3_13 90588.23529411767
R_3_2_13_3 Node3_2_13 Node4_2_13 0.167552
C_3_2_13 Node3_2_13 GND 1.91748046875e-10
R_3_2_14_1 Node3_2_14 Node3_2_15 90588.23529411762
R_3_2_14_2 Node3_2_14 Node3_3_14 90588.23529411767
R_3_2_14_3 Node3_2_14 Node4_2_14 0.167552
C_3_2_14 Node3_2_14 GND 1.91748046875e-10
R_3_2_15_2 Node3_2_15 Node3_3_15 90588.23529411759
R_3_2_15_3 Node3_2_15 Node4_2_15 0.16755199999999984
C_3_2_15 Node3_2_15 GND 1.917480468750002e-10
R_3_3_0_1 Node3_3_0 Node3_3_1 90588.23529411767
R_3_3_0_2 Node3_3_0 Node3_4_0 90588.23529411767
R_3_3_0_3 Node3_3_0 Node4_3_0 0.167552
C_3_3_0 Node3_3_0 GND 1.91748046875e-10
R_3_3_1_1 Node3_3_1 Node3_3_2 90588.23529411767
R_3_3_1_2 Node3_3_1 Node3_4_1 90588.23529411767
R_3_3_1_3 Node3_3_1 Node4_3_1 0.167552
C_3_3_1 Node3_3_1 GND 1.91748046875e-10
R_3_3_2_1 Node3_3_2 Node3_3_3 90588.23529411767
R_3_3_2_2 Node3_3_2 Node3_4_2 90588.23529411767
R_3_3_2_3 Node3_3_2 Node4_3_2 0.167552
C_3_3_2 Node3_3_2 GND 1.91748046875e-10
R_3_3_3_1 Node3_3_3 Node3_3_4 90588.23529411767
R_3_3_3_2 Node3_3_3 Node3_4_3 90588.23529411767
R_3_3_3_3 Node3_3_3 Node4_3_3 0.167552
C_3_3_3 Node3_3_3 GND 1.91748046875e-10
R_3_3_4_1 Node3_3_4 Node3_3_5 90588.23529411767
R_3_3_4_2 Node3_3_4 Node3_4_4 90588.23529411767
R_3_3_4_3 Node3_3_4 Node4_3_4 0.167552
C_3_3_4 Node3_3_4 GND 1.91748046875e-10
R_3_3_5_1 Node3_3_5 Node3_3_6 90588.23529411767
R_3_3_5_2 Node3_3_5 Node3_4_5 90588.23529411767
R_3_3_5_3 Node3_3_5 Node4_3_5 0.167552
C_3_3_5 Node3_3_5 GND 1.91748046875e-10
R_3_3_6_1 Node3_3_6 Node3_3_7 90588.23529411767
R_3_3_6_2 Node3_3_6 Node3_4_6 90588.23529411767
R_3_3_6_3 Node3_3_6 Node4_3_6 0.167552
C_3_3_6 Node3_3_6 GND 1.91748046875e-10
R_3_3_7_1 Node3_3_7 Node3_3_8 90588.23529411767
R_3_3_7_2 Node3_3_7 Node3_4_7 90588.23529411767
R_3_3_7_3 Node3_3_7 Node4_3_7 0.167552
C_3_3_7 Node3_3_7 GND 1.91748046875e-10
R_3_3_8_1 Node3_3_8 Node3_3_9 90588.23529411767
R_3_3_8_2 Node3_3_8 Node3_4_8 90588.23529411767
R_3_3_8_3 Node3_3_8 Node4_3_8 0.167552
C_3_3_8 Node3_3_8 GND 1.91748046875e-10
R_3_3_9_1 Node3_3_9 Node3_3_10 90588.23529411767
R_3_3_9_2 Node3_3_9 Node3_4_9 90588.23529411767
R_3_3_9_3 Node3_3_9 Node4_3_9 0.167552
C_3_3_9 Node3_3_9 GND 1.91748046875e-10
R_3_3_10_1 Node3_3_10 Node3_3_11 90588.23529411767
R_3_3_10_2 Node3_3_10 Node3_4_10 90588.23529411767
R_3_3_10_3 Node3_3_10 Node4_3_10 0.167552
C_3_3_10 Node3_3_10 GND 1.91748046875e-10
R_3_3_11_1 Node3_3_11 Node3_3_12 90588.23529411767
R_3_3_11_2 Node3_3_11 Node3_4_11 90588.23529411767
R_3_3_11_3 Node3_3_11 Node4_3_11 0.167552
C_3_3_11 Node3_3_11 GND 1.91748046875e-10
R_3_3_12_1 Node3_3_12 Node3_3_13 90588.23529411767
R_3_3_12_2 Node3_3_12 Node3_4_12 90588.23529411767
R_3_3_12_3 Node3_3_12 Node4_3_12 0.167552
C_3_3_12 Node3_3_12 GND 1.91748046875e-10
R_3_3_13_1 Node3_3_13 Node3_3_14 90588.23529411767
R_3_3_13_2 Node3_3_13 Node3_4_13 90588.23529411767
R_3_3_13_3 Node3_3_13 Node4_3_13 0.167552
C_3_3_13 Node3_3_13 GND 1.91748046875e-10
R_3_3_14_1 Node3_3_14 Node3_3_15 90588.23529411762
R_3_3_14_2 Node3_3_14 Node3_4_14 90588.23529411767
R_3_3_14_3 Node3_3_14 Node4_3_14 0.167552
C_3_3_14 Node3_3_14 GND 1.91748046875e-10
R_3_3_15_2 Node3_3_15 Node3_4_15 90588.23529411759
R_3_3_15_3 Node3_3_15 Node4_3_15 0.16755199999999984
C_3_3_15 Node3_3_15 GND 1.917480468750002e-10
R_3_4_0_1 Node3_4_0 Node3_4_1 90588.23529411767
R_3_4_0_2 Node3_4_0 Node3_5_0 90588.23529411767
R_3_4_0_3 Node3_4_0 Node4_4_0 0.167552
C_3_4_0 Node3_4_0 GND 1.91748046875e-10
R_3_4_1_1 Node3_4_1 Node3_4_2 90588.23529411767
R_3_4_1_2 Node3_4_1 Node3_5_1 90588.23529411767
R_3_4_1_3 Node3_4_1 Node4_4_1 0.167552
C_3_4_1 Node3_4_1 GND 1.91748046875e-10
R_3_4_2_1 Node3_4_2 Node3_4_3 90588.23529411767
R_3_4_2_2 Node3_4_2 Node3_5_2 90588.23529411767
R_3_4_2_3 Node3_4_2 Node4_4_2 0.167552
C_3_4_2 Node3_4_2 GND 1.91748046875e-10
R_3_4_3_1 Node3_4_3 Node3_4_4 90588.23529411767
R_3_4_3_2 Node3_4_3 Node3_5_3 90588.23529411767
R_3_4_3_3 Node3_4_3 Node4_4_3 0.167552
C_3_4_3 Node3_4_3 GND 1.91748046875e-10
R_3_4_4_1 Node3_4_4 Node3_4_5 90588.23529411767
R_3_4_4_2 Node3_4_4 Node3_5_4 90588.23529411767
R_3_4_4_3 Node3_4_4 Node4_4_4 0.167552
C_3_4_4 Node3_4_4 GND 1.91748046875e-10
R_3_4_5_1 Node3_4_5 Node3_4_6 90588.23529411767
R_3_4_5_2 Node3_4_5 Node3_5_5 90588.23529411767
R_3_4_5_3 Node3_4_5 Node4_4_5 0.167552
C_3_4_5 Node3_4_5 GND 1.91748046875e-10
R_3_4_6_1 Node3_4_6 Node3_4_7 90588.23529411767
R_3_4_6_2 Node3_4_6 Node3_5_6 90588.23529411767
R_3_4_6_3 Node3_4_6 Node4_4_6 0.167552
C_3_4_6 Node3_4_6 GND 1.91748046875e-10
R_3_4_7_1 Node3_4_7 Node3_4_8 90588.23529411767
R_3_4_7_2 Node3_4_7 Node3_5_7 90588.23529411767
R_3_4_7_3 Node3_4_7 Node4_4_7 0.167552
C_3_4_7 Node3_4_7 GND 1.91748046875e-10
R_3_4_8_1 Node3_4_8 Node3_4_9 90588.23529411767
R_3_4_8_2 Node3_4_8 Node3_5_8 90588.23529411767
R_3_4_8_3 Node3_4_8 Node4_4_8 0.167552
C_3_4_8 Node3_4_8 GND 1.91748046875e-10
R_3_4_9_1 Node3_4_9 Node3_4_10 90588.23529411767
R_3_4_9_2 Node3_4_9 Node3_5_9 90588.23529411767
R_3_4_9_3 Node3_4_9 Node4_4_9 0.167552
C_3_4_9 Node3_4_9 GND 1.91748046875e-10
R_3_4_10_1 Node3_4_10 Node3_4_11 90588.23529411767
R_3_4_10_2 Node3_4_10 Node3_5_10 90588.23529411767
R_3_4_10_3 Node3_4_10 Node4_4_10 0.167552
C_3_4_10 Node3_4_10 GND 1.91748046875e-10
R_3_4_11_1 Node3_4_11 Node3_4_12 90588.23529411767
R_3_4_11_2 Node3_4_11 Node3_5_11 90588.23529411767
R_3_4_11_3 Node3_4_11 Node4_4_11 0.167552
C_3_4_11 Node3_4_11 GND 1.91748046875e-10
R_3_4_12_1 Node3_4_12 Node3_4_13 90588.23529411767
R_3_4_12_2 Node3_4_12 Node3_5_12 90588.23529411767
R_3_4_12_3 Node3_4_12 Node4_4_12 0.167552
C_3_4_12 Node3_4_12 GND 1.91748046875e-10
R_3_4_13_1 Node3_4_13 Node3_4_14 90588.23529411767
R_3_4_13_2 Node3_4_13 Node3_5_13 90588.23529411767
R_3_4_13_3 Node3_4_13 Node4_4_13 0.167552
C_3_4_13 Node3_4_13 GND 1.91748046875e-10
R_3_4_14_1 Node3_4_14 Node3_4_15 90588.23529411762
R_3_4_14_2 Node3_4_14 Node3_5_14 90588.23529411767
R_3_4_14_3 Node3_4_14 Node4_4_14 0.167552
C_3_4_14 Node3_4_14 GND 1.91748046875e-10
R_3_4_15_2 Node3_4_15 Node3_5_15 90588.23529411759
R_3_4_15_3 Node3_4_15 Node4_4_15 0.16755199999999984
C_3_4_15 Node3_4_15 GND 1.917480468750002e-10
R_3_5_0_1 Node3_5_0 Node3_5_1 90588.23529411767
R_3_5_0_2 Node3_5_0 Node3_6_0 90588.23529411767
R_3_5_0_3 Node3_5_0 Node4_5_0 0.167552
C_3_5_0 Node3_5_0 GND 1.91748046875e-10
R_3_5_1_1 Node3_5_1 Node3_5_2 90588.23529411767
R_3_5_1_2 Node3_5_1 Node3_6_1 90588.23529411767
R_3_5_1_3 Node3_5_1 Node4_5_1 0.167552
C_3_5_1 Node3_5_1 GND 1.91748046875e-10
R_3_5_2_1 Node3_5_2 Node3_5_3 90588.23529411767
R_3_5_2_2 Node3_5_2 Node3_6_2 90588.23529411767
R_3_5_2_3 Node3_5_2 Node4_5_2 0.167552
C_3_5_2 Node3_5_2 GND 1.91748046875e-10
R_3_5_3_1 Node3_5_3 Node3_5_4 90588.23529411767
R_3_5_3_2 Node3_5_3 Node3_6_3 90588.23529411767
R_3_5_3_3 Node3_5_3 Node4_5_3 0.167552
C_3_5_3 Node3_5_3 GND 1.91748046875e-10
R_3_5_4_1 Node3_5_4 Node3_5_5 90588.23529411767
R_3_5_4_2 Node3_5_4 Node3_6_4 90588.23529411767
R_3_5_4_3 Node3_5_4 Node4_5_4 0.167552
C_3_5_4 Node3_5_4 GND 1.91748046875e-10
R_3_5_5_1 Node3_5_5 Node3_5_6 90588.23529411767
R_3_5_5_2 Node3_5_5 Node3_6_5 90588.23529411767
R_3_5_5_3 Node3_5_5 Node4_5_5 0.167552
C_3_5_5 Node3_5_5 GND 1.91748046875e-10
R_3_5_6_1 Node3_5_6 Node3_5_7 90588.23529411767
R_3_5_6_2 Node3_5_6 Node3_6_6 90588.23529411765
R_3_5_6_3 Node3_5_6 Node4_5_6 0.167552
C_3_5_6 Node3_5_6 GND 1.91748046875e-10
R_3_5_7_1 Node3_5_7 Node3_5_8 90588.23529411767
R_3_5_7_2 Node3_5_7 Node3_6_7 90588.23529411767
R_3_5_7_3 Node3_5_7 Node4_5_7 0.167552
C_3_5_7 Node3_5_7 GND 1.91748046875e-10
R_3_5_8_1 Node3_5_8 Node3_5_9 90588.23529411767
R_3_5_8_2 Node3_5_8 Node3_6_8 90588.23529411767
R_3_5_8_3 Node3_5_8 Node4_5_8 0.167552
C_3_5_8 Node3_5_8 GND 1.91748046875e-10
R_3_5_9_1 Node3_5_9 Node3_5_10 90588.23529411767
R_3_5_9_2 Node3_5_9 Node3_6_9 90588.23529411765
R_3_5_9_3 Node3_5_9 Node4_5_9 0.167552
C_3_5_9 Node3_5_9 GND 1.91748046875e-10
R_3_5_10_1 Node3_5_10 Node3_5_11 90588.23529411767
R_3_5_10_2 Node3_5_10 Node3_6_10 90588.23529411767
R_3_5_10_3 Node3_5_10 Node4_5_10 0.167552
C_3_5_10 Node3_5_10 GND 1.91748046875e-10
R_3_5_11_1 Node3_5_11 Node3_5_12 90588.23529411767
R_3_5_11_2 Node3_5_11 Node3_6_11 90588.23529411767
R_3_5_11_3 Node3_5_11 Node4_5_11 0.167552
C_3_5_11 Node3_5_11 GND 1.91748046875e-10
R_3_5_12_1 Node3_5_12 Node3_5_13 90588.23529411767
R_3_5_12_2 Node3_5_12 Node3_6_12 90588.23529411767
R_3_5_12_3 Node3_5_12 Node4_5_12 0.167552
C_3_5_12 Node3_5_12 GND 1.91748046875e-10
R_3_5_13_1 Node3_5_13 Node3_5_14 90588.23529411767
R_3_5_13_2 Node3_5_13 Node3_6_13 90588.23529411767
R_3_5_13_3 Node3_5_13 Node4_5_13 0.167552
C_3_5_13 Node3_5_13 GND 1.91748046875e-10
R_3_5_14_1 Node3_5_14 Node3_5_15 90588.23529411762
R_3_5_14_2 Node3_5_14 Node3_6_14 90588.23529411767
R_3_5_14_3 Node3_5_14 Node4_5_14 0.167552
C_3_5_14 Node3_5_14 GND 1.91748046875e-10
R_3_5_15_2 Node3_5_15 Node3_6_15 90588.23529411759
R_3_5_15_3 Node3_5_15 Node4_5_15 0.16755199999999984
C_3_5_15 Node3_5_15 GND 1.917480468750002e-10
R_3_6_0_1 Node3_6_0 Node3_6_1 90588.23529411767
R_3_6_0_2 Node3_6_0 Node3_7_0 90588.23529411767
R_3_6_0_3 Node3_6_0 Node4_6_0 0.16755199999999998
C_3_6_0 Node3_6_0 GND 1.9174804687500003e-10
R_3_6_1_1 Node3_6_1 Node3_6_2 90588.23529411767
R_3_6_1_2 Node3_6_1 Node3_7_1 90588.23529411767
R_3_6_1_3 Node3_6_1 Node4_6_1 0.167552
C_3_6_1 Node3_6_1 GND 1.91748046875e-10
R_3_6_2_1 Node3_6_2 Node3_6_3 90588.23529411767
R_3_6_2_2 Node3_6_2 Node3_7_2 90588.23529411767
R_3_6_2_3 Node3_6_2 Node4_6_2 0.167552
C_3_6_2 Node3_6_2 GND 1.91748046875e-10
R_3_6_3_1 Node3_6_3 Node3_6_4 90588.23529411767
R_3_6_3_2 Node3_6_3 Node3_7_3 90588.23529411767
R_3_6_3_3 Node3_6_3 Node4_6_3 0.167552
C_3_6_3 Node3_6_3 GND 1.91748046875e-10
R_3_6_4_1 Node3_6_4 Node3_6_5 90588.23529411767
R_3_6_4_2 Node3_6_4 Node3_7_4 90588.23529411767
R_3_6_4_3 Node3_6_4 Node4_6_4 0.167552
C_3_6_4 Node3_6_4 GND 1.91748046875e-10
R_3_6_5_1 Node3_6_5 Node3_6_6 90588.23529411765
R_3_6_5_2 Node3_6_5 Node3_7_5 90588.23529411767
R_3_6_5_3 Node3_6_5 Node4_6_5 0.167552
C_3_6_5 Node3_6_5 GND 1.91748046875e-10
R_3_6_6_1 Node3_6_6 Node3_6_7 90588.23529411765
R_3_6_6_2 Node3_6_6 Node3_7_6 90588.23529411765
R_3_6_6_3 Node3_6_6 Node4_6_6 0.16755199999999998
C_3_6_6 Node3_6_6 GND 1.9174804687500003e-10
R_3_6_7_1 Node3_6_7 Node3_6_8 90588.23529411767
R_3_6_7_2 Node3_6_7 Node3_7_7 90588.23529411767
R_3_6_7_3 Node3_6_7 Node4_6_7 0.167552
C_3_6_7 Node3_6_7 GND 1.91748046875e-10
R_3_6_8_1 Node3_6_8 Node3_6_9 90588.23529411765
R_3_6_8_2 Node3_6_8 Node3_7_8 90588.23529411767
R_3_6_8_3 Node3_6_8 Node4_6_8 0.167552
C_3_6_8 Node3_6_8 GND 1.91748046875e-10
R_3_6_9_1 Node3_6_9 Node3_6_10 90588.23529411765
R_3_6_9_2 Node3_6_9 Node3_7_9 90588.2352941176
R_3_6_9_3 Node3_6_9 Node4_6_9 0.1675519999999999
C_3_6_9 Node3_6_9 GND 1.917480468750001e-10
R_3_6_10_1 Node3_6_10 Node3_6_11 90588.23529411767
R_3_6_10_2 Node3_6_10 Node3_7_10 90588.23529411767
R_3_6_10_3 Node3_6_10 Node4_6_10 0.167552
C_3_6_10 Node3_6_10 GND 1.91748046875e-10
R_3_6_11_1 Node3_6_11 Node3_6_12 90588.23529411767
R_3_6_11_2 Node3_6_11 Node3_7_11 90588.23529411767
R_3_6_11_3 Node3_6_11 Node4_6_11 0.167552
C_3_6_11 Node3_6_11 GND 1.91748046875e-10
R_3_6_12_1 Node3_6_12 Node3_6_13 90588.23529411767
R_3_6_12_2 Node3_6_12 Node3_7_12 90588.23529411767
R_3_6_12_3 Node3_6_12 Node4_6_12 0.167552
C_3_6_12 Node3_6_12 GND 1.91748046875e-10
R_3_6_13_1 Node3_6_13 Node3_6_14 90588.23529411767
R_3_6_13_2 Node3_6_13 Node3_7_13 90588.23529411767
R_3_6_13_3 Node3_6_13 Node4_6_13 0.167552
C_3_6_13 Node3_6_13 GND 1.91748046875e-10
R_3_6_14_1 Node3_6_14 Node3_6_15 90588.23529411762
R_3_6_14_2 Node3_6_14 Node3_7_14 90588.23529411767
R_3_6_14_3 Node3_6_14 Node4_6_14 0.167552
C_3_6_14 Node3_6_14 GND 1.91748046875e-10
R_3_6_15_2 Node3_6_15 Node3_7_15 90588.23529411759
R_3_6_15_3 Node3_6_15 Node4_6_15 0.16755199999999984
C_3_6_15 Node3_6_15 GND 1.917480468750002e-10
R_3_7_0_1 Node3_7_0 Node3_7_1 90588.23529411767
R_3_7_0_2 Node3_7_0 Node3_8_0 90588.23529411767
R_3_7_0_3 Node3_7_0 Node4_7_0 0.167552
C_3_7_0 Node3_7_0 GND 1.91748046875e-10
R_3_7_1_1 Node3_7_1 Node3_7_2 90588.23529411767
R_3_7_1_2 Node3_7_1 Node3_8_1 90588.23529411767
R_3_7_1_3 Node3_7_1 Node4_7_1 0.167552
C_3_7_1 Node3_7_1 GND 1.91748046875e-10
R_3_7_2_1 Node3_7_2 Node3_7_3 90588.23529411767
R_3_7_2_2 Node3_7_2 Node3_8_2 90588.23529411767
R_3_7_2_3 Node3_7_2 Node4_7_2 0.167552
C_3_7_2 Node3_7_2 GND 1.91748046875e-10
R_3_7_3_1 Node3_7_3 Node3_7_4 90588.23529411767
R_3_7_3_2 Node3_7_3 Node3_8_3 90588.23529411767
R_3_7_3_3 Node3_7_3 Node4_7_3 0.167552
C_3_7_3 Node3_7_3 GND 1.91748046875e-10
R_3_7_4_1 Node3_7_4 Node3_7_5 90588.23529411767
R_3_7_4_2 Node3_7_4 Node3_8_4 90588.23529411767
R_3_7_4_3 Node3_7_4 Node4_7_4 0.167552
C_3_7_4 Node3_7_4 GND 1.91748046875e-10
R_3_7_5_1 Node3_7_5 Node3_7_6 90588.23529411767
R_3_7_5_2 Node3_7_5 Node3_8_5 90588.23529411767
R_3_7_5_3 Node3_7_5 Node4_7_5 0.167552
C_3_7_5 Node3_7_5 GND 1.91748046875e-10
R_3_7_6_1 Node3_7_6 Node3_7_7 90588.23529411767
R_3_7_6_2 Node3_7_6 Node3_8_6 90588.23529411767
R_3_7_6_3 Node3_7_6 Node4_7_6 0.16755199999999998
C_3_7_6 Node3_7_6 GND 1.9174804687500003e-10
R_3_7_7_1 Node3_7_7 Node3_7_8 90588.23529411767
R_3_7_7_2 Node3_7_7 Node3_8_7 90588.23529411767
R_3_7_7_3 Node3_7_7 Node4_7_7 0.167552
C_3_7_7 Node3_7_7 GND 1.91748046875e-10
R_3_7_8_1 Node3_7_8 Node3_7_9 90588.23529411762
R_3_7_8_2 Node3_7_8 Node3_8_8 90588.23529411767
R_3_7_8_3 Node3_7_8 Node4_7_8 0.167552
C_3_7_8 Node3_7_8 GND 1.91748046875e-10
R_3_7_9_1 Node3_7_9 Node3_7_10 90588.23529411762
R_3_7_9_2 Node3_7_9 Node3_8_9 90588.23529411759
R_3_7_9_3 Node3_7_9 Node4_7_9 0.16755199999999987
C_3_7_9 Node3_7_9 GND 1.917480468750002e-10
R_3_7_10_1 Node3_7_10 Node3_7_11 90588.23529411767
R_3_7_10_2 Node3_7_10 Node3_8_10 90588.23529411767
R_3_7_10_3 Node3_7_10 Node4_7_10 0.167552
C_3_7_10 Node3_7_10 GND 1.91748046875e-10
R_3_7_11_1 Node3_7_11 Node3_7_12 90588.23529411767
R_3_7_11_2 Node3_7_11 Node3_8_11 90588.23529411767
R_3_7_11_3 Node3_7_11 Node4_7_11 0.167552
C_3_7_11 Node3_7_11 GND 1.91748046875e-10
R_3_7_12_1 Node3_7_12 Node3_7_13 90588.23529411767
R_3_7_12_2 Node3_7_12 Node3_8_12 90588.23529411767
R_3_7_12_3 Node3_7_12 Node4_7_12 0.167552
C_3_7_12 Node3_7_12 GND 1.91748046875e-10
R_3_7_13_1 Node3_7_13 Node3_7_14 90588.23529411767
R_3_7_13_2 Node3_7_13 Node3_8_13 90588.23529411767
R_3_7_13_3 Node3_7_13 Node4_7_13 0.167552
C_3_7_13 Node3_7_13 GND 1.91748046875e-10
R_3_7_14_1 Node3_7_14 Node3_7_15 90588.23529411762
R_3_7_14_2 Node3_7_14 Node3_8_14 90588.23529411767
R_3_7_14_3 Node3_7_14 Node4_7_14 0.167552
C_3_7_14 Node3_7_14 GND 1.91748046875e-10
R_3_7_15_2 Node3_7_15 Node3_8_15 90588.23529411759
R_3_7_15_3 Node3_7_15 Node4_7_15 0.16755199999999984
C_3_7_15 Node3_7_15 GND 1.917480468750002e-10
R_3_8_0_1 Node3_8_0 Node3_8_1 90588.23529411767
R_3_8_0_2 Node3_8_0 Node3_9_0 90588.23529411771
R_3_8_0_3 Node3_8_0 Node4_8_0 0.167552
C_3_8_0 Node3_8_0 GND 1.91748046875e-10
R_3_8_1_1 Node3_8_1 Node3_8_2 90588.23529411767
R_3_8_1_2 Node3_8_1 Node3_9_1 90588.23529411771
R_3_8_1_3 Node3_8_1 Node4_8_1 0.167552
C_3_8_1 Node3_8_1 GND 1.91748046875e-10
R_3_8_2_1 Node3_8_2 Node3_8_3 90588.23529411767
R_3_8_2_2 Node3_8_2 Node3_9_2 90588.23529411771
R_3_8_2_3 Node3_8_2 Node4_8_2 0.167552
C_3_8_2 Node3_8_2 GND 1.91748046875e-10
R_3_8_3_1 Node3_8_3 Node3_8_4 90588.23529411767
R_3_8_3_2 Node3_8_3 Node3_9_3 90588.23529411771
R_3_8_3_3 Node3_8_3 Node4_8_3 0.167552
C_3_8_3 Node3_8_3 GND 1.91748046875e-10
R_3_8_4_1 Node3_8_4 Node3_8_5 90588.23529411767
R_3_8_4_2 Node3_8_4 Node3_9_4 90588.23529411771
R_3_8_4_3 Node3_8_4 Node4_8_4 0.167552
C_3_8_4 Node3_8_4 GND 1.91748046875e-10
R_3_8_5_1 Node3_8_5 Node3_8_6 90588.23529411767
R_3_8_5_2 Node3_8_5 Node3_9_5 90588.23529411771
R_3_8_5_3 Node3_8_5 Node4_8_5 0.167552
C_3_8_5 Node3_8_5 GND 1.91748046875e-10
R_3_8_6_1 Node3_8_6 Node3_8_7 90588.23529411767
R_3_8_6_2 Node3_8_6 Node3_9_6 90588.23529411771
R_3_8_6_3 Node3_8_6 Node4_8_6 0.16755199999999998
C_3_8_6 Node3_8_6 GND 1.9174804687500003e-10
R_3_8_7_1 Node3_8_7 Node3_8_8 90588.23529411767
R_3_8_7_2 Node3_8_7 Node3_9_7 90588.23529411771
R_3_8_7_3 Node3_8_7 Node4_8_7 0.167552
C_3_8_7 Node3_8_7 GND 1.91748046875e-10
R_3_8_8_1 Node3_8_8 Node3_8_9 90588.23529411762
R_3_8_8_2 Node3_8_8 Node3_9_8 90588.23529411771
R_3_8_8_3 Node3_8_8 Node4_8_8 0.167552
C_3_8_8 Node3_8_8 GND 1.91748046875e-10
R_3_8_9_1 Node3_8_9 Node3_8_10 90588.23529411762
R_3_8_9_2 Node3_8_9 Node3_9_9 90588.23529411765
R_3_8_9_3 Node3_8_9 Node4_8_9 0.16755199999999987
C_3_8_9 Node3_8_9 GND 1.917480468750002e-10
R_3_8_10_1 Node3_8_10 Node3_8_11 90588.23529411767
R_3_8_10_2 Node3_8_10 Node3_9_10 90588.23529411771
R_3_8_10_3 Node3_8_10 Node4_8_10 0.167552
C_3_8_10 Node3_8_10 GND 1.91748046875e-10
R_3_8_11_1 Node3_8_11 Node3_8_12 90588.23529411767
R_3_8_11_2 Node3_8_11 Node3_9_11 90588.23529411771
R_3_8_11_3 Node3_8_11 Node4_8_11 0.167552
C_3_8_11 Node3_8_11 GND 1.91748046875e-10
R_3_8_12_1 Node3_8_12 Node3_8_13 90588.23529411767
R_3_8_12_2 Node3_8_12 Node3_9_12 90588.23529411771
R_3_8_12_3 Node3_8_12 Node4_8_12 0.167552
C_3_8_12 Node3_8_12 GND 1.91748046875e-10
R_3_8_13_1 Node3_8_13 Node3_8_14 90588.23529411767
R_3_8_13_2 Node3_8_13 Node3_9_13 90588.23529411771
R_3_8_13_3 Node3_8_13 Node4_8_13 0.167552
C_3_8_13 Node3_8_13 GND 1.91748046875e-10
R_3_8_14_1 Node3_8_14 Node3_8_15 90588.23529411762
R_3_8_14_2 Node3_8_14 Node3_9_14 90588.23529411771
R_3_8_14_3 Node3_8_14 Node4_8_14 0.167552
C_3_8_14 Node3_8_14 GND 1.91748046875e-10
R_3_8_15_2 Node3_8_15 Node3_9_15 90588.23529411762
R_3_8_15_3 Node3_8_15 Node4_8_15 0.16755199999999984
C_3_8_15 Node3_8_15 GND 1.917480468750002e-10
R_3_9_0_1 Node3_9_0 Node3_9_1 90588.23529411774
R_3_9_0_2 Node3_9_0 Node3_10_0 90588.23529411771
R_3_9_0_3 Node3_9_0 Node4_9_0 0.16755200000000012
C_3_9_0 Node3_9_0 GND 1.9174804687499988e-10
R_3_9_1_1 Node3_9_1 Node3_9_2 90588.23529411775
R_3_9_1_2 Node3_9_1 Node3_10_1 90588.23529411771
R_3_9_1_3 Node3_9_1 Node4_9_1 0.16755200000000012
C_3_9_1 Node3_9_1 GND 1.9174804687499985e-10
R_3_9_2_1 Node3_9_2 Node3_9_3 90588.23529411775
R_3_9_2_2 Node3_9_2 Node3_10_2 90588.23529411771
R_3_9_2_3 Node3_9_2 Node4_9_2 0.16755200000000012
C_3_9_2 Node3_9_2 GND 1.9174804687499985e-10
R_3_9_3_1 Node3_9_3 Node3_9_4 90588.23529411775
R_3_9_3_2 Node3_9_3 Node3_10_3 90588.23529411771
R_3_9_3_3 Node3_9_3 Node4_9_3 0.16755200000000012
C_3_9_3 Node3_9_3 GND 1.9174804687499985e-10
R_3_9_4_1 Node3_9_4 Node3_9_5 90588.23529411775
R_3_9_4_2 Node3_9_4 Node3_10_4 90588.23529411771
R_3_9_4_3 Node3_9_4 Node4_9_4 0.16755200000000012
C_3_9_4 Node3_9_4 GND 1.9174804687499985e-10
R_3_9_5_1 Node3_9_5 Node3_9_6 90588.23529411775
R_3_9_5_2 Node3_9_5 Node3_10_5 90588.23529411771
R_3_9_5_3 Node3_9_5 Node4_9_5 0.16755200000000012
C_3_9_5 Node3_9_5 GND 1.9174804687499985e-10
R_3_9_6_1 Node3_9_6 Node3_9_7 90588.23529411775
R_3_9_6_2 Node3_9_6 Node3_10_6 90588.23529411771
R_3_9_6_3 Node3_9_6 Node4_9_6 0.16755200000000012
C_3_9_6 Node3_9_6 GND 1.9174804687499983e-10
R_3_9_7_1 Node3_9_7 Node3_9_8 90588.23529411775
R_3_9_7_2 Node3_9_7 Node3_10_7 90588.23529411771
R_3_9_7_3 Node3_9_7 Node4_9_7 0.16755200000000012
C_3_9_7 Node3_9_7 GND 1.9174804687499985e-10
R_3_9_8_1 Node3_9_8 Node3_9_9 90588.23529411772
R_3_9_8_2 Node3_9_8 Node3_10_8 90588.23529411771
R_3_9_8_3 Node3_9_8 Node4_9_8 0.16755200000000012
C_3_9_8 Node3_9_8 GND 1.9174804687499985e-10
R_3_9_9_1 Node3_9_9 Node3_9_10 90588.23529411772
R_3_9_9_2 Node3_9_9 Node3_10_9 90588.23529411768
R_3_9_9_3 Node3_9_9 Node4_9_9 0.16755200000000006
C_3_9_9 Node3_9_9 GND 1.9174804687499993e-10
R_3_9_10_1 Node3_9_10 Node3_9_11 90588.23529411775
R_3_9_10_2 Node3_9_10 Node3_10_10 90588.23529411771
R_3_9_10_3 Node3_9_10 Node4_9_10 0.16755200000000012
C_3_9_10 Node3_9_10 GND 1.9174804687499985e-10
R_3_9_11_1 Node3_9_11 Node3_9_12 90588.23529411775
R_3_9_11_2 Node3_9_11 Node3_10_11 90588.23529411771
R_3_9_11_3 Node3_9_11 Node4_9_11 0.16755200000000012
C_3_9_11 Node3_9_11 GND 1.9174804687499985e-10
R_3_9_12_1 Node3_9_12 Node3_9_13 90588.23529411775
R_3_9_12_2 Node3_9_12 Node3_10_12 90588.23529411771
R_3_9_12_3 Node3_9_12 Node4_9_12 0.16755200000000012
C_3_9_12 Node3_9_12 GND 1.9174804687499985e-10
R_3_9_13_1 Node3_9_13 Node3_9_14 90588.23529411775
R_3_9_13_2 Node3_9_13 Node3_10_13 90588.23529411771
R_3_9_13_3 Node3_9_13 Node4_9_13 0.16755200000000012
C_3_9_13 Node3_9_13 GND 1.9174804687499985e-10
R_3_9_14_1 Node3_9_14 Node3_9_15 90588.23529411771
R_3_9_14_2 Node3_9_14 Node3_10_14 90588.23529411771
R_3_9_14_3 Node3_9_14 Node4_9_14 0.16755200000000012
C_3_9_14 Node3_9_14 GND 1.9174804687499985e-10
R_3_9_15_2 Node3_9_15 Node3_10_15 90588.23529411762
R_3_9_15_3 Node3_9_15 Node4_9_15 0.167552
C_3_9_15 Node3_9_15 GND 1.91748046875e-10
R_3_10_0_1 Node3_10_0 Node3_10_1 90588.23529411767
R_3_10_0_2 Node3_10_0 Node3_11_0 90588.23529411767
R_3_10_0_3 Node3_10_0 Node4_10_0 0.167552
C_3_10_0 Node3_10_0 GND 1.91748046875e-10
R_3_10_1_1 Node3_10_1 Node3_10_2 90588.23529411767
R_3_10_1_2 Node3_10_1 Node3_11_1 90588.23529411767
R_3_10_1_3 Node3_10_1 Node4_10_1 0.167552
C_3_10_1 Node3_10_1 GND 1.91748046875e-10
R_3_10_2_1 Node3_10_2 Node3_10_3 90588.23529411767
R_3_10_2_2 Node3_10_2 Node3_11_2 90588.23529411767
R_3_10_2_3 Node3_10_2 Node4_10_2 0.167552
C_3_10_2 Node3_10_2 GND 1.91748046875e-10
R_3_10_3_1 Node3_10_3 Node3_10_4 90588.23529411767
R_3_10_3_2 Node3_10_3 Node3_11_3 90588.23529411767
R_3_10_3_3 Node3_10_3 Node4_10_3 0.167552
C_3_10_3 Node3_10_3 GND 1.91748046875e-10
R_3_10_4_1 Node3_10_4 Node3_10_5 90588.23529411767
R_3_10_4_2 Node3_10_4 Node3_11_4 90588.23529411767
R_3_10_4_3 Node3_10_4 Node4_10_4 0.167552
C_3_10_4 Node3_10_4 GND 1.91748046875e-10
R_3_10_5_1 Node3_10_5 Node3_10_6 90588.23529411767
R_3_10_5_2 Node3_10_5 Node3_11_5 90588.23529411767
R_3_10_5_3 Node3_10_5 Node4_10_5 0.167552
C_3_10_5 Node3_10_5 GND 1.91748046875e-10
R_3_10_6_1 Node3_10_6 Node3_10_7 90588.23529411767
R_3_10_6_2 Node3_10_6 Node3_11_6 90588.23529411767
R_3_10_6_3 Node3_10_6 Node4_10_6 0.167552
C_3_10_6 Node3_10_6 GND 1.91748046875e-10
R_3_10_7_1 Node3_10_7 Node3_10_8 90588.23529411767
R_3_10_7_2 Node3_10_7 Node3_11_7 90588.23529411767
R_3_10_7_3 Node3_10_7 Node4_10_7 0.167552
C_3_10_7 Node3_10_7 GND 1.91748046875e-10
R_3_10_8_1 Node3_10_8 Node3_10_9 90588.23529411767
R_3_10_8_2 Node3_10_8 Node3_11_8 90588.23529411767
R_3_10_8_3 Node3_10_8 Node4_10_8 0.167552
C_3_10_8 Node3_10_8 GND 1.91748046875e-10
R_3_10_9_1 Node3_10_9 Node3_10_10 90588.23529411767
R_3_10_9_2 Node3_10_9 Node3_11_9 90588.23529411767
R_3_10_9_3 Node3_10_9 Node4_10_9 0.167552
C_3_10_9 Node3_10_9 GND 1.91748046875e-10
R_3_10_10_1 Node3_10_10 Node3_10_11 90588.23529411767
R_3_10_10_2 Node3_10_10 Node3_11_10 90588.23529411767
R_3_10_10_3 Node3_10_10 Node4_10_10 0.167552
C_3_10_10 Node3_10_10 GND 1.91748046875e-10
R_3_10_11_1 Node3_10_11 Node3_10_12 90588.23529411767
R_3_10_11_2 Node3_10_11 Node3_11_11 90588.23529411767
R_3_10_11_3 Node3_10_11 Node4_10_11 0.167552
C_3_10_11 Node3_10_11 GND 1.91748046875e-10
R_3_10_12_1 Node3_10_12 Node3_10_13 90588.23529411767
R_3_10_12_2 Node3_10_12 Node3_11_12 90588.23529411767
R_3_10_12_3 Node3_10_12 Node4_10_12 0.167552
C_3_10_12 Node3_10_12 GND 1.91748046875e-10
R_3_10_13_1 Node3_10_13 Node3_10_14 90588.23529411767
R_3_10_13_2 Node3_10_13 Node3_11_13 90588.23529411767
R_3_10_13_3 Node3_10_13 Node4_10_13 0.167552
C_3_10_13 Node3_10_13 GND 1.91748046875e-10
R_3_10_14_1 Node3_10_14 Node3_10_15 90588.23529411762
R_3_10_14_2 Node3_10_14 Node3_11_14 90588.23529411767
R_3_10_14_3 Node3_10_14 Node4_10_14 0.167552
C_3_10_14 Node3_10_14 GND 1.91748046875e-10
R_3_10_15_2 Node3_10_15 Node3_11_15 90588.23529411759
R_3_10_15_3 Node3_10_15 Node4_10_15 0.16755199999999984
C_3_10_15 Node3_10_15 GND 1.917480468750002e-10
R_3_11_0_1 Node3_11_0 Node3_11_1 90588.23529411767
R_3_11_0_2 Node3_11_0 Node3_12_0 90588.23529411767
R_3_11_0_3 Node3_11_0 Node4_11_0 0.167552
C_3_11_0 Node3_11_0 GND 1.91748046875e-10
R_3_11_1_1 Node3_11_1 Node3_11_2 90588.23529411767
R_3_11_1_2 Node3_11_1 Node3_12_1 90588.23529411767
R_3_11_1_3 Node3_11_1 Node4_11_1 0.167552
C_3_11_1 Node3_11_1 GND 1.91748046875e-10
R_3_11_2_1 Node3_11_2 Node3_11_3 90588.23529411767
R_3_11_2_2 Node3_11_2 Node3_12_2 90588.23529411767
R_3_11_2_3 Node3_11_2 Node4_11_2 0.167552
C_3_11_2 Node3_11_2 GND 1.91748046875e-10
R_3_11_3_1 Node3_11_3 Node3_11_4 90588.23529411767
R_3_11_3_2 Node3_11_3 Node3_12_3 90588.23529411767
R_3_11_3_3 Node3_11_3 Node4_11_3 0.167552
C_3_11_3 Node3_11_3 GND 1.91748046875e-10
R_3_11_4_1 Node3_11_4 Node3_11_5 90588.23529411767
R_3_11_4_2 Node3_11_4 Node3_12_4 90588.23529411767
R_3_11_4_3 Node3_11_4 Node4_11_4 0.167552
C_3_11_4 Node3_11_4 GND 1.91748046875e-10
R_3_11_5_1 Node3_11_5 Node3_11_6 90588.23529411767
R_3_11_5_2 Node3_11_5 Node3_12_5 90588.23529411767
R_3_11_5_3 Node3_11_5 Node4_11_5 0.167552
C_3_11_5 Node3_11_5 GND 1.91748046875e-10
R_3_11_6_1 Node3_11_6 Node3_11_7 90588.23529411767
R_3_11_6_2 Node3_11_6 Node3_12_6 90588.23529411767
R_3_11_6_3 Node3_11_6 Node4_11_6 0.167552
C_3_11_6 Node3_11_6 GND 1.91748046875e-10
R_3_11_7_1 Node3_11_7 Node3_11_8 90588.23529411767
R_3_11_7_2 Node3_11_7 Node3_12_7 90588.23529411767
R_3_11_7_3 Node3_11_7 Node4_11_7 0.167552
C_3_11_7 Node3_11_7 GND 1.91748046875e-10
R_3_11_8_1 Node3_11_8 Node3_11_9 90588.23529411767
R_3_11_8_2 Node3_11_8 Node3_12_8 90588.23529411767
R_3_11_8_3 Node3_11_8 Node4_11_8 0.167552
C_3_11_8 Node3_11_8 GND 1.91748046875e-10
R_3_11_9_1 Node3_11_9 Node3_11_10 90588.23529411767
R_3_11_9_2 Node3_11_9 Node3_12_9 90588.23529411767
R_3_11_9_3 Node3_11_9 Node4_11_9 0.167552
C_3_11_9 Node3_11_9 GND 1.91748046875e-10
R_3_11_10_1 Node3_11_10 Node3_11_11 90588.23529411767
R_3_11_10_2 Node3_11_10 Node3_12_10 90588.23529411767
R_3_11_10_3 Node3_11_10 Node4_11_10 0.167552
C_3_11_10 Node3_11_10 GND 1.91748046875e-10
R_3_11_11_1 Node3_11_11 Node3_11_12 90588.23529411767
R_3_11_11_2 Node3_11_11 Node3_12_11 90588.23529411767
R_3_11_11_3 Node3_11_11 Node4_11_11 0.167552
C_3_11_11 Node3_11_11 GND 1.91748046875e-10
R_3_11_12_1 Node3_11_12 Node3_11_13 90588.23529411767
R_3_11_12_2 Node3_11_12 Node3_12_12 90588.23529411767
R_3_11_12_3 Node3_11_12 Node4_11_12 0.167552
C_3_11_12 Node3_11_12 GND 1.91748046875e-10
R_3_11_13_1 Node3_11_13 Node3_11_14 90588.23529411767
R_3_11_13_2 Node3_11_13 Node3_12_13 90588.23529411767
R_3_11_13_3 Node3_11_13 Node4_11_13 0.167552
C_3_11_13 Node3_11_13 GND 1.91748046875e-10
R_3_11_14_1 Node3_11_14 Node3_11_15 90588.23529411762
R_3_11_14_2 Node3_11_14 Node3_12_14 90588.23529411767
R_3_11_14_3 Node3_11_14 Node4_11_14 0.167552
C_3_11_14 Node3_11_14 GND 1.91748046875e-10
R_3_11_15_2 Node3_11_15 Node3_12_15 90588.23529411759
R_3_11_15_3 Node3_11_15 Node4_11_15 0.16755199999999984
C_3_11_15 Node3_11_15 GND 1.917480468750002e-10
R_3_12_0_1 Node3_12_0 Node3_12_1 90588.23529411767
R_3_12_0_2 Node3_12_0 Node3_13_0 90588.23529411767
R_3_12_0_3 Node3_12_0 Node4_12_0 0.167552
C_3_12_0 Node3_12_0 GND 1.91748046875e-10
R_3_12_1_1 Node3_12_1 Node3_12_2 90588.23529411767
R_3_12_1_2 Node3_12_1 Node3_13_1 90588.23529411767
R_3_12_1_3 Node3_12_1 Node4_12_1 0.167552
C_3_12_1 Node3_12_1 GND 1.91748046875e-10
R_3_12_2_1 Node3_12_2 Node3_12_3 90588.23529411767
R_3_12_2_2 Node3_12_2 Node3_13_2 90588.23529411767
R_3_12_2_3 Node3_12_2 Node4_12_2 0.167552
C_3_12_2 Node3_12_2 GND 1.91748046875e-10
R_3_12_3_1 Node3_12_3 Node3_12_4 90588.23529411767
R_3_12_3_2 Node3_12_3 Node3_13_3 90588.23529411767
R_3_12_3_3 Node3_12_3 Node4_12_3 0.167552
C_3_12_3 Node3_12_3 GND 1.91748046875e-10
R_3_12_4_1 Node3_12_4 Node3_12_5 90588.23529411767
R_3_12_4_2 Node3_12_4 Node3_13_4 90588.23529411767
R_3_12_4_3 Node3_12_4 Node4_12_4 0.167552
C_3_12_4 Node3_12_4 GND 1.91748046875e-10
R_3_12_5_1 Node3_12_5 Node3_12_6 90588.23529411767
R_3_12_5_2 Node3_12_5 Node3_13_5 90588.23529411767
R_3_12_5_3 Node3_12_5 Node4_12_5 0.167552
C_3_12_5 Node3_12_5 GND 1.91748046875e-10
R_3_12_6_1 Node3_12_6 Node3_12_7 90588.23529411767
R_3_12_6_2 Node3_12_6 Node3_13_6 90588.23529411767
R_3_12_6_3 Node3_12_6 Node4_12_6 0.167552
C_3_12_6 Node3_12_6 GND 1.91748046875e-10
R_3_12_7_1 Node3_12_7 Node3_12_8 90588.23529411767
R_3_12_7_2 Node3_12_7 Node3_13_7 90588.23529411767
R_3_12_7_3 Node3_12_7 Node4_12_7 0.167552
C_3_12_7 Node3_12_7 GND 1.91748046875e-10
R_3_12_8_1 Node3_12_8 Node3_12_9 90588.23529411767
R_3_12_8_2 Node3_12_8 Node3_13_8 90588.23529411767
R_3_12_8_3 Node3_12_8 Node4_12_8 0.167552
C_3_12_8 Node3_12_8 GND 1.91748046875e-10
R_3_12_9_1 Node3_12_9 Node3_12_10 90588.23529411767
R_3_12_9_2 Node3_12_9 Node3_13_9 90588.23529411767
R_3_12_9_3 Node3_12_9 Node4_12_9 0.167552
C_3_12_9 Node3_12_9 GND 1.91748046875e-10
R_3_12_10_1 Node3_12_10 Node3_12_11 90588.23529411767
R_3_12_10_2 Node3_12_10 Node3_13_10 90588.23529411767
R_3_12_10_3 Node3_12_10 Node4_12_10 0.167552
C_3_12_10 Node3_12_10 GND 1.91748046875e-10
R_3_12_11_1 Node3_12_11 Node3_12_12 90588.23529411767
R_3_12_11_2 Node3_12_11 Node3_13_11 90588.23529411767
R_3_12_11_3 Node3_12_11 Node4_12_11 0.167552
C_3_12_11 Node3_12_11 GND 1.91748046875e-10
R_3_12_12_1 Node3_12_12 Node3_12_13 90588.23529411767
R_3_12_12_2 Node3_12_12 Node3_13_12 90588.23529411767
R_3_12_12_3 Node3_12_12 Node4_12_12 0.167552
C_3_12_12 Node3_12_12 GND 1.91748046875e-10
R_3_12_13_1 Node3_12_13 Node3_12_14 90588.23529411767
R_3_12_13_2 Node3_12_13 Node3_13_13 90588.23529411767
R_3_12_13_3 Node3_12_13 Node4_12_13 0.167552
C_3_12_13 Node3_12_13 GND 1.91748046875e-10
R_3_12_14_1 Node3_12_14 Node3_12_15 90588.23529411762
R_3_12_14_2 Node3_12_14 Node3_13_14 90588.23529411767
R_3_12_14_3 Node3_12_14 Node4_12_14 0.167552
C_3_12_14 Node3_12_14 GND 1.91748046875e-10
R_3_12_15_2 Node3_12_15 Node3_13_15 90588.23529411759
R_3_12_15_3 Node3_12_15 Node4_12_15 0.16755199999999984
C_3_12_15 Node3_12_15 GND 1.917480468750002e-10
R_3_13_0_1 Node3_13_0 Node3_13_1 90588.23529411767
R_3_13_0_2 Node3_13_0 Node3_14_0 90588.23529411767
R_3_13_0_3 Node3_13_0 Node4_13_0 0.167552
C_3_13_0 Node3_13_0 GND 1.91748046875e-10
R_3_13_1_1 Node3_13_1 Node3_13_2 90588.23529411767
R_3_13_1_2 Node3_13_1 Node3_14_1 90588.23529411767
R_3_13_1_3 Node3_13_1 Node4_13_1 0.167552
C_3_13_1 Node3_13_1 GND 1.91748046875e-10
R_3_13_2_1 Node3_13_2 Node3_13_3 90588.23529411767
R_3_13_2_2 Node3_13_2 Node3_14_2 90588.23529411767
R_3_13_2_3 Node3_13_2 Node4_13_2 0.167552
C_3_13_2 Node3_13_2 GND 1.91748046875e-10
R_3_13_3_1 Node3_13_3 Node3_13_4 90588.23529411767
R_3_13_3_2 Node3_13_3 Node3_14_3 90588.23529411767
R_3_13_3_3 Node3_13_3 Node4_13_3 0.167552
C_3_13_3 Node3_13_3 GND 1.91748046875e-10
R_3_13_4_1 Node3_13_4 Node3_13_5 90588.23529411767
R_3_13_4_2 Node3_13_4 Node3_14_4 90588.23529411767
R_3_13_4_3 Node3_13_4 Node4_13_4 0.167552
C_3_13_4 Node3_13_4 GND 1.91748046875e-10
R_3_13_5_1 Node3_13_5 Node3_13_6 90588.23529411767
R_3_13_5_2 Node3_13_5 Node3_14_5 90588.23529411767
R_3_13_5_3 Node3_13_5 Node4_13_5 0.167552
C_3_13_5 Node3_13_5 GND 1.91748046875e-10
R_3_13_6_1 Node3_13_6 Node3_13_7 90588.23529411767
R_3_13_6_2 Node3_13_6 Node3_14_6 90588.23529411767
R_3_13_6_3 Node3_13_6 Node4_13_6 0.167552
C_3_13_6 Node3_13_6 GND 1.91748046875e-10
R_3_13_7_1 Node3_13_7 Node3_13_8 90588.23529411767
R_3_13_7_2 Node3_13_7 Node3_14_7 90588.23529411767
R_3_13_7_3 Node3_13_7 Node4_13_7 0.167552
C_3_13_7 Node3_13_7 GND 1.91748046875e-10
R_3_13_8_1 Node3_13_8 Node3_13_9 90588.23529411767
R_3_13_8_2 Node3_13_8 Node3_14_8 90588.23529411767
R_3_13_8_3 Node3_13_8 Node4_13_8 0.167552
C_3_13_8 Node3_13_8 GND 1.91748046875e-10
R_3_13_9_1 Node3_13_9 Node3_13_10 90588.23529411767
R_3_13_9_2 Node3_13_9 Node3_14_9 90588.23529411767
R_3_13_9_3 Node3_13_9 Node4_13_9 0.167552
C_3_13_9 Node3_13_9 GND 1.91748046875e-10
R_3_13_10_1 Node3_13_10 Node3_13_11 90588.23529411767
R_3_13_10_2 Node3_13_10 Node3_14_10 90588.23529411767
R_3_13_10_3 Node3_13_10 Node4_13_10 0.167552
C_3_13_10 Node3_13_10 GND 1.91748046875e-10
R_3_13_11_1 Node3_13_11 Node3_13_12 90588.23529411767
R_3_13_11_2 Node3_13_11 Node3_14_11 90588.23529411767
R_3_13_11_3 Node3_13_11 Node4_13_11 0.167552
C_3_13_11 Node3_13_11 GND 1.91748046875e-10
R_3_13_12_1 Node3_13_12 Node3_13_13 90588.23529411767
R_3_13_12_2 Node3_13_12 Node3_14_12 90588.23529411767
R_3_13_12_3 Node3_13_12 Node4_13_12 0.167552
C_3_13_12 Node3_13_12 GND 1.91748046875e-10
R_3_13_13_1 Node3_13_13 Node3_13_14 90588.23529411767
R_3_13_13_2 Node3_13_13 Node3_14_13 90588.23529411767
R_3_13_13_3 Node3_13_13 Node4_13_13 0.167552
C_3_13_13 Node3_13_13 GND 1.91748046875e-10
R_3_13_14_1 Node3_13_14 Node3_13_15 90588.23529411762
R_3_13_14_2 Node3_13_14 Node3_14_14 90588.23529411767
R_3_13_14_3 Node3_13_14 Node4_13_14 0.167552
C_3_13_14 Node3_13_14 GND 1.91748046875e-10
R_3_13_15_2 Node3_13_15 Node3_14_15 90588.23529411759
R_3_13_15_3 Node3_13_15 Node4_13_15 0.16755199999999984
C_3_13_15 Node3_13_15 GND 1.917480468750002e-10
R_3_14_0_1 Node3_14_0 Node3_14_1 90588.23529411767
R_3_14_0_2 Node3_14_0 Node3_15_0 90588.23529411767
R_3_14_0_3 Node3_14_0 Node4_14_0 0.167552
C_3_14_0 Node3_14_0 GND 1.91748046875e-10
R_3_14_1_1 Node3_14_1 Node3_14_2 90588.23529411767
R_3_14_1_2 Node3_14_1 Node3_15_1 90588.23529411767
R_3_14_1_3 Node3_14_1 Node4_14_1 0.167552
C_3_14_1 Node3_14_1 GND 1.91748046875e-10
R_3_14_2_1 Node3_14_2 Node3_14_3 90588.23529411767
R_3_14_2_2 Node3_14_2 Node3_15_2 90588.23529411767
R_3_14_2_3 Node3_14_2 Node4_14_2 0.167552
C_3_14_2 Node3_14_2 GND 1.91748046875e-10
R_3_14_3_1 Node3_14_3 Node3_14_4 90588.23529411767
R_3_14_3_2 Node3_14_3 Node3_15_3 90588.23529411767
R_3_14_3_3 Node3_14_3 Node4_14_3 0.167552
C_3_14_3 Node3_14_3 GND 1.91748046875e-10
R_3_14_4_1 Node3_14_4 Node3_14_5 90588.23529411767
R_3_14_4_2 Node3_14_4 Node3_15_4 90588.23529411767
R_3_14_4_3 Node3_14_4 Node4_14_4 0.167552
C_3_14_4 Node3_14_4 GND 1.91748046875e-10
R_3_14_5_1 Node3_14_5 Node3_14_6 90588.23529411767
R_3_14_5_2 Node3_14_5 Node3_15_5 90588.23529411767
R_3_14_5_3 Node3_14_5 Node4_14_5 0.167552
C_3_14_5 Node3_14_5 GND 1.91748046875e-10
R_3_14_6_1 Node3_14_6 Node3_14_7 90588.23529411767
R_3_14_6_2 Node3_14_6 Node3_15_6 90588.23529411767
R_3_14_6_3 Node3_14_6 Node4_14_6 0.167552
C_3_14_6 Node3_14_6 GND 1.91748046875e-10
R_3_14_7_1 Node3_14_7 Node3_14_8 90588.23529411767
R_3_14_7_2 Node3_14_7 Node3_15_7 90588.23529411767
R_3_14_7_3 Node3_14_7 Node4_14_7 0.167552
C_3_14_7 Node3_14_7 GND 1.91748046875e-10
R_3_14_8_1 Node3_14_8 Node3_14_9 90588.23529411767
R_3_14_8_2 Node3_14_8 Node3_15_8 90588.23529411767
R_3_14_8_3 Node3_14_8 Node4_14_8 0.167552
C_3_14_8 Node3_14_8 GND 1.91748046875e-10
R_3_14_9_1 Node3_14_9 Node3_14_10 90588.23529411767
R_3_14_9_2 Node3_14_9 Node3_15_9 90588.23529411767
R_3_14_9_3 Node3_14_9 Node4_14_9 0.167552
C_3_14_9 Node3_14_9 GND 1.91748046875e-10
R_3_14_10_1 Node3_14_10 Node3_14_11 90588.23529411767
R_3_14_10_2 Node3_14_10 Node3_15_10 90588.23529411767
R_3_14_10_3 Node3_14_10 Node4_14_10 0.167552
C_3_14_10 Node3_14_10 GND 1.91748046875e-10
R_3_14_11_1 Node3_14_11 Node3_14_12 90588.23529411767
R_3_14_11_2 Node3_14_11 Node3_15_11 90588.23529411767
R_3_14_11_3 Node3_14_11 Node4_14_11 0.167552
C_3_14_11 Node3_14_11 GND 1.91748046875e-10
R_3_14_12_1 Node3_14_12 Node3_14_13 90588.23529411767
R_3_14_12_2 Node3_14_12 Node3_15_12 90588.23529411767
R_3_14_12_3 Node3_14_12 Node4_14_12 0.167552
C_3_14_12 Node3_14_12 GND 1.91748046875e-10
R_3_14_13_1 Node3_14_13 Node3_14_14 90588.23529411767
R_3_14_13_2 Node3_14_13 Node3_15_13 90588.23529411767
R_3_14_13_3 Node3_14_13 Node4_14_13 0.167552
C_3_14_13 Node3_14_13 GND 1.91748046875e-10
R_3_14_14_1 Node3_14_14 Node3_14_15 90588.23529411762
R_3_14_14_2 Node3_14_14 Node3_15_14 90588.23529411767
R_3_14_14_3 Node3_14_14 Node4_14_14 0.167552
C_3_14_14 Node3_14_14 GND 1.91748046875e-10
R_3_14_15_2 Node3_14_15 Node3_15_15 90588.23529411759
R_3_14_15_3 Node3_14_15 Node4_14_15 0.16755199999999984
C_3_14_15 Node3_14_15 GND 1.917480468750002e-10
R_3_15_0_1 Node3_15_0 Node3_15_1 90588.23529411767
R_3_15_0_3 Node3_15_0 Node4_15_0 0.167552
C_3_15_0 Node3_15_0 GND 1.91748046875e-10
R_3_15_1_1 Node3_15_1 Node3_15_2 90588.23529411767
R_3_15_1_3 Node3_15_1 Node4_15_1 0.167552
C_3_15_1 Node3_15_1 GND 1.91748046875e-10
R_3_15_2_1 Node3_15_2 Node3_15_3 90588.23529411767
R_3_15_2_3 Node3_15_2 Node4_15_2 0.167552
C_3_15_2 Node3_15_2 GND 1.91748046875e-10
R_3_15_3_1 Node3_15_3 Node3_15_4 90588.23529411767
R_3_15_3_3 Node3_15_3 Node4_15_3 0.167552
C_3_15_3 Node3_15_3 GND 1.91748046875e-10
R_3_15_4_1 Node3_15_4 Node3_15_5 90588.23529411767
R_3_15_4_3 Node3_15_4 Node4_15_4 0.167552
C_3_15_4 Node3_15_4 GND 1.91748046875e-10
R_3_15_5_1 Node3_15_5 Node3_15_6 90588.23529411767
R_3_15_5_3 Node3_15_5 Node4_15_5 0.167552
C_3_15_5 Node3_15_5 GND 1.91748046875e-10
R_3_15_6_1 Node3_15_6 Node3_15_7 90588.23529411767
R_3_15_6_3 Node3_15_6 Node4_15_6 0.167552
C_3_15_6 Node3_15_6 GND 1.91748046875e-10
R_3_15_7_1 Node3_15_7 Node3_15_8 90588.23529411767
R_3_15_7_3 Node3_15_7 Node4_15_7 0.167552
C_3_15_7 Node3_15_7 GND 1.91748046875e-10
R_3_15_8_1 Node3_15_8 Node3_15_9 90588.23529411767
R_3_15_8_3 Node3_15_8 Node4_15_8 0.167552
C_3_15_8 Node3_15_8 GND 1.91748046875e-10
R_3_15_9_1 Node3_15_9 Node3_15_10 90588.23529411767
R_3_15_9_3 Node3_15_9 Node4_15_9 0.167552
C_3_15_9 Node3_15_9 GND 1.91748046875e-10
R_3_15_10_1 Node3_15_10 Node3_15_11 90588.23529411767
R_3_15_10_3 Node3_15_10 Node4_15_10 0.167552
C_3_15_10 Node3_15_10 GND 1.91748046875e-10
R_3_15_11_1 Node3_15_11 Node3_15_12 90588.23529411767
R_3_15_11_3 Node3_15_11 Node4_15_11 0.167552
C_3_15_11 Node3_15_11 GND 1.91748046875e-10
R_3_15_12_1 Node3_15_12 Node3_15_13 90588.23529411767
R_3_15_12_3 Node3_15_12 Node4_15_12 0.167552
C_3_15_12 Node3_15_12 GND 1.91748046875e-10
R_3_15_13_1 Node3_15_13 Node3_15_14 90588.23529411767
R_3_15_13_3 Node3_15_13 Node4_15_13 0.167552
C_3_15_13 Node3_15_13 GND 1.91748046875e-10
R_3_15_14_1 Node3_15_14 Node3_15_15 90588.23529411762
R_3_15_14_3 Node3_15_14 Node4_15_14 0.167552
C_3_15_14 Node3_15_14 GND 1.91748046875e-10
R_3_15_15_3 Node3_15_15 Node4_15_15 0.1675519999999998
C_3_15_15 Node3_15_15 GND 1.9174804687500021e-10
I_4_0_0 GND Node4_0_0 PWL(0s 0A 3.33us 3.906249999999996e-08A 6.66us 3.906249999999996e-08A 9.99us 3.906249999999996e-08A 13.32us 3.906249999999996e-08A 16.65us 3.906249999999996e-08A 19.98us 3.906249999999996e-08A 23.310000000000002us 3.906249999999996e-08A 26.64us 3.906249999999996e-08A 29.97us 3.906249999999996e-08A 33.3us 3.906249999999996e-08A 36.63us 0.0019531249999999983A 39.96us 0.0019531249999999983A 43.29us 0.0019531249999999983A 46.620000000000005us 0.0019531249999999983A 49.95us 0.0019531249999999983A 53.28us 0.0019531249999999983A 56.61us 0.0019531249999999983A 59.94us 0.0019531249999999983A 63.27us 0.0019531249999999983A 66.6us 0.0019531249999999983A 69.93us 3.906249999999996e-08A 73.26us 3.906249999999996e-08A 76.59us 3.906249999999996e-08A 79.92us 3.906249999999996e-08A 83.25us 3.906249999999996e-08A 86.58us 3.906249999999996e-08A 89.91us 3.906249999999996e-08A 93.24000000000001us 3.906249999999996e-08A 96.57000000000001us 3.906249999999996e-08A 99.9us 3.906249999999996e-08A)
R_4_0_0_1 Node4_0_0 Node4_0_1 15400.000000000013
R_4_0_0_2 Node4_0_0 Node4_1_0 15400.000000000007
R_4_0_0_3 Node4_0_0 Node5_0_0 0.9856000000000009
C_4_0_0 Node4_0_0 GND 1.127929687499999e-09
I_4_0_1 GND Node4_0_1 PWL(0s 0A 3.33us 3.906249999999996e-08A 6.66us 3.906249999999996e-08A 9.99us 3.906249999999996e-08A 13.32us 3.906249999999996e-08A 16.65us 3.906249999999996e-08A 19.98us 3.906249999999996e-08A 23.310000000000002us 3.906249999999996e-08A 26.64us 3.906249999999996e-08A 29.97us 3.906249999999996e-08A 33.3us 3.906249999999996e-08A 36.63us 0.0019531249999999983A 39.96us 0.0019531249999999983A 43.29us 0.0019531249999999983A 46.620000000000005us 0.0019531249999999983A 49.95us 0.0019531249999999983A 53.28us 0.0019531249999999983A 56.61us 0.0019531249999999983A 59.94us 0.0019531249999999983A 63.27us 0.0019531249999999983A 66.6us 0.0019531249999999983A 69.93us 3.906249999999996e-08A 73.26us 3.906249999999996e-08A 76.59us 3.906249999999996e-08A 79.92us 3.906249999999996e-08A 83.25us 3.906249999999996e-08A 86.58us 3.906249999999996e-08A 89.91us 3.906249999999996e-08A 93.24000000000001us 3.906249999999996e-08A 96.57000000000001us 3.906249999999996e-08A 99.9us 3.906249999999996e-08A)
R_4_0_1_1 Node4_0_1 Node4_0_2 15400.000000000013
R_4_0_1_2 Node4_0_1 Node4_1_1 15400.000000000007
R_4_0_1_3 Node4_0_1 Node5_0_1 0.9856000000000009
C_4_0_1 Node4_0_1 GND 1.127929687499999e-09
I_4_0_2 GND Node4_0_2 PWL(0s 0A 3.33us 3.906249999999996e-08A 6.66us 3.906249999999996e-08A 9.99us 3.906249999999996e-08A 13.32us 3.906249999999996e-08A 16.65us 3.906249999999996e-08A 19.98us 3.906249999999996e-08A 23.310000000000002us 3.906249999999996e-08A 26.64us 3.906249999999996e-08A 29.97us 3.906249999999996e-08A 33.3us 3.906249999999996e-08A 36.63us 0.0019531249999999983A 39.96us 0.0019531249999999983A 43.29us 0.0019531249999999983A 46.620000000000005us 0.0019531249999999983A 49.95us 0.0019531249999999983A 53.28us 0.0019531249999999983A 56.61us 0.0019531249999999983A 59.94us 0.0019531249999999983A 63.27us 0.0019531249999999983A 66.6us 0.0019531249999999983A 69.93us 3.906249999999996e-08A 73.26us 3.906249999999996e-08A 76.59us 3.906249999999996e-08A 79.92us 3.906249999999996e-08A 83.25us 3.906249999999996e-08A 86.58us 3.906249999999996e-08A 89.91us 3.906249999999996e-08A 93.24000000000001us 3.906249999999996e-08A 96.57000000000001us 3.906249999999996e-08A 99.9us 3.906249999999996e-08A)
R_4_0_2_1 Node4_0_2 Node4_0_3 15400.000000000013
R_4_0_2_2 Node4_0_2 Node4_1_2 15400.000000000007
R_4_0_2_3 Node4_0_2 Node5_0_2 0.9856000000000009
C_4_0_2 Node4_0_2 GND 1.127929687499999e-09
I_4_0_3 GND Node4_0_3 PWL(0s 0A 3.33us 3.906249999999996e-08A 6.66us 3.906249999999996e-08A 9.99us 3.906249999999996e-08A 13.32us 3.906249999999996e-08A 16.65us 3.906249999999996e-08A 19.98us 3.906249999999996e-08A 23.310000000000002us 3.906249999999996e-08A 26.64us 3.906249999999996e-08A 29.97us 3.906249999999996e-08A 33.3us 3.906249999999996e-08A 36.63us 0.0019531249999999983A 39.96us 0.0019531249999999983A 43.29us 0.0019531249999999983A 46.620000000000005us 0.0019531249999999983A 49.95us 0.0019531249999999983A 53.28us 0.0019531249999999983A 56.61us 0.0019531249999999983A 59.94us 0.0019531249999999983A 63.27us 0.0019531249999999983A 66.6us 0.0019531249999999983A 69.93us 3.906249999999996e-08A 73.26us 3.906249999999996e-08A 76.59us 3.906249999999996e-08A 79.92us 3.906249999999996e-08A 83.25us 3.906249999999996e-08A 86.58us 3.906249999999996e-08A 89.91us 3.906249999999996e-08A 93.24000000000001us 3.906249999999996e-08A 96.57000000000001us 3.906249999999996e-08A 99.9us 3.906249999999996e-08A)
R_4_0_3_1 Node4_0_3 Node4_0_4 15400.000000000013
R_4_0_3_2 Node4_0_3 Node4_1_3 15400.000000000007
R_4_0_3_3 Node4_0_3 Node5_0_3 0.9856000000000009
C_4_0_3 Node4_0_3 GND 1.127929687499999e-09
I_4_0_4 GND Node4_0_4 PWL(0s 0A 3.33us 3.906249999999996e-08A 6.66us 3.906249999999996e-08A 9.99us 3.906249999999996e-08A 13.32us 3.906249999999996e-08A 16.65us 3.906249999999996e-08A 19.98us 3.906249999999996e-08A 23.310000000000002us 3.906249999999996e-08A 26.64us 3.906249999999996e-08A 29.97us 3.906249999999996e-08A 33.3us 3.906249999999996e-08A 36.63us 0.0019531249999999983A 39.96us 0.0019531249999999983A 43.29us 0.0019531249999999983A 46.620000000000005us 0.0019531249999999983A 49.95us 0.0019531249999999983A 53.28us 0.0019531249999999983A 56.61us 0.0019531249999999983A 59.94us 0.0019531249999999983A 63.27us 0.0019531249999999983A 66.6us 0.0019531249999999983A 69.93us 3.906249999999996e-08A 73.26us 3.906249999999996e-08A 76.59us 3.906249999999996e-08A 79.92us 3.906249999999996e-08A 83.25us 3.906249999999996e-08A 86.58us 3.906249999999996e-08A 89.91us 3.906249999999996e-08A 93.24000000000001us 3.906249999999996e-08A 96.57000000000001us 3.906249999999996e-08A 99.9us 3.906249999999996e-08A)
R_4_0_4_1 Node4_0_4 Node4_0_5 15400.000000000013
R_4_0_4_2 Node4_0_4 Node4_1_4 15400.000000000007
R_4_0_4_3 Node4_0_4 Node5_0_4 0.9856000000000009
C_4_0_4 Node4_0_4 GND 1.127929687499999e-09
I_4_0_5 GND Node4_0_5 PWL(0s 0A 3.33us 3.906249999999996e-08A 6.66us 3.906249999999996e-08A 9.99us 3.906249999999996e-08A 13.32us 3.906249999999996e-08A 16.65us 3.906249999999996e-08A 19.98us 3.906249999999996e-08A 23.310000000000002us 3.906249999999996e-08A 26.64us 3.906249999999996e-08A 29.97us 3.906249999999996e-08A 33.3us 3.906249999999996e-08A 36.63us 0.0019531249999999983A 39.96us 0.0019531249999999983A 43.29us 0.0019531249999999983A 46.620000000000005us 0.0019531249999999983A 49.95us 0.0019531249999999983A 53.28us 0.0019531249999999983A 56.61us 0.0019531249999999983A 59.94us 0.0019531249999999983A 63.27us 0.0019531249999999983A 66.6us 0.0019531249999999983A 69.93us 3.906249999999996e-08A 73.26us 3.906249999999996e-08A 76.59us 3.906249999999996e-08A 79.92us 3.906249999999996e-08A 83.25us 3.906249999999996e-08A 86.58us 3.906249999999996e-08A 89.91us 3.906249999999996e-08A 93.24000000000001us 3.906249999999996e-08A 96.57000000000001us 3.906249999999996e-08A 99.9us 3.906249999999996e-08A)
R_4_0_5_1 Node4_0_5 Node4_0_6 15400.000000000013
R_4_0_5_2 Node4_0_5 Node4_1_5 15400.000000000007
R_4_0_5_3 Node4_0_5 Node5_0_5 0.9856000000000009
C_4_0_5 Node4_0_5 GND 1.127929687499999e-09
I_4_0_6 GND Node4_0_6 PWL(0s 0A 3.33us 3.906249999999996e-08A 6.66us 3.906249999999996e-08A 9.99us 3.906249999999996e-08A 13.32us 3.906249999999996e-08A 16.65us 3.906249999999996e-08A 19.98us 3.906249999999996e-08A 23.310000000000002us 3.906249999999996e-08A 26.64us 3.906249999999996e-08A 29.97us 3.906249999999996e-08A 33.3us 3.906249999999996e-08A 36.63us 0.0019531249999999983A 39.96us 0.0019531249999999983A 43.29us 0.0019531249999999983A 46.620000000000005us 0.0019531249999999983A 49.95us 0.0019531249999999983A 53.28us 0.0019531249999999983A 56.61us 0.0019531249999999983A 59.94us 0.0019531249999999983A 63.27us 0.0019531249999999983A 66.6us 0.0019531249999999983A 69.93us 3.906249999999996e-08A 73.26us 3.906249999999996e-08A 76.59us 3.906249999999996e-08A 79.92us 3.906249999999996e-08A 83.25us 3.906249999999996e-08A 86.58us 3.906249999999996e-08A 89.91us 3.906249999999996e-08A 93.24000000000001us 3.906249999999996e-08A 96.57000000000001us 3.906249999999996e-08A 99.9us 3.906249999999996e-08A)
R_4_0_6_1 Node4_0_6 Node4_0_7 15400.000000000013
R_4_0_6_2 Node4_0_6 Node4_1_6 15400.000000000007
R_4_0_6_3 Node4_0_6 Node5_0_6 0.9856000000000009
C_4_0_6 Node4_0_6 GND 1.127929687499999e-09
I_4_0_7 GND Node4_0_7 PWL(0s 0A 3.33us 3.906249999999996e-08A 6.66us 3.906249999999996e-08A 9.99us 3.906249999999996e-08A 13.32us 3.906249999999996e-08A 16.65us 3.906249999999996e-08A 19.98us 3.906249999999996e-08A 23.310000000000002us 3.906249999999996e-08A 26.64us 3.906249999999996e-08A 29.97us 3.906249999999996e-08A 33.3us 3.906249999999996e-08A 36.63us 0.0019531249999999983A 39.96us 0.0019531249999999983A 43.29us 0.0019531249999999983A 46.620000000000005us 0.0019531249999999983A 49.95us 0.0019531249999999983A 53.28us 0.0019531249999999983A 56.61us 0.0019531249999999983A 59.94us 0.0019531249999999983A 63.27us 0.0019531249999999983A 66.6us 0.0019531249999999983A 69.93us 3.906249999999996e-08A 73.26us 3.906249999999996e-08A 76.59us 3.906249999999996e-08A 79.92us 3.906249999999996e-08A 83.25us 3.906249999999996e-08A 86.58us 3.906249999999996e-08A 89.91us 3.906249999999996e-08A 93.24000000000001us 3.906249999999996e-08A 96.57000000000001us 3.906249999999996e-08A 99.9us 3.906249999999996e-08A)
R_4_0_7_1 Node4_0_7 Node4_0_8 15400.000000000013
R_4_0_7_2 Node4_0_7 Node4_1_7 15400.000000000007
R_4_0_7_3 Node4_0_7 Node5_0_7 0.9856000000000009
C_4_0_7 Node4_0_7 GND 1.127929687499999e-09
I_4_0_8 GND Node4_0_8 PWL(0s 0A 3.33us 3.906249999999996e-08A 6.66us 3.906249999999996e-08A 9.99us 3.906249999999996e-08A 13.32us 3.906249999999996e-08A 16.65us 3.906249999999996e-08A 19.98us 3.906249999999996e-08A 23.310000000000002us 3.906249999999996e-08A 26.64us 3.906249999999996e-08A 29.97us 3.906249999999996e-08A 33.3us 3.906249999999996e-08A 36.63us 0.0019531249999999983A 39.96us 0.0019531249999999983A 43.29us 0.0019531249999999983A 46.620000000000005us 0.0019531249999999983A 49.95us 0.0019531249999999983A 53.28us 0.0019531249999999983A 56.61us 0.0019531249999999983A 59.94us 0.0019531249999999983A 63.27us 0.0019531249999999983A 66.6us 0.0019531249999999983A 69.93us 3.906249999999996e-08A 73.26us 3.906249999999996e-08A 76.59us 3.906249999999996e-08A 79.92us 3.906249999999996e-08A 83.25us 3.906249999999996e-08A 86.58us 3.906249999999996e-08A 89.91us 3.906249999999996e-08A 93.24000000000001us 3.906249999999996e-08A 96.57000000000001us 3.906249999999996e-08A 99.9us 3.906249999999996e-08A)
R_4_0_8_1 Node4_0_8 Node4_0_9 15400.000000000013
R_4_0_8_2 Node4_0_8 Node4_1_8 15400.000000000007
R_4_0_8_3 Node4_0_8 Node5_0_8 0.9856000000000009
C_4_0_8 Node4_0_8 GND 1.127929687499999e-09
I_4_0_9 GND Node4_0_9 PWL(0s 0A 3.33us 3.906249999999996e-08A 6.66us 3.906249999999996e-08A 9.99us 3.906249999999996e-08A 13.32us 3.906249999999996e-08A 16.65us 3.906249999999996e-08A 19.98us 3.906249999999996e-08A 23.310000000000002us 3.906249999999996e-08A 26.64us 3.906249999999996e-08A 29.97us 3.906249999999996e-08A 33.3us 3.906249999999996e-08A 36.63us 0.0019531249999999983A 39.96us 0.0019531249999999983A 43.29us 0.0019531249999999983A 46.620000000000005us 0.0019531249999999983A 49.95us 0.0019531249999999983A 53.28us 0.0019531249999999983A 56.61us 0.0019531249999999983A 59.94us 0.0019531249999999983A 63.27us 0.0019531249999999983A 66.6us 0.0019531249999999983A 69.93us 3.906249999999996e-08A 73.26us 3.906249999999996e-08A 76.59us 3.906249999999996e-08A 79.92us 3.906249999999996e-08A 83.25us 3.906249999999996e-08A 86.58us 3.906249999999996e-08A 89.91us 3.906249999999996e-08A 93.24000000000001us 3.906249999999996e-08A 96.57000000000001us 3.906249999999996e-08A 99.9us 3.906249999999996e-08A)
R_4_0_9_1 Node4_0_9 Node4_0_10 15400.000000000013
R_4_0_9_2 Node4_0_9 Node4_1_9 15400.000000000007
R_4_0_9_3 Node4_0_9 Node5_0_9 0.9856000000000009
C_4_0_9 Node4_0_9 GND 1.127929687499999e-09
I_4_0_10 GND Node4_0_10 PWL(0s 0A 3.33us 3.906249999999996e-08A 6.66us 3.906249999999996e-08A 9.99us 3.906249999999996e-08A 13.32us 3.906249999999996e-08A 16.65us 3.906249999999996e-08A 19.98us 3.906249999999996e-08A 23.310000000000002us 3.906249999999996e-08A 26.64us 3.906249999999996e-08A 29.97us 3.906249999999996e-08A 33.3us 3.906249999999996e-08A 36.63us 0.0019531249999999983A 39.96us 0.0019531249999999983A 43.29us 0.0019531249999999983A 46.620000000000005us 0.0019531249999999983A 49.95us 0.0019531249999999983A 53.28us 0.0019531249999999983A 56.61us 0.0019531249999999983A 59.94us 0.0019531249999999983A 63.27us 0.0019531249999999983A 66.6us 0.0019531249999999983A 69.93us 3.906249999999996e-08A 73.26us 3.906249999999996e-08A 76.59us 3.906249999999996e-08A 79.92us 3.906249999999996e-08A 83.25us 3.906249999999996e-08A 86.58us 3.906249999999996e-08A 89.91us 3.906249999999996e-08A 93.24000000000001us 3.906249999999996e-08A 96.57000000000001us 3.906249999999996e-08A 99.9us 3.906249999999996e-08A)
R_4_0_10_1 Node4_0_10 Node4_0_11 15400.000000000013
R_4_0_10_2 Node4_0_10 Node4_1_10 15400.000000000007
R_4_0_10_3 Node4_0_10 Node5_0_10 0.9856000000000009
C_4_0_10 Node4_0_10 GND 1.127929687499999e-09
I_4_0_11 GND Node4_0_11 PWL(0s 0A 3.33us 3.906249999999996e-08A 6.66us 3.906249999999996e-08A 9.99us 3.906249999999996e-08A 13.32us 3.906249999999996e-08A 16.65us 3.906249999999996e-08A 19.98us 3.906249999999996e-08A 23.310000000000002us 3.906249999999996e-08A 26.64us 3.906249999999996e-08A 29.97us 3.906249999999996e-08A 33.3us 3.906249999999996e-08A 36.63us 0.0019531249999999983A 39.96us 0.0019531249999999983A 43.29us 0.0019531249999999983A 46.620000000000005us 0.0019531249999999983A 49.95us 0.0019531249999999983A 53.28us 0.0019531249999999983A 56.61us 0.0019531249999999983A 59.94us 0.0019531249999999983A 63.27us 0.0019531249999999983A 66.6us 0.0019531249999999983A 69.93us 3.906249999999996e-08A 73.26us 3.906249999999996e-08A 76.59us 3.906249999999996e-08A 79.92us 3.906249999999996e-08A 83.25us 3.906249999999996e-08A 86.58us 3.906249999999996e-08A 89.91us 3.906249999999996e-08A 93.24000000000001us 3.906249999999996e-08A 96.57000000000001us 3.906249999999996e-08A 99.9us 3.906249999999996e-08A)
R_4_0_11_1 Node4_0_11 Node4_0_12 15400.000000000013
R_4_0_11_2 Node4_0_11 Node4_1_11 15400.000000000007
R_4_0_11_3 Node4_0_11 Node5_0_11 0.9856000000000009
C_4_0_11 Node4_0_11 GND 1.127929687499999e-09
I_4_0_12 GND Node4_0_12 PWL(0s 0A 3.33us 3.906249999999996e-08A 6.66us 3.906249999999996e-08A 9.99us 3.906249999999996e-08A 13.32us 3.906249999999996e-08A 16.65us 3.906249999999996e-08A 19.98us 3.906249999999996e-08A 23.310000000000002us 3.906249999999996e-08A 26.64us 3.906249999999996e-08A 29.97us 3.906249999999996e-08A 33.3us 3.906249999999996e-08A 36.63us 0.0019531249999999983A 39.96us 0.0019531249999999983A 43.29us 0.0019531249999999983A 46.620000000000005us 0.0019531249999999983A 49.95us 0.0019531249999999983A 53.28us 0.0019531249999999983A 56.61us 0.0019531249999999983A 59.94us 0.0019531249999999983A 63.27us 0.0019531249999999983A 66.6us 0.0019531249999999983A 69.93us 3.906249999999996e-08A 73.26us 3.906249999999996e-08A 76.59us 3.906249999999996e-08A 79.92us 3.906249999999996e-08A 83.25us 3.906249999999996e-08A 86.58us 3.906249999999996e-08A 89.91us 3.906249999999996e-08A 93.24000000000001us 3.906249999999996e-08A 96.57000000000001us 3.906249999999996e-08A 99.9us 3.906249999999996e-08A)
R_4_0_12_1 Node4_0_12 Node4_0_13 15400.000000000013
R_4_0_12_2 Node4_0_12 Node4_1_12 15400.000000000007
R_4_0_12_3 Node4_0_12 Node5_0_12 0.9856000000000009
C_4_0_12 Node4_0_12 GND 1.127929687499999e-09
I_4_0_13 GND Node4_0_13 PWL(0s 0A 3.33us 3.906249999999996e-08A 6.66us 3.906249999999996e-08A 9.99us 3.906249999999996e-08A 13.32us 3.906249999999996e-08A 16.65us 3.906249999999996e-08A 19.98us 3.906249999999996e-08A 23.310000000000002us 3.906249999999996e-08A 26.64us 3.906249999999996e-08A 29.97us 3.906249999999996e-08A 33.3us 3.906249999999996e-08A 36.63us 0.0019531249999999983A 39.96us 0.0019531249999999983A 43.29us 0.0019531249999999983A 46.620000000000005us 0.0019531249999999983A 49.95us 0.0019531249999999983A 53.28us 0.0019531249999999983A 56.61us 0.0019531249999999983A 59.94us 0.0019531249999999983A 63.27us 0.0019531249999999983A 66.6us 0.0019531249999999983A 69.93us 3.906249999999996e-08A 73.26us 3.906249999999996e-08A 76.59us 3.906249999999996e-08A 79.92us 3.906249999999996e-08A 83.25us 3.906249999999996e-08A 86.58us 3.906249999999996e-08A 89.91us 3.906249999999996e-08A 93.24000000000001us 3.906249999999996e-08A 96.57000000000001us 3.906249999999996e-08A 99.9us 3.906249999999996e-08A)
R_4_0_13_1 Node4_0_13 Node4_0_14 15400.000000000013
R_4_0_13_2 Node4_0_13 Node4_1_13 15400.000000000007
R_4_0_13_3 Node4_0_13 Node5_0_13 0.9856000000000009
C_4_0_13 Node4_0_13 GND 1.127929687499999e-09
I_4_0_14 GND Node4_0_14 PWL(0s 0A 3.33us 3.906249999999996e-08A 6.66us 3.906249999999996e-08A 9.99us 3.906249999999996e-08A 13.32us 3.906249999999996e-08A 16.65us 3.906249999999996e-08A 19.98us 3.906249999999996e-08A 23.310000000000002us 3.906249999999996e-08A 26.64us 3.906249999999996e-08A 29.97us 3.906249999999996e-08A 33.3us 3.906249999999996e-08A 36.63us 0.0019531249999999983A 39.96us 0.0019531249999999983A 43.29us 0.0019531249999999983A 46.620000000000005us 0.0019531249999999983A 49.95us 0.0019531249999999983A 53.28us 0.0019531249999999983A 56.61us 0.0019531249999999983A 59.94us 0.0019531249999999983A 63.27us 0.0019531249999999983A 66.6us 0.0019531249999999983A 69.93us 3.906249999999996e-08A 73.26us 3.906249999999996e-08A 76.59us 3.906249999999996e-08A 79.92us 3.906249999999996e-08A 83.25us 3.906249999999996e-08A 86.58us 3.906249999999996e-08A 89.91us 3.906249999999996e-08A 93.24000000000001us 3.906249999999996e-08A 96.57000000000001us 3.906249999999996e-08A 99.9us 3.906249999999996e-08A)
R_4_0_14_1 Node4_0_14 Node4_0_15 15400.000000000007
R_4_0_14_2 Node4_0_14 Node4_1_14 15400.000000000007
R_4_0_14_3 Node4_0_14 Node5_0_14 0.9856000000000009
C_4_0_14 Node4_0_14 GND 1.127929687499999e-09
I_4_0_15 GND Node4_0_15 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 0.001953125A 39.96us 0.001953125A 43.29us 0.001953125A 46.620000000000005us 0.001953125A 49.95us 0.001953125A 53.28us 0.001953125A 56.61us 0.001953125A 59.94us 0.001953125A 63.27us 0.001953125A 66.6us 0.001953125A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_4_0_15_2 Node4_0_15 Node4_1_15 15399.999999999993
R_4_0_15_3 Node4_0_15 Node5_0_15 0.9856000000000001
C_4_0_15 Node4_0_15 GND 1.1279296875e-09
I_4_1_0 GND Node4_1_0 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 0.001953125A 39.96us 0.001953125A 43.29us 0.001953125A 46.620000000000005us 0.001953125A 49.95us 0.001953125A 53.28us 0.001953125A 56.61us 0.001953125A 59.94us 0.001953125A 63.27us 0.001953125A 66.6us 0.001953125A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_4_1_0_1 Node4_1_0 Node4_1_1 15400.0
R_4_1_0_2 Node4_1_0 Node4_2_0 15400.0
R_4_1_0_3 Node4_1_0 Node5_1_0 0.9856000000000001
C_4_1_0 Node4_1_0 GND 1.1279296875e-09
I_4_1_1 GND Node4_1_1 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 0.001953125A 39.96us 0.001953125A 43.29us 0.001953125A 46.620000000000005us 0.001953125A 49.95us 0.001953125A 53.28us 0.001953125A 56.61us 0.001953125A 59.94us 0.001953125A 63.27us 0.001953125A 66.6us 0.001953125A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_4_1_1_1 Node4_1_1 Node4_1_2 15400.0
R_4_1_1_2 Node4_1_1 Node4_2_1 15400.0
R_4_1_1_3 Node4_1_1 Node5_1_1 0.9856000000000001
C_4_1_1 Node4_1_1 GND 1.1279296875e-09
I_4_1_2 GND Node4_1_2 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 0.001953125A 39.96us 0.001953125A 43.29us 0.001953125A 46.620000000000005us 0.001953125A 49.95us 0.001953125A 53.28us 0.001953125A 56.61us 0.001953125A 59.94us 0.001953125A 63.27us 0.001953125A 66.6us 0.001953125A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_4_1_2_1 Node4_1_2 Node4_1_3 15400.0
R_4_1_2_2 Node4_1_2 Node4_2_2 15400.0
R_4_1_2_3 Node4_1_2 Node5_1_2 0.9856000000000001
C_4_1_2 Node4_1_2 GND 1.1279296875e-09
I_4_1_3 GND Node4_1_3 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 0.001953125A 39.96us 0.001953125A 43.29us 0.001953125A 46.620000000000005us 0.001953125A 49.95us 0.001953125A 53.28us 0.001953125A 56.61us 0.001953125A 59.94us 0.001953125A 63.27us 0.001953125A 66.6us 0.001953125A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_4_1_3_1 Node4_1_3 Node4_1_4 15400.0
R_4_1_3_2 Node4_1_3 Node4_2_3 15400.0
R_4_1_3_3 Node4_1_3 Node5_1_3 0.9856000000000001
C_4_1_3 Node4_1_3 GND 1.1279296875e-09
I_4_1_4 GND Node4_1_4 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 0.001953125A 39.96us 0.001953125A 43.29us 0.001953125A 46.620000000000005us 0.001953125A 49.95us 0.001953125A 53.28us 0.001953125A 56.61us 0.001953125A 59.94us 0.001953125A 63.27us 0.001953125A 66.6us 0.001953125A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_4_1_4_1 Node4_1_4 Node4_1_5 15400.0
R_4_1_4_2 Node4_1_4 Node4_2_4 15400.0
R_4_1_4_3 Node4_1_4 Node5_1_4 0.9856000000000001
C_4_1_4 Node4_1_4 GND 1.1279296875e-09
I_4_1_5 GND Node4_1_5 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 0.001953125A 39.96us 0.001953125A 43.29us 0.001953125A 46.620000000000005us 0.001953125A 49.95us 0.001953125A 53.28us 0.001953125A 56.61us 0.001953125A 59.94us 0.001953125A 63.27us 0.001953125A 66.6us 0.001953125A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_4_1_5_1 Node4_1_5 Node4_1_6 15400.0
R_4_1_5_2 Node4_1_5 Node4_2_5 15400.0
R_4_1_5_3 Node4_1_5 Node5_1_5 0.9856000000000001
C_4_1_5 Node4_1_5 GND 1.1279296875e-09
I_4_1_6 GND Node4_1_6 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 0.001953125A 39.96us 0.001953125A 43.29us 0.001953125A 46.620000000000005us 0.001953125A 49.95us 0.001953125A 53.28us 0.001953125A 56.61us 0.001953125A 59.94us 0.001953125A 63.27us 0.001953125A 66.6us 0.001953125A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_4_1_6_1 Node4_1_6 Node4_1_7 15400.0
R_4_1_6_2 Node4_1_6 Node4_2_6 15400.0
R_4_1_6_3 Node4_1_6 Node5_1_6 0.9856000000000001
C_4_1_6 Node4_1_6 GND 1.1279296875e-09
I_4_1_7 GND Node4_1_7 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 0.001953125A 39.96us 0.001953125A 43.29us 0.001953125A 46.620000000000005us 0.001953125A 49.95us 0.001953125A 53.28us 0.001953125A 56.61us 0.001953125A 59.94us 0.001953125A 63.27us 0.001953125A 66.6us 0.001953125A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_4_1_7_1 Node4_1_7 Node4_1_8 15400.0
R_4_1_7_2 Node4_1_7 Node4_2_7 15400.0
R_4_1_7_3 Node4_1_7 Node5_1_7 0.9856000000000001
C_4_1_7 Node4_1_7 GND 1.1279296875e-09
I_4_1_8 GND Node4_1_8 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 0.001953125A 39.96us 0.001953125A 43.29us 0.001953125A 46.620000000000005us 0.001953125A 49.95us 0.001953125A 53.28us 0.001953125A 56.61us 0.001953125A 59.94us 0.001953125A 63.27us 0.001953125A 66.6us 0.001953125A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_4_1_8_1 Node4_1_8 Node4_1_9 15400.0
R_4_1_8_2 Node4_1_8 Node4_2_8 15400.0
R_4_1_8_3 Node4_1_8 Node5_1_8 0.9856000000000001
C_4_1_8 Node4_1_8 GND 1.1279296875e-09
I_4_1_9 GND Node4_1_9 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 0.001953125A 39.96us 0.001953125A 43.29us 0.001953125A 46.620000000000005us 0.001953125A 49.95us 0.001953125A 53.28us 0.001953125A 56.61us 0.001953125A 59.94us 0.001953125A 63.27us 0.001953125A 66.6us 0.001953125A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_4_1_9_1 Node4_1_9 Node4_1_10 15400.0
R_4_1_9_2 Node4_1_9 Node4_2_9 15400.0
R_4_1_9_3 Node4_1_9 Node5_1_9 0.9856000000000001
C_4_1_9 Node4_1_9 GND 1.1279296875e-09
I_4_1_10 GND Node4_1_10 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 0.001953125A 39.96us 0.001953125A 43.29us 0.001953125A 46.620000000000005us 0.001953125A 49.95us 0.001953125A 53.28us 0.001953125A 56.61us 0.001953125A 59.94us 0.001953125A 63.27us 0.001953125A 66.6us 0.001953125A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_4_1_10_1 Node4_1_10 Node4_1_11 15400.0
R_4_1_10_2 Node4_1_10 Node4_2_10 15400.0
R_4_1_10_3 Node4_1_10 Node5_1_10 0.9856000000000001
C_4_1_10 Node4_1_10 GND 1.1279296875e-09
I_4_1_11 GND Node4_1_11 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 0.001953125A 39.96us 0.001953125A 43.29us 0.001953125A 46.620000000000005us 0.001953125A 49.95us 0.001953125A 53.28us 0.001953125A 56.61us 0.001953125A 59.94us 0.001953125A 63.27us 0.001953125A 66.6us 0.001953125A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_4_1_11_1 Node4_1_11 Node4_1_12 15400.0
R_4_1_11_2 Node4_1_11 Node4_2_11 15400.0
R_4_1_11_3 Node4_1_11 Node5_1_11 0.9856000000000001
C_4_1_11 Node4_1_11 GND 1.1279296875e-09
I_4_1_12 GND Node4_1_12 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 0.001953125A 39.96us 0.001953125A 43.29us 0.001953125A 46.620000000000005us 0.001953125A 49.95us 0.001953125A 53.28us 0.001953125A 56.61us 0.001953125A 59.94us 0.001953125A 63.27us 0.001953125A 66.6us 0.001953125A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_4_1_12_1 Node4_1_12 Node4_1_13 15400.0
R_4_1_12_2 Node4_1_12 Node4_2_12 15400.0
R_4_1_12_3 Node4_1_12 Node5_1_12 0.9856000000000001
C_4_1_12 Node4_1_12 GND 1.1279296875e-09
I_4_1_13 GND Node4_1_13 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 0.001953125A 39.96us 0.001953125A 43.29us 0.001953125A 46.620000000000005us 0.001953125A 49.95us 0.001953125A 53.28us 0.001953125A 56.61us 0.001953125A 59.94us 0.001953125A 63.27us 0.001953125A 66.6us 0.001953125A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_4_1_13_1 Node4_1_13 Node4_1_14 15400.0
R_4_1_13_2 Node4_1_13 Node4_2_13 15400.0
R_4_1_13_3 Node4_1_13 Node5_1_13 0.9856000000000001
C_4_1_13 Node4_1_13 GND 1.1279296875e-09
I_4_1_14 GND Node4_1_14 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 0.001953125A 39.96us 0.001953125A 43.29us 0.001953125A 46.620000000000005us 0.001953125A 49.95us 0.001953125A 53.28us 0.001953125A 56.61us 0.001953125A 59.94us 0.001953125A 63.27us 0.001953125A 66.6us 0.001953125A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_4_1_14_1 Node4_1_14 Node4_1_15 15399.999999999993
R_4_1_14_2 Node4_1_14 Node4_2_14 15400.0
R_4_1_14_3 Node4_1_14 Node5_1_14 0.9856000000000001
C_4_1_14 Node4_1_14 GND 1.1279296875e-09
I_4_1_15 GND Node4_1_15 PWL(0s 0A 3.33us 3.906250000000002e-08A 6.66us 3.906250000000002e-08A 9.99us 3.906250000000002e-08A 13.32us 3.906250000000002e-08A 16.65us 3.906250000000002e-08A 19.98us 3.906250000000002e-08A 23.310000000000002us 3.906250000000002e-08A 26.64us 3.906250000000002e-08A 29.97us 3.906250000000002e-08A 33.3us 3.906250000000002e-08A 36.63us 0.0019531250000000017A 39.96us 0.0019531250000000017A 43.29us 0.0019531250000000017A 46.620000000000005us 0.0019531250000000017A 49.95us 0.0019531250000000017A 53.28us 0.0019531250000000017A 56.61us 0.0019531250000000017A 59.94us 0.0019531250000000017A 63.27us 0.0019531250000000017A 66.6us 0.0019531250000000017A 69.93us 3.906250000000002e-08A 73.26us 3.906250000000002e-08A 76.59us 3.906250000000002e-08A 79.92us 3.906250000000002e-08A 83.25us 3.906250000000002e-08A 86.58us 3.906250000000002e-08A 89.91us 3.906250000000002e-08A 93.24000000000001us 3.906250000000002e-08A 96.57000000000001us 3.906250000000002e-08A 99.9us 3.906250000000002e-08A)
R_4_1_15_2 Node4_1_15 Node4_2_15 15399.999999999987
R_4_1_15_3 Node4_1_15 Node5_1_15 0.9855999999999993
C_4_1_15 Node4_1_15 GND 1.127929687500001e-09
I_4_2_0 GND Node4_2_0 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 0.001953125A 39.96us 0.001953125A 43.29us 0.001953125A 46.620000000000005us 0.001953125A 49.95us 0.001953125A 53.28us 0.001953125A 56.61us 0.001953125A 59.94us 0.001953125A 63.27us 0.001953125A 66.6us 0.001953125A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_4_2_0_1 Node4_2_0 Node4_2_1 15400.0
R_4_2_0_2 Node4_2_0 Node4_3_0 15400.0
R_4_2_0_3 Node4_2_0 Node5_2_0 0.9856000000000001
C_4_2_0 Node4_2_0 GND 1.1279296875e-09
I_4_2_1 GND Node4_2_1 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 0.001953125A 39.96us 0.001953125A 43.29us 0.001953125A 46.620000000000005us 0.001953125A 49.95us 0.001953125A 53.28us 0.001953125A 56.61us 0.001953125A 59.94us 0.001953125A 63.27us 0.001953125A 66.6us 0.001953125A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_4_2_1_1 Node4_2_1 Node4_2_2 15400.0
R_4_2_1_2 Node4_2_1 Node4_3_1 15400.0
R_4_2_1_3 Node4_2_1 Node5_2_1 0.9856000000000001
C_4_2_1 Node4_2_1 GND 1.1279296875e-09
I_4_2_2 GND Node4_2_2 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 0.001953125A 39.96us 0.001953125A 43.29us 0.001953125A 46.620000000000005us 0.001953125A 49.95us 0.001953125A 53.28us 0.001953125A 56.61us 0.001953125A 59.94us 0.001953125A 63.27us 0.001953125A 66.6us 0.001953125A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_4_2_2_1 Node4_2_2 Node4_2_3 15400.0
R_4_2_2_2 Node4_2_2 Node4_3_2 15400.0
R_4_2_2_3 Node4_2_2 Node5_2_2 0.9856000000000001
C_4_2_2 Node4_2_2 GND 1.1279296875e-09
I_4_2_3 GND Node4_2_3 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 0.001953125A 39.96us 0.001953125A 43.29us 0.001953125A 46.620000000000005us 0.001953125A 49.95us 0.001953125A 53.28us 0.001953125A 56.61us 0.001953125A 59.94us 0.001953125A 63.27us 0.001953125A 66.6us 0.001953125A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_4_2_3_1 Node4_2_3 Node4_2_4 15400.0
R_4_2_3_2 Node4_2_3 Node4_3_3 15400.0
R_4_2_3_3 Node4_2_3 Node5_2_3 0.9856000000000001
C_4_2_3 Node4_2_3 GND 1.1279296875e-09
I_4_2_4 GND Node4_2_4 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 0.001953125A 39.96us 0.001953125A 43.29us 0.001953125A 46.620000000000005us 0.001953125A 49.95us 0.001953125A 53.28us 0.001953125A 56.61us 0.001953125A 59.94us 0.001953125A 63.27us 0.001953125A 66.6us 0.001953125A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_4_2_4_1 Node4_2_4 Node4_2_5 15400.0
R_4_2_4_2 Node4_2_4 Node4_3_4 15400.0
R_4_2_4_3 Node4_2_4 Node5_2_4 0.9856000000000001
C_4_2_4 Node4_2_4 GND 1.1279296875e-09
I_4_2_5 GND Node4_2_5 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 0.001953125A 39.96us 0.001953125A 43.29us 0.001953125A 46.620000000000005us 0.001953125A 49.95us 0.001953125A 53.28us 0.001953125A 56.61us 0.001953125A 59.94us 0.001953125A 63.27us 0.001953125A 66.6us 0.001953125A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_4_2_5_1 Node4_2_5 Node4_2_6 15400.0
R_4_2_5_2 Node4_2_5 Node4_3_5 15400.0
R_4_2_5_3 Node4_2_5 Node5_2_5 0.9856000000000001
C_4_2_5 Node4_2_5 GND 1.1279296875e-09
I_4_2_6 GND Node4_2_6 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 0.001953125A 39.96us 0.001953125A 43.29us 0.001953125A 46.620000000000005us 0.001953125A 49.95us 0.001953125A 53.28us 0.001953125A 56.61us 0.001953125A 59.94us 0.001953125A 63.27us 0.001953125A 66.6us 0.001953125A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_4_2_6_1 Node4_2_6 Node4_2_7 15400.0
R_4_2_6_2 Node4_2_6 Node4_3_6 15400.0
R_4_2_6_3 Node4_2_6 Node5_2_6 0.9856000000000001
C_4_2_6 Node4_2_6 GND 1.1279296875e-09
I_4_2_7 GND Node4_2_7 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 0.001953125A 39.96us 0.001953125A 43.29us 0.001953125A 46.620000000000005us 0.001953125A 49.95us 0.001953125A 53.28us 0.001953125A 56.61us 0.001953125A 59.94us 0.001953125A 63.27us 0.001953125A 66.6us 0.001953125A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_4_2_7_1 Node4_2_7 Node4_2_8 15400.0
R_4_2_7_2 Node4_2_7 Node4_3_7 15400.0
R_4_2_7_3 Node4_2_7 Node5_2_7 0.9856000000000001
C_4_2_7 Node4_2_7 GND 1.1279296875e-09
I_4_2_8 GND Node4_2_8 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 0.001953125A 39.96us 0.001953125A 43.29us 0.001953125A 46.620000000000005us 0.001953125A 49.95us 0.001953125A 53.28us 0.001953125A 56.61us 0.001953125A 59.94us 0.001953125A 63.27us 0.001953125A 66.6us 0.001953125A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_4_2_8_1 Node4_2_8 Node4_2_9 15400.0
R_4_2_8_2 Node4_2_8 Node4_3_8 15400.0
R_4_2_8_3 Node4_2_8 Node5_2_8 0.9856000000000001
C_4_2_8 Node4_2_8 GND 1.1279296875e-09
I_4_2_9 GND Node4_2_9 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 0.001953125A 39.96us 0.001953125A 43.29us 0.001953125A 46.620000000000005us 0.001953125A 49.95us 0.001953125A 53.28us 0.001953125A 56.61us 0.001953125A 59.94us 0.001953125A 63.27us 0.001953125A 66.6us 0.001953125A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_4_2_9_1 Node4_2_9 Node4_2_10 15400.0
R_4_2_9_2 Node4_2_9 Node4_3_9 15400.0
R_4_2_9_3 Node4_2_9 Node5_2_9 0.9856000000000001
C_4_2_9 Node4_2_9 GND 1.1279296875e-09
I_4_2_10 GND Node4_2_10 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 0.001953125A 39.96us 0.001953125A 43.29us 0.001953125A 46.620000000000005us 0.001953125A 49.95us 0.001953125A 53.28us 0.001953125A 56.61us 0.001953125A 59.94us 0.001953125A 63.27us 0.001953125A 66.6us 0.001953125A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_4_2_10_1 Node4_2_10 Node4_2_11 15400.0
R_4_2_10_2 Node4_2_10 Node4_3_10 15400.0
R_4_2_10_3 Node4_2_10 Node5_2_10 0.9856000000000001
C_4_2_10 Node4_2_10 GND 1.1279296875e-09
I_4_2_11 GND Node4_2_11 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 0.001953125A 39.96us 0.001953125A 43.29us 0.001953125A 46.620000000000005us 0.001953125A 49.95us 0.001953125A 53.28us 0.001953125A 56.61us 0.001953125A 59.94us 0.001953125A 63.27us 0.001953125A 66.6us 0.001953125A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_4_2_11_1 Node4_2_11 Node4_2_12 15400.0
R_4_2_11_2 Node4_2_11 Node4_3_11 15400.0
R_4_2_11_3 Node4_2_11 Node5_2_11 0.9856000000000001
C_4_2_11 Node4_2_11 GND 1.1279296875e-09
I_4_2_12 GND Node4_2_12 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 0.001953125A 39.96us 0.001953125A 43.29us 0.001953125A 46.620000000000005us 0.001953125A 49.95us 0.001953125A 53.28us 0.001953125A 56.61us 0.001953125A 59.94us 0.001953125A 63.27us 0.001953125A 66.6us 0.001953125A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_4_2_12_1 Node4_2_12 Node4_2_13 15400.0
R_4_2_12_2 Node4_2_12 Node4_3_12 15400.0
R_4_2_12_3 Node4_2_12 Node5_2_12 0.9856000000000001
C_4_2_12 Node4_2_12 GND 1.1279296875e-09
I_4_2_13 GND Node4_2_13 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 0.001953125A 39.96us 0.001953125A 43.29us 0.001953125A 46.620000000000005us 0.001953125A 49.95us 0.001953125A 53.28us 0.001953125A 56.61us 0.001953125A 59.94us 0.001953125A 63.27us 0.001953125A 66.6us 0.001953125A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_4_2_13_1 Node4_2_13 Node4_2_14 15400.0
R_4_2_13_2 Node4_2_13 Node4_3_13 15400.0
R_4_2_13_3 Node4_2_13 Node5_2_13 0.9856000000000001
C_4_2_13 Node4_2_13 GND 1.1279296875e-09
I_4_2_14 GND Node4_2_14 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 0.001953125A 39.96us 0.001953125A 43.29us 0.001953125A 46.620000000000005us 0.001953125A 49.95us 0.001953125A 53.28us 0.001953125A 56.61us 0.001953125A 59.94us 0.001953125A 63.27us 0.001953125A 66.6us 0.001953125A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_4_2_14_1 Node4_2_14 Node4_2_15 15399.999999999993
R_4_2_14_2 Node4_2_14 Node4_3_14 15400.0
R_4_2_14_3 Node4_2_14 Node5_2_14 0.9856000000000001
C_4_2_14 Node4_2_14 GND 1.1279296875e-09
I_4_2_15 GND Node4_2_15 PWL(0s 0A 3.33us 3.906250000000002e-08A 6.66us 3.906250000000002e-08A 9.99us 3.906250000000002e-08A 13.32us 3.906250000000002e-08A 16.65us 3.906250000000002e-08A 19.98us 3.906250000000002e-08A 23.310000000000002us 3.906250000000002e-08A 26.64us 3.906250000000002e-08A 29.97us 3.906250000000002e-08A 33.3us 3.906250000000002e-08A 36.63us 0.0019531250000000017A 39.96us 0.0019531250000000017A 43.29us 0.0019531250000000017A 46.620000000000005us 0.0019531250000000017A 49.95us 0.0019531250000000017A 53.28us 0.0019531250000000017A 56.61us 0.0019531250000000017A 59.94us 0.0019531250000000017A 63.27us 0.0019531250000000017A 66.6us 0.0019531250000000017A 69.93us 3.906250000000002e-08A 73.26us 3.906250000000002e-08A 76.59us 3.906250000000002e-08A 79.92us 3.906250000000002e-08A 83.25us 3.906250000000002e-08A 86.58us 3.906250000000002e-08A 89.91us 3.906250000000002e-08A 93.24000000000001us 3.906250000000002e-08A 96.57000000000001us 3.906250000000002e-08A 99.9us 3.906250000000002e-08A)
R_4_2_15_2 Node4_2_15 Node4_3_15 15399.999999999987
R_4_2_15_3 Node4_2_15 Node5_2_15 0.9855999999999993
C_4_2_15 Node4_2_15 GND 1.127929687500001e-09
I_4_3_0 GND Node4_3_0 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 0.001953125A 39.96us 0.001953125A 43.29us 0.001953125A 46.620000000000005us 0.001953125A 49.95us 0.001953125A 53.28us 0.001953125A 56.61us 0.001953125A 59.94us 0.001953125A 63.27us 0.001953125A 66.6us 0.001953125A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_4_3_0_1 Node4_3_0 Node4_3_1 15400.0
R_4_3_0_2 Node4_3_0 Node4_4_0 15400.0
R_4_3_0_3 Node4_3_0 Node5_3_0 0.9856000000000001
C_4_3_0 Node4_3_0 GND 1.1279296875e-09
I_4_3_1 GND Node4_3_1 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 0.001953125A 39.96us 0.001953125A 43.29us 0.001953125A 46.620000000000005us 0.001953125A 49.95us 0.001953125A 53.28us 0.001953125A 56.61us 0.001953125A 59.94us 0.001953125A 63.27us 0.001953125A 66.6us 0.001953125A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_4_3_1_1 Node4_3_1 Node4_3_2 15400.0
R_4_3_1_2 Node4_3_1 Node4_4_1 15400.0
R_4_3_1_3 Node4_3_1 Node5_3_1 0.9856000000000001
C_4_3_1 Node4_3_1 GND 1.1279296875e-09
I_4_3_2 GND Node4_3_2 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 0.001953125A 39.96us 0.001953125A 43.29us 0.001953125A 46.620000000000005us 0.001953125A 49.95us 0.001953125A 53.28us 0.001953125A 56.61us 0.001953125A 59.94us 0.001953125A 63.27us 0.001953125A 66.6us 0.001953125A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_4_3_2_1 Node4_3_2 Node4_3_3 15400.0
R_4_3_2_2 Node4_3_2 Node4_4_2 15400.0
R_4_3_2_3 Node4_3_2 Node5_3_2 0.9856000000000001
C_4_3_2 Node4_3_2 GND 1.1279296875e-09
I_4_3_3 GND Node4_3_3 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 0.001953125A 39.96us 0.001953125A 43.29us 0.001953125A 46.620000000000005us 0.001953125A 49.95us 0.001953125A 53.28us 0.001953125A 56.61us 0.001953125A 59.94us 0.001953125A 63.27us 0.001953125A 66.6us 0.001953125A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_4_3_3_1 Node4_3_3 Node4_3_4 15400.0
R_4_3_3_2 Node4_3_3 Node4_4_3 15400.0
R_4_3_3_3 Node4_3_3 Node5_3_3 0.9856000000000001
C_4_3_3 Node4_3_3 GND 1.1279296875e-09
I_4_3_4 GND Node4_3_4 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 0.001953125A 39.96us 0.001953125A 43.29us 0.001953125A 46.620000000000005us 0.001953125A 49.95us 0.001953125A 53.28us 0.001953125A 56.61us 0.001953125A 59.94us 0.001953125A 63.27us 0.001953125A 66.6us 0.001953125A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_4_3_4_1 Node4_3_4 Node4_3_5 15400.0
R_4_3_4_2 Node4_3_4 Node4_4_4 15400.0
R_4_3_4_3 Node4_3_4 Node5_3_4 0.9856000000000001
C_4_3_4 Node4_3_4 GND 1.1279296875e-09
I_4_3_5 GND Node4_3_5 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 0.001953125A 39.96us 0.001953125A 43.29us 0.001953125A 46.620000000000005us 0.001953125A 49.95us 0.001953125A 53.28us 0.001953125A 56.61us 0.001953125A 59.94us 0.001953125A 63.27us 0.001953125A 66.6us 0.001953125A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_4_3_5_1 Node4_3_5 Node4_3_6 15400.0
R_4_3_5_2 Node4_3_5 Node4_4_5 15400.0
R_4_3_5_3 Node4_3_5 Node5_3_5 0.9856000000000001
C_4_3_5 Node4_3_5 GND 1.1279296875e-09
I_4_3_6 GND Node4_3_6 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 0.001953125A 39.96us 0.001953125A 43.29us 0.001953125A 46.620000000000005us 0.001953125A 49.95us 0.001953125A 53.28us 0.001953125A 56.61us 0.001953125A 59.94us 0.001953125A 63.27us 0.001953125A 66.6us 0.001953125A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_4_3_6_1 Node4_3_6 Node4_3_7 15400.0
R_4_3_6_2 Node4_3_6 Node4_4_6 15400.0
R_4_3_6_3 Node4_3_6 Node5_3_6 0.9856000000000001
C_4_3_6 Node4_3_6 GND 1.1279296875e-09
I_4_3_7 GND Node4_3_7 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 0.001953125A 39.96us 0.001953125A 43.29us 0.001953125A 46.620000000000005us 0.001953125A 49.95us 0.001953125A 53.28us 0.001953125A 56.61us 0.001953125A 59.94us 0.001953125A 63.27us 0.001953125A 66.6us 0.001953125A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_4_3_7_1 Node4_3_7 Node4_3_8 15400.0
R_4_3_7_2 Node4_3_7 Node4_4_7 15400.0
R_4_3_7_3 Node4_3_7 Node5_3_7 0.9856000000000001
C_4_3_7 Node4_3_7 GND 1.1279296875e-09
I_4_3_8 GND Node4_3_8 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 0.001953125A 39.96us 0.001953125A 43.29us 0.001953125A 46.620000000000005us 0.001953125A 49.95us 0.001953125A 53.28us 0.001953125A 56.61us 0.001953125A 59.94us 0.001953125A 63.27us 0.001953125A 66.6us 0.001953125A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_4_3_8_1 Node4_3_8 Node4_3_9 15400.0
R_4_3_8_2 Node4_3_8 Node4_4_8 15400.0
R_4_3_8_3 Node4_3_8 Node5_3_8 0.9856000000000001
C_4_3_8 Node4_3_8 GND 1.1279296875e-09
I_4_3_9 GND Node4_3_9 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 0.001953125A 39.96us 0.001953125A 43.29us 0.001953125A 46.620000000000005us 0.001953125A 49.95us 0.001953125A 53.28us 0.001953125A 56.61us 0.001953125A 59.94us 0.001953125A 63.27us 0.001953125A 66.6us 0.001953125A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_4_3_9_1 Node4_3_9 Node4_3_10 15400.0
R_4_3_9_2 Node4_3_9 Node4_4_9 15400.0
R_4_3_9_3 Node4_3_9 Node5_3_9 0.9856000000000001
C_4_3_9 Node4_3_9 GND 1.1279296875e-09
I_4_3_10 GND Node4_3_10 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 0.001953125A 39.96us 0.001953125A 43.29us 0.001953125A 46.620000000000005us 0.001953125A 49.95us 0.001953125A 53.28us 0.001953125A 56.61us 0.001953125A 59.94us 0.001953125A 63.27us 0.001953125A 66.6us 0.001953125A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_4_3_10_1 Node4_3_10 Node4_3_11 15400.0
R_4_3_10_2 Node4_3_10 Node4_4_10 15400.0
R_4_3_10_3 Node4_3_10 Node5_3_10 0.9856000000000001
C_4_3_10 Node4_3_10 GND 1.1279296875e-09
I_4_3_11 GND Node4_3_11 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 0.001953125A 39.96us 0.001953125A 43.29us 0.001953125A 46.620000000000005us 0.001953125A 49.95us 0.001953125A 53.28us 0.001953125A 56.61us 0.001953125A 59.94us 0.001953125A 63.27us 0.001953125A 66.6us 0.001953125A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_4_3_11_1 Node4_3_11 Node4_3_12 15400.0
R_4_3_11_2 Node4_3_11 Node4_4_11 15400.0
R_4_3_11_3 Node4_3_11 Node5_3_11 0.9856000000000001
C_4_3_11 Node4_3_11 GND 1.1279296875e-09
I_4_3_12 GND Node4_3_12 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 0.001953125A 39.96us 0.001953125A 43.29us 0.001953125A 46.620000000000005us 0.001953125A 49.95us 0.001953125A 53.28us 0.001953125A 56.61us 0.001953125A 59.94us 0.001953125A 63.27us 0.001953125A 66.6us 0.001953125A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_4_3_12_1 Node4_3_12 Node4_3_13 15400.0
R_4_3_12_2 Node4_3_12 Node4_4_12 15400.0
R_4_3_12_3 Node4_3_12 Node5_3_12 0.9856000000000001
C_4_3_12 Node4_3_12 GND 1.1279296875e-09
I_4_3_13 GND Node4_3_13 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 0.001953125A 39.96us 0.001953125A 43.29us 0.001953125A 46.620000000000005us 0.001953125A 49.95us 0.001953125A 53.28us 0.001953125A 56.61us 0.001953125A 59.94us 0.001953125A 63.27us 0.001953125A 66.6us 0.001953125A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_4_3_13_1 Node4_3_13 Node4_3_14 15400.0
R_4_3_13_2 Node4_3_13 Node4_4_13 15400.0
R_4_3_13_3 Node4_3_13 Node5_3_13 0.9856000000000001
C_4_3_13 Node4_3_13 GND 1.1279296875e-09
I_4_3_14 GND Node4_3_14 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 0.001953125A 39.96us 0.001953125A 43.29us 0.001953125A 46.620000000000005us 0.001953125A 49.95us 0.001953125A 53.28us 0.001953125A 56.61us 0.001953125A 59.94us 0.001953125A 63.27us 0.001953125A 66.6us 0.001953125A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_4_3_14_1 Node4_3_14 Node4_3_15 15399.999999999993
R_4_3_14_2 Node4_3_14 Node4_4_14 15400.0
R_4_3_14_3 Node4_3_14 Node5_3_14 0.9856000000000001
C_4_3_14 Node4_3_14 GND 1.1279296875e-09
I_4_3_15 GND Node4_3_15 PWL(0s 0A 3.33us 3.906250000000002e-08A 6.66us 3.906250000000002e-08A 9.99us 3.906250000000002e-08A 13.32us 3.906250000000002e-08A 16.65us 3.906250000000002e-08A 19.98us 3.906250000000002e-08A 23.310000000000002us 3.906250000000002e-08A 26.64us 3.906250000000002e-08A 29.97us 3.906250000000002e-08A 33.3us 3.906250000000002e-08A 36.63us 0.0019531250000000017A 39.96us 0.0019531250000000017A 43.29us 0.0019531250000000017A 46.620000000000005us 0.0019531250000000017A 49.95us 0.0019531250000000017A 53.28us 0.0019531250000000017A 56.61us 0.0019531250000000017A 59.94us 0.0019531250000000017A 63.27us 0.0019531250000000017A 66.6us 0.0019531250000000017A 69.93us 3.906250000000002e-08A 73.26us 3.906250000000002e-08A 76.59us 3.906250000000002e-08A 79.92us 3.906250000000002e-08A 83.25us 3.906250000000002e-08A 86.58us 3.906250000000002e-08A 89.91us 3.906250000000002e-08A 93.24000000000001us 3.906250000000002e-08A 96.57000000000001us 3.906250000000002e-08A 99.9us 3.906250000000002e-08A)
R_4_3_15_2 Node4_3_15 Node4_4_15 15399.999999999987
R_4_3_15_3 Node4_3_15 Node5_3_15 0.9855999999999993
C_4_3_15 Node4_3_15 GND 1.127929687500001e-09
I_4_4_0 GND Node4_4_0 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 0.001953125A 39.96us 0.001953125A 43.29us 0.001953125A 46.620000000000005us 0.001953125A 49.95us 0.001953125A 53.28us 0.001953125A 56.61us 0.001953125A 59.94us 0.001953125A 63.27us 0.001953125A 66.6us 0.001953125A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_4_4_0_1 Node4_4_0 Node4_4_1 15400.0
R_4_4_0_2 Node4_4_0 Node4_5_0 15400.0
R_4_4_0_3 Node4_4_0 Node5_4_0 0.9856000000000001
C_4_4_0 Node4_4_0 GND 1.1279296875e-09
I_4_4_1 GND Node4_4_1 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 0.001953125A 39.96us 0.001953125A 43.29us 0.001953125A 46.620000000000005us 0.001953125A 49.95us 0.001953125A 53.28us 0.001953125A 56.61us 0.001953125A 59.94us 0.001953125A 63.27us 0.001953125A 66.6us 0.001953125A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_4_4_1_1 Node4_4_1 Node4_4_2 15400.0
R_4_4_1_2 Node4_4_1 Node4_5_1 15400.0
R_4_4_1_3 Node4_4_1 Node5_4_1 0.9856000000000001
C_4_4_1 Node4_4_1 GND 1.1279296875e-09
I_4_4_2 GND Node4_4_2 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 0.001953125A 39.96us 0.001953125A 43.29us 0.001953125A 46.620000000000005us 0.001953125A 49.95us 0.001953125A 53.28us 0.001953125A 56.61us 0.001953125A 59.94us 0.001953125A 63.27us 0.001953125A 66.6us 0.001953125A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_4_4_2_1 Node4_4_2 Node4_4_3 15400.0
R_4_4_2_2 Node4_4_2 Node4_5_2 15400.0
R_4_4_2_3 Node4_4_2 Node5_4_2 0.9856000000000001
C_4_4_2 Node4_4_2 GND 1.1279296875e-09
I_4_4_3 GND Node4_4_3 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 0.001953125A 39.96us 0.001953125A 43.29us 0.001953125A 46.620000000000005us 0.001953125A 49.95us 0.001953125A 53.28us 0.001953125A 56.61us 0.001953125A 59.94us 0.001953125A 63.27us 0.001953125A 66.6us 0.001953125A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_4_4_3_1 Node4_4_3 Node4_4_4 15400.0
R_4_4_3_2 Node4_4_3 Node4_5_3 15400.0
R_4_4_3_3 Node4_4_3 Node5_4_3 0.9856000000000001
C_4_4_3 Node4_4_3 GND 1.1279296875e-09
I_4_4_4 GND Node4_4_4 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 0.001953125A 39.96us 0.001953125A 43.29us 0.001953125A 46.620000000000005us 0.001953125A 49.95us 0.001953125A 53.28us 0.001953125A 56.61us 0.001953125A 59.94us 0.001953125A 63.27us 0.001953125A 66.6us 0.001953125A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_4_4_4_1 Node4_4_4 Node4_4_5 15400.0
R_4_4_4_2 Node4_4_4 Node4_5_4 15400.0
R_4_4_4_3 Node4_4_4 Node5_4_4 0.9856000000000001
C_4_4_4 Node4_4_4 GND 1.1279296875e-09
I_4_4_5 GND Node4_4_5 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 0.001953125A 39.96us 0.001953125A 43.29us 0.001953125A 46.620000000000005us 0.001953125A 49.95us 0.001953125A 53.28us 0.001953125A 56.61us 0.001953125A 59.94us 0.001953125A 63.27us 0.001953125A 66.6us 0.001953125A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_4_4_5_1 Node4_4_5 Node4_4_6 15400.0
R_4_4_5_2 Node4_4_5 Node4_5_5 15400.0
R_4_4_5_3 Node4_4_5 Node5_4_5 0.9856000000000001
C_4_4_5 Node4_4_5 GND 1.1279296875e-09
I_4_4_6 GND Node4_4_6 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 0.001953125A 39.96us 0.001953125A 43.29us 0.001953125A 46.620000000000005us 0.001953125A 49.95us 0.001953125A 53.28us 0.001953125A 56.61us 0.001953125A 59.94us 0.001953125A 63.27us 0.001953125A 66.6us 0.001953125A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_4_4_6_1 Node4_4_6 Node4_4_7 15400.0
R_4_4_6_2 Node4_4_6 Node4_5_6 15400.0
R_4_4_6_3 Node4_4_6 Node5_4_6 0.9856000000000001
C_4_4_6 Node4_4_6 GND 1.1279296875e-09
I_4_4_7 GND Node4_4_7 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 0.001953125A 39.96us 0.001953125A 43.29us 0.001953125A 46.620000000000005us 0.001953125A 49.95us 0.001953125A 53.28us 0.001953125A 56.61us 0.001953125A 59.94us 0.001953125A 63.27us 0.001953125A 66.6us 0.001953125A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_4_4_7_1 Node4_4_7 Node4_4_8 15400.0
R_4_4_7_2 Node4_4_7 Node4_5_7 15400.0
R_4_4_7_3 Node4_4_7 Node5_4_7 0.9856000000000001
C_4_4_7 Node4_4_7 GND 1.1279296875e-09
I_4_4_8 GND Node4_4_8 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 0.001953125A 39.96us 0.001953125A 43.29us 0.001953125A 46.620000000000005us 0.001953125A 49.95us 0.001953125A 53.28us 0.001953125A 56.61us 0.001953125A 59.94us 0.001953125A 63.27us 0.001953125A 66.6us 0.001953125A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_4_4_8_1 Node4_4_8 Node4_4_9 15400.0
R_4_4_8_2 Node4_4_8 Node4_5_8 15400.0
R_4_4_8_3 Node4_4_8 Node5_4_8 0.9856000000000001
C_4_4_8 Node4_4_8 GND 1.1279296875e-09
I_4_4_9 GND Node4_4_9 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 0.001953125A 39.96us 0.001953125A 43.29us 0.001953125A 46.620000000000005us 0.001953125A 49.95us 0.001953125A 53.28us 0.001953125A 56.61us 0.001953125A 59.94us 0.001953125A 63.27us 0.001953125A 66.6us 0.001953125A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_4_4_9_1 Node4_4_9 Node4_4_10 15400.0
R_4_4_9_2 Node4_4_9 Node4_5_9 15400.0
R_4_4_9_3 Node4_4_9 Node5_4_9 0.9856000000000001
C_4_4_9 Node4_4_9 GND 1.1279296875e-09
I_4_4_10 GND Node4_4_10 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 0.001953125A 39.96us 0.001953125A 43.29us 0.001953125A 46.620000000000005us 0.001953125A 49.95us 0.001953125A 53.28us 0.001953125A 56.61us 0.001953125A 59.94us 0.001953125A 63.27us 0.001953125A 66.6us 0.001953125A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_4_4_10_1 Node4_4_10 Node4_4_11 15400.0
R_4_4_10_2 Node4_4_10 Node4_5_10 15400.0
R_4_4_10_3 Node4_4_10 Node5_4_10 0.9856000000000001
C_4_4_10 Node4_4_10 GND 1.1279296875e-09
I_4_4_11 GND Node4_4_11 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 0.001953125A 39.96us 0.001953125A 43.29us 0.001953125A 46.620000000000005us 0.001953125A 49.95us 0.001953125A 53.28us 0.001953125A 56.61us 0.001953125A 59.94us 0.001953125A 63.27us 0.001953125A 66.6us 0.001953125A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_4_4_11_1 Node4_4_11 Node4_4_12 15400.0
R_4_4_11_2 Node4_4_11 Node4_5_11 15400.0
R_4_4_11_3 Node4_4_11 Node5_4_11 0.9856000000000001
C_4_4_11 Node4_4_11 GND 1.1279296875e-09
I_4_4_12 GND Node4_4_12 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 0.001953125A 39.96us 0.001953125A 43.29us 0.001953125A 46.620000000000005us 0.001953125A 49.95us 0.001953125A 53.28us 0.001953125A 56.61us 0.001953125A 59.94us 0.001953125A 63.27us 0.001953125A 66.6us 0.001953125A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_4_4_12_1 Node4_4_12 Node4_4_13 15400.0
R_4_4_12_2 Node4_4_12 Node4_5_12 15400.0
R_4_4_12_3 Node4_4_12 Node5_4_12 0.9856000000000001
C_4_4_12 Node4_4_12 GND 1.1279296875e-09
I_4_4_13 GND Node4_4_13 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 0.001953125A 39.96us 0.001953125A 43.29us 0.001953125A 46.620000000000005us 0.001953125A 49.95us 0.001953125A 53.28us 0.001953125A 56.61us 0.001953125A 59.94us 0.001953125A 63.27us 0.001953125A 66.6us 0.001953125A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_4_4_13_1 Node4_4_13 Node4_4_14 15400.0
R_4_4_13_2 Node4_4_13 Node4_5_13 15400.0
R_4_4_13_3 Node4_4_13 Node5_4_13 0.9856000000000001
C_4_4_13 Node4_4_13 GND 1.1279296875e-09
I_4_4_14 GND Node4_4_14 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 0.001953125A 39.96us 0.001953125A 43.29us 0.001953125A 46.620000000000005us 0.001953125A 49.95us 0.001953125A 53.28us 0.001953125A 56.61us 0.001953125A 59.94us 0.001953125A 63.27us 0.001953125A 66.6us 0.001953125A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_4_4_14_1 Node4_4_14 Node4_4_15 15399.999999999993
R_4_4_14_2 Node4_4_14 Node4_5_14 15400.0
R_4_4_14_3 Node4_4_14 Node5_4_14 0.9856000000000001
C_4_4_14 Node4_4_14 GND 1.1279296875e-09
I_4_4_15 GND Node4_4_15 PWL(0s 0A 3.33us 3.906250000000002e-08A 6.66us 3.906250000000002e-08A 9.99us 3.906250000000002e-08A 13.32us 3.906250000000002e-08A 16.65us 3.906250000000002e-08A 19.98us 3.906250000000002e-08A 23.310000000000002us 3.906250000000002e-08A 26.64us 3.906250000000002e-08A 29.97us 3.906250000000002e-08A 33.3us 3.906250000000002e-08A 36.63us 0.0019531250000000017A 39.96us 0.0019531250000000017A 43.29us 0.0019531250000000017A 46.620000000000005us 0.0019531250000000017A 49.95us 0.0019531250000000017A 53.28us 0.0019531250000000017A 56.61us 0.0019531250000000017A 59.94us 0.0019531250000000017A 63.27us 0.0019531250000000017A 66.6us 0.0019531250000000017A 69.93us 3.906250000000002e-08A 73.26us 3.906250000000002e-08A 76.59us 3.906250000000002e-08A 79.92us 3.906250000000002e-08A 83.25us 3.906250000000002e-08A 86.58us 3.906250000000002e-08A 89.91us 3.906250000000002e-08A 93.24000000000001us 3.906250000000002e-08A 96.57000000000001us 3.906250000000002e-08A 99.9us 3.906250000000002e-08A)
R_4_4_15_2 Node4_4_15 Node4_5_15 15399.999999999987
R_4_4_15_3 Node4_4_15 Node5_4_15 0.9855999999999993
C_4_4_15 Node4_4_15 GND 1.127929687500001e-09
I_4_5_0 GND Node4_5_0 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 0.001953125A 39.96us 0.001953125A 43.29us 0.001953125A 46.620000000000005us 0.001953125A 49.95us 0.001953125A 53.28us 0.001953125A 56.61us 0.001953125A 59.94us 0.001953125A 63.27us 0.001953125A 66.6us 0.001953125A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_4_5_0_1 Node4_5_0 Node4_5_1 15400.0
R_4_5_0_2 Node4_5_0 Node4_6_0 11200.000000000004
R_4_5_0_3 Node4_5_0 Node5_5_0 0.9856000000000001
C_4_5_0 Node4_5_0 GND 1.1279296875e-09
I_4_5_1 GND Node4_5_1 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 0.001953125A 39.96us 0.001953125A 43.29us 0.001953125A 46.620000000000005us 0.001953125A 49.95us 0.001953125A 53.28us 0.001953125A 56.61us 0.001953125A 59.94us 0.001953125A 63.27us 0.001953125A 66.6us 0.001953125A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_4_5_1_1 Node4_5_1 Node4_5_2 15400.0
R_4_5_1_2 Node4_5_1 Node4_6_1 11200.000000000004
R_4_5_1_3 Node4_5_1 Node5_5_1 0.9856000000000001
C_4_5_1 Node4_5_1 GND 1.1279296875e-09
I_4_5_2 GND Node4_5_2 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 0.001953125A 39.96us 0.001953125A 43.29us 0.001953125A 46.620000000000005us 0.001953125A 49.95us 0.001953125A 53.28us 0.001953125A 56.61us 0.001953125A 59.94us 0.001953125A 63.27us 0.001953125A 66.6us 0.001953125A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_4_5_2_1 Node4_5_2 Node4_5_3 15400.0
R_4_5_2_2 Node4_5_2 Node4_6_2 11200.000000000004
R_4_5_2_3 Node4_5_2 Node5_5_2 0.9856000000000001
C_4_5_2 Node4_5_2 GND 1.1279296875e-09
I_4_5_3 GND Node4_5_3 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 0.001953125A 39.96us 0.001953125A 43.29us 0.001953125A 46.620000000000005us 0.001953125A 49.95us 0.001953125A 53.28us 0.001953125A 56.61us 0.001953125A 59.94us 0.001953125A 63.27us 0.001953125A 66.6us 0.001953125A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_4_5_3_1 Node4_5_3 Node4_5_4 15400.0
R_4_5_3_2 Node4_5_3 Node4_6_3 12176.744186046515
R_4_5_3_3 Node4_5_3 Node5_5_3 0.9856000000000001
C_4_5_3 Node4_5_3 GND 1.1279296875e-09
I_4_5_4 GND Node4_5_4 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 0.001953125A 39.96us 0.001953125A 43.29us 0.001953125A 46.620000000000005us 0.001953125A 49.95us 0.001953125A 53.28us 0.001953125A 56.61us 0.001953125A 59.94us 0.001953125A 63.27us 0.001953125A 66.6us 0.001953125A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_4_5_4_1 Node4_5_4 Node4_5_5 15400.0
R_4_5_4_2 Node4_5_4 Node4_6_4 12512.500000000004
R_4_5_4_3 Node4_5_4 Node5_5_4 0.9856000000000001
C_4_5_4 Node4_5_4 GND 1.1279296875e-09
I_4_5_5 GND Node4_5_5 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 0.001953125A 39.96us 0.001953125A 43.29us 0.001953125A 46.620000000000005us 0.001953125A 49.95us 0.001953125A 53.28us 0.001953125A 56.61us 0.001953125A 59.94us 0.001953125A 63.27us 0.001953125A 66.6us 0.001953125A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_4_5_5_1 Node4_5_5 Node4_5_6 15400.0
R_4_5_5_2 Node4_5_5 Node4_6_5 12512.500000000004
R_4_5_5_3 Node4_5_5 Node5_5_5 0.9856000000000001
C_4_5_5 Node4_5_5 GND 1.1279296875e-09
I_4_5_6 GND Node4_5_6 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 0.001953125A 39.96us 0.001953125A 43.29us 0.001953125A 46.620000000000005us 0.001953125A 49.95us 0.001953125A 53.28us 0.001953125A 56.61us 0.001953125A 59.94us 0.001953125A 63.27us 0.001953125A 66.6us 0.001953125A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_4_5_6_1 Node4_5_6 Node4_5_7 15400.0
R_4_5_6_2 Node4_5_6 Node4_6_6 16449.999999999996
R_4_5_6_3 Node4_5_6 Node5_5_6 0.9856000000000001
C_4_5_6 Node4_5_6 GND 1.1279296875e-09
I_4_5_7 GND Node4_5_7 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 0.001953125A 39.96us 0.001953125A 43.29us 0.001953125A 46.620000000000005us 0.001953125A 49.95us 0.001953125A 53.28us 0.001953125A 56.61us 0.001953125A 59.94us 0.001953125A 63.27us 0.001953125A 66.6us 0.001953125A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_4_5_7_1 Node4_5_7 Node4_5_8 15400.0
R_4_5_7_2 Node4_5_7 Node4_6_7 26949.999999999953
R_4_5_7_3 Node4_5_7 Node5_5_7 0.9856000000000001
C_4_5_7 Node4_5_7 GND 1.1279296875e-09
I_4_5_8 GND Node4_5_8 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 0.001953125A 39.96us 0.001953125A 43.29us 0.001953125A 46.620000000000005us 0.001953125A 49.95us 0.001953125A 53.28us 0.001953125A 56.61us 0.001953125A 59.94us 0.001953125A 63.27us 0.001953125A 66.6us 0.001953125A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_4_5_8_1 Node4_5_8 Node4_5_9 15400.0
R_4_5_8_2 Node4_5_8 Node4_6_8 26949.999999999953
R_4_5_8_3 Node4_5_8 Node5_5_8 0.9856000000000001
C_4_5_8 Node4_5_8 GND 1.1279296875e-09
I_4_5_9 GND Node4_5_9 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 0.001953125A 39.96us 0.001953125A 43.29us 0.001953125A 46.620000000000005us 0.001953125A 49.95us 0.001953125A 53.28us 0.001953125A 56.61us 0.001953125A 59.94us 0.001953125A 63.27us 0.001953125A 66.6us 0.001953125A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_4_5_9_1 Node4_5_9 Node4_5_10 15400.0
R_4_5_9_2 Node4_5_9 Node4_6_9 26949.999999999953
R_4_5_9_3 Node4_5_9 Node5_5_9 0.9856000000000001
C_4_5_9 Node4_5_9 GND 1.1279296875e-09
I_4_5_10 GND Node4_5_10 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 0.001953125A 39.96us 0.001953125A 43.29us 0.001953125A 46.620000000000005us 0.001953125A 49.95us 0.001953125A 53.28us 0.001953125A 56.61us 0.001953125A 59.94us 0.001953125A 63.27us 0.001953125A 66.6us 0.001953125A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_4_5_10_1 Node4_5_10 Node4_5_11 15400.0
R_4_5_10_2 Node4_5_10 Node4_6_10 26949.999999999953
R_4_5_10_3 Node4_5_10 Node5_5_10 0.9856000000000001
C_4_5_10 Node4_5_10 GND 1.1279296875e-09
I_4_5_11 GND Node4_5_11 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 0.001953125A 39.96us 0.001953125A 43.29us 0.001953125A 46.620000000000005us 0.001953125A 49.95us 0.001953125A 53.28us 0.001953125A 56.61us 0.001953125A 59.94us 0.001953125A 63.27us 0.001953125A 66.6us 0.001953125A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_4_5_11_1 Node4_5_11 Node4_5_12 15400.0
R_4_5_11_2 Node4_5_11 Node4_6_11 26949.999999999953
R_4_5_11_3 Node4_5_11 Node5_5_11 0.9856000000000001
C_4_5_11 Node4_5_11 GND 1.1279296875e-09
I_4_5_12 GND Node4_5_12 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 0.001953125A 39.96us 0.001953125A 43.29us 0.001953125A 46.620000000000005us 0.001953125A 49.95us 0.001953125A 53.28us 0.001953125A 56.61us 0.001953125A 59.94us 0.001953125A 63.27us 0.001953125A 66.6us 0.001953125A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_4_5_12_1 Node4_5_12 Node4_5_13 15400.0
R_4_5_12_2 Node4_5_12 Node4_6_12 26949.999999999953
R_4_5_12_3 Node4_5_12 Node5_5_12 0.9856000000000001
C_4_5_12 Node4_5_12 GND 1.1279296875e-09
I_4_5_13 GND Node4_5_13 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 0.001953125A 39.96us 0.001953125A 43.29us 0.001953125A 46.620000000000005us 0.001953125A 49.95us 0.001953125A 53.28us 0.001953125A 56.61us 0.001953125A 59.94us 0.001953125A 63.27us 0.001953125A 66.6us 0.001953125A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_4_5_13_1 Node4_5_13 Node4_5_14 15400.0
R_4_5_13_2 Node4_5_13 Node4_6_13 26949.999999999953
R_4_5_13_3 Node4_5_13 Node5_5_13 0.9856000000000001
C_4_5_13 Node4_5_13 GND 1.1279296875e-09
I_4_5_14 GND Node4_5_14 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 0.001953125A 39.96us 0.001953125A 43.29us 0.001953125A 46.620000000000005us 0.001953125A 49.95us 0.001953125A 53.28us 0.001953125A 56.61us 0.001953125A 59.94us 0.001953125A 63.27us 0.001953125A 66.6us 0.001953125A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_4_5_14_1 Node4_5_14 Node4_5_15 15399.999999999993
R_4_5_14_2 Node4_5_14 Node4_6_14 26949.999999999953
R_4_5_14_3 Node4_5_14 Node5_5_14 0.9856000000000001
C_4_5_14 Node4_5_14 GND 1.1279296875e-09
I_4_5_15 GND Node4_5_15 PWL(0s 0A 3.33us 3.906250000000002e-08A 6.66us 3.906250000000002e-08A 9.99us 3.906250000000002e-08A 13.32us 3.906250000000002e-08A 16.65us 3.906250000000002e-08A 19.98us 3.906250000000002e-08A 23.310000000000002us 3.906250000000002e-08A 26.64us 3.906250000000002e-08A 29.97us 3.906250000000002e-08A 33.3us 3.906250000000002e-08A 36.63us 0.0019531250000000017A 39.96us 0.0019531250000000017A 43.29us 0.0019531250000000017A 46.620000000000005us 0.0019531250000000017A 49.95us 0.0019531250000000017A 53.28us 0.0019531250000000017A 56.61us 0.0019531250000000017A 59.94us 0.0019531250000000017A 63.27us 0.0019531250000000017A 66.6us 0.0019531250000000017A 69.93us 3.906250000000002e-08A 73.26us 3.906250000000002e-08A 76.59us 3.906250000000002e-08A 79.92us 3.906250000000002e-08A 83.25us 3.906250000000002e-08A 86.58us 3.906250000000002e-08A 89.91us 3.906250000000002e-08A 93.24000000000001us 3.906250000000002e-08A 96.57000000000001us 3.906250000000002e-08A 99.9us 3.906250000000002e-08A)
R_4_5_15_2 Node4_5_15 Node4_6_15 26949.999999999924
R_4_5_15_3 Node4_5_15 Node5_5_15 0.9855999999999993
C_4_5_15 Node4_5_15 GND 1.127929687500001e-09
I_4_6_0 GND Node4_6_0 PWL(0s 0A 3.33us 8.59374999999999e-08A 6.66us 8.59374999999999e-08A 9.99us 8.59374999999999e-08A 13.32us 8.59374999999999e-08A 16.65us 8.59374999999999e-08A 19.98us 8.59374999999999e-08A 23.310000000000002us 8.59374999999999e-08A 26.64us 8.59374999999999e-08A 29.97us 8.59374999999999e-08A 33.3us 8.59374999999999e-08A 36.63us 0.03828124999999993A 39.96us 0.03828124999999993A 43.29us 0.03828124999999993A 46.620000000000005us 0.03828124999999993A 49.95us 0.03828124999999993A 53.28us 0.03828124999999993A 56.61us 0.03828124999999993A 59.94us 0.03828124999999993A 63.27us 0.03828124999999993A 66.6us 0.03828124999999993A 69.93us 8.59374999999999e-08A 73.26us 8.59374999999999e-08A 76.59us 8.59374999999999e-08A 79.92us 8.59374999999999e-08A 83.25us 8.59374999999999e-08A 86.58us 8.59374999999999e-08A 89.91us 8.59374999999999e-08A 93.24000000000001us 8.59374999999999e-08A 96.57000000000001us 8.59374999999999e-08A 99.9us 8.59374999999999e-08A)
R_4_6_0_1 Node4_6_0 Node4_6_1 7000.000000000007
R_4_6_0_2 Node4_6_0 Node4_7_0 6066.66666666667
R_4_6_0_3 Node4_6_0 Node5_6_0 0.44800000000000045
C_4_6_0 Node4_6_0 GND 2.481445312499998e-09
I_4_6_1 GND Node4_6_1 PWL(0s 0A 3.33us 8.59374999999999e-08A 6.66us 8.59374999999999e-08A 9.99us 8.59374999999999e-08A 13.32us 8.59374999999999e-08A 16.65us 8.59374999999999e-08A 19.98us 8.59374999999999e-08A 23.310000000000002us 8.59374999999999e-08A 26.64us 8.59374999999999e-08A 29.97us 8.59374999999999e-08A 33.3us 8.59374999999999e-08A 36.63us 0.03828124999999993A 39.96us 0.03828124999999993A 43.29us 0.03828124999999993A 46.620000000000005us 0.03828124999999993A 49.95us 0.03828124999999993A 53.28us 0.03828124999999993A 56.61us 0.03828124999999993A 59.94us 0.03828124999999993A 63.27us 0.03828124999999993A 66.6us 0.03828124999999993A 69.93us 8.59374999999999e-08A 73.26us 8.59374999999999e-08A 76.59us 8.59374999999999e-08A 79.92us 8.59374999999999e-08A 83.25us 8.59374999999999e-08A 86.58us 8.59374999999999e-08A 89.91us 8.59374999999999e-08A 93.24000000000001us 8.59374999999999e-08A 96.57000000000001us 8.59374999999999e-08A 99.9us 8.59374999999999e-08A)
R_4_6_1_1 Node4_6_1 Node4_6_2 7000.000000000007
R_4_6_1_2 Node4_6_1 Node4_7_1 6066.66666666667
R_4_6_1_3 Node4_6_1 Node5_6_1 0.44800000000000045
C_4_6_1 Node4_6_1 GND 2.481445312499998e-09
I_4_6_2 GND Node4_6_2 PWL(0s 0A 3.33us 8.59374999999999e-08A 6.66us 8.59374999999999e-08A 9.99us 8.59374999999999e-08A 13.32us 8.59374999999999e-08A 16.65us 8.59374999999999e-08A 19.98us 8.59374999999999e-08A 23.310000000000002us 8.59374999999999e-08A 26.64us 8.59374999999999e-08A 29.97us 8.59374999999999e-08A 33.3us 8.59374999999999e-08A 36.63us 0.03828124999999993A 39.96us 0.03828124999999993A 43.29us 0.03828124999999993A 46.620000000000005us 0.03828124999999993A 49.95us 0.03828124999999993A 53.28us 0.03828124999999993A 56.61us 0.03828124999999993A 59.94us 0.03828124999999993A 63.27us 0.03828124999999993A 66.6us 0.03828124999999993A 69.93us 8.59374999999999e-08A 73.26us 8.59374999999999e-08A 76.59us 8.59374999999999e-08A 79.92us 8.59374999999999e-08A 83.25us 8.59374999999999e-08A 86.58us 8.59374999999999e-08A 89.91us 8.59374999999999e-08A 93.24000000000001us 8.59374999999999e-08A 96.57000000000001us 8.59374999999999e-08A 99.9us 8.59374999999999e-08A)
R_4_6_2_1 Node4_6_2 Node4_6_3 7976.744186046519
R_4_6_2_2 Node4_6_2 Node4_7_2 6066.66666666667
R_4_6_2_3 Node4_6_2 Node5_6_2 0.44800000000000045
C_4_6_2 Node4_6_2 GND 2.481445312499998e-09
I_4_6_3 GND Node4_6_3 PWL(0s 0A 3.33us 6.718749999999994e-08A 6.66us 6.718749999999994e-08A 9.99us 6.718749999999994e-08A 13.32us 6.718749999999994e-08A 16.65us 6.718749999999994e-08A 19.98us 6.718749999999994e-08A 23.310000000000002us 6.718749999999994e-08A 26.64us 6.718749999999994e-08A 29.97us 6.718749999999994e-08A 33.3us 6.718749999999994e-08A 36.63us 0.01015624999999999A 39.96us 0.01015624999999999A 43.29us 0.01015624999999999A 46.620000000000005us 0.01015624999999999A 49.95us 0.01015624999999999A 53.28us 0.01015624999999999A 56.61us 0.01015624999999999A 59.94us 0.01015624999999999A 63.27us 0.01015624999999999A 66.6us 0.01015624999999999A 69.93us 6.718749999999994e-08A 73.26us 6.718749999999994e-08A 76.59us 6.718749999999994e-08A 79.92us 6.718749999999994e-08A 83.25us 6.718749999999994e-08A 86.58us 6.718749999999994e-08A 89.91us 6.718749999999994e-08A 93.24000000000001us 6.718749999999994e-08A 96.57000000000001us 6.718749999999994e-08A 99.9us 6.718749999999994e-08A)
R_4_6_3_1 Node4_6_3 Node4_6_4 9289.244186046519
R_4_6_3_2 Node4_6_3 Node4_7_3 7976.744186046515
R_4_6_3_3 Node4_6_3 Node5_6_3 0.573023255813954
C_4_6_3 Node4_6_3 GND 1.9400390624999985e-09
I_4_6_4 GND Node4_6_4 PWL(0s 0A 3.33us 6.249999999999996e-08A 6.66us 6.249999999999996e-08A 9.99us 6.249999999999996e-08A 13.32us 6.249999999999996e-08A 16.65us 6.249999999999996e-08A 19.98us 6.249999999999996e-08A 23.310000000000002us 6.249999999999996e-08A 26.64us 6.249999999999996e-08A 29.97us 6.249999999999996e-08A 33.3us 6.249999999999996e-08A 36.63us 0.003124999999999998A 39.96us 0.003124999999999998A 43.29us 0.003124999999999998A 46.620000000000005us 0.003124999999999998A 49.95us 0.003124999999999998A 53.28us 0.003124999999999998A 56.61us 0.003124999999999998A 59.94us 0.003124999999999998A 63.27us 0.003124999999999998A 66.6us 0.003124999999999998A 69.93us 6.249999999999996e-08A 73.26us 6.249999999999996e-08A 76.59us 6.249999999999996e-08A 79.92us 6.249999999999996e-08A 83.25us 6.249999999999996e-08A 86.58us 6.249999999999996e-08A 89.91us 6.249999999999996e-08A 93.24000000000001us 6.249999999999996e-08A 96.57000000000001us 6.249999999999996e-08A 99.9us 6.249999999999996e-08A)
R_4_6_4_1 Node4_6_4 Node4_6_5 9625.000000000007
R_4_6_4_2 Node4_6_4 Node4_7_4 8662.500000000004
R_4_6_4_3 Node4_6_4 Node5_6_4 0.6160000000000005
C_4_6_4 Node4_6_4 GND 1.8046874999999987e-09
I_4_6_5 GND Node4_6_5 PWL(0s 0A 3.33us 6.249999999999996e-08A 6.66us 6.249999999999996e-08A 9.99us 6.249999999999996e-08A 13.32us 6.249999999999996e-08A 16.65us 6.249999999999996e-08A 19.98us 6.249999999999996e-08A 23.310000000000002us 6.249999999999996e-08A 26.64us 6.249999999999996e-08A 29.97us 6.249999999999996e-08A 33.3us 6.249999999999996e-08A 36.63us 0.003124999999999998A 39.96us 0.003124999999999998A 43.29us 0.003124999999999998A 46.620000000000005us 0.003124999999999998A 49.95us 0.003124999999999998A 53.28us 0.003124999999999998A 56.61us 0.003124999999999998A 59.94us 0.003124999999999998A 63.27us 0.003124999999999998A 66.6us 0.003124999999999998A 69.93us 6.249999999999996e-08A 73.26us 6.249999999999996e-08A 76.59us 6.249999999999996e-08A 79.92us 6.249999999999996e-08A 83.25us 6.249999999999996e-08A 86.58us 6.249999999999996e-08A 89.91us 6.249999999999996e-08A 93.24000000000001us 6.249999999999996e-08A 96.57000000000001us 6.249999999999996e-08A 99.9us 6.249999999999996e-08A)
R_4_6_5_1 Node4_6_5 Node4_6_6 13562.5
R_4_6_5_2 Node4_6_5 Node4_7_5 8662.500000000004
R_4_6_5_3 Node4_6_5 Node5_6_5 0.6160000000000005
C_4_6_5 Node4_6_5 GND 1.8046874999999987e-09
I_4_6_6 GND Node4_6_6 PWL(0s 0A 3.33us 3.4375000000000015e-08A 6.66us 3.4375000000000015e-08A 9.99us 3.4375000000000015e-08A 13.32us 3.4375000000000015e-08A 16.65us 3.4375000000000015e-08A 19.98us 3.4375000000000015e-08A 23.310000000000002us 3.4375000000000015e-08A 26.64us 3.4375000000000015e-08A 29.97us 3.4375000000000015e-08A 33.3us 3.4375000000000015e-08A 36.63us 0.001718750000000001A 39.96us 0.001718750000000001A 43.29us 0.001718750000000001A 46.620000000000005us 0.001718750000000001A 49.95us 0.001718750000000001A 53.28us 0.001718750000000001A 56.61us 0.001718750000000001A 59.94us 0.001718750000000001A 63.27us 0.001718750000000001A 66.6us 0.001718750000000001A 69.93us 3.4375000000000015e-08A 73.26us 3.4375000000000015e-08A 76.59us 3.4375000000000015e-08A 79.92us 3.4375000000000015e-08A 83.25us 3.4375000000000015e-08A 86.58us 3.4375000000000015e-08A 89.91us 3.4375000000000015e-08A 93.24000000000001us 3.4375000000000015e-08A 96.57000000000001us 3.4375000000000015e-08A 99.9us 3.4375000000000015e-08A)
R_4_6_6_1 Node4_6_6 Node4_6_7 27999.99999999995
R_4_6_6_2 Node4_6_6 Node4_7_6 18374.999999999993
R_4_6_6_3 Node4_6_6 Node5_6_6 1.1199999999999994
C_4_6_6 Node4_6_6 GND 9.925781250000005e-10
I_4_6_7 GND Node4_6_7 PWL(0s 0A 3.33us 1.5625000000000036e-08A 6.66us 1.5625000000000036e-08A 9.99us 1.5625000000000036e-08A 13.32us 1.5625000000000036e-08A 16.65us 1.5625000000000036e-08A 19.98us 1.5625000000000036e-08A 23.310000000000002us 1.5625000000000036e-08A 26.64us 1.5625000000000036e-08A 29.97us 1.5625000000000036e-08A 33.3us 1.5625000000000036e-08A 36.63us 0.000781250000000002A 39.96us 0.000781250000000002A 43.29us 0.000781250000000002A 46.620000000000005us 0.000781250000000002A 49.95us 0.000781250000000002A 53.28us 0.000781250000000002A 56.61us 0.000781250000000002A 59.94us 0.000781250000000002A 63.27us 0.000781250000000002A 66.6us 0.000781250000000002A 69.93us 1.5625000000000036e-08A 73.26us 1.5625000000000036e-08A 76.59us 1.5625000000000036e-08A 79.92us 1.5625000000000036e-08A 83.25us 1.5625000000000036e-08A 86.58us 1.5625000000000036e-08A 89.91us 1.5625000000000036e-08A 93.24000000000001us 1.5625000000000036e-08A 96.57000000000001us 1.5625000000000036e-08A 99.9us 1.5625000000000036e-08A)
R_4_6_7_1 Node4_6_7 Node4_6_8 38499.999999999905
R_4_6_7_2 Node4_6_7 Node4_7_7 19250.000000499953
R_4_6_7_3 Node4_6_7 Node5_6_7 2.4639999999999938
C_4_6_7 Node4_6_7 GND 4.511718750000011e-10
I_4_6_8 GND Node4_6_8 PWL(0s 0A 3.33us 1.5625000000000036e-08A 6.66us 1.5625000000000036e-08A 9.99us 1.5625000000000036e-08A 13.32us 1.5625000000000036e-08A 16.65us 1.5625000000000036e-08A 19.98us 1.5625000000000036e-08A 23.310000000000002us 1.5625000000000036e-08A 26.64us 1.5625000000000036e-08A 29.97us 1.5625000000000036e-08A 33.3us 1.5625000000000036e-08A 36.63us 0.000781250000000002A 39.96us 0.000781250000000002A 43.29us 0.000781250000000002A 46.620000000000005us 0.000781250000000002A 49.95us 0.000781250000000002A 53.28us 0.000781250000000002A 56.61us 0.000781250000000002A 59.94us 0.000781250000000002A 63.27us 0.000781250000000002A 66.6us 0.000781250000000002A 69.93us 1.5625000000000036e-08A 73.26us 1.5625000000000036e-08A 76.59us 1.5625000000000036e-08A 79.92us 1.5625000000000036e-08A 83.25us 1.5625000000000036e-08A 86.58us 1.5625000000000036e-08A 89.91us 1.5625000000000036e-08A 93.24000000000001us 1.5625000000000036e-08A 96.57000000000001us 1.5625000000000036e-08A 99.9us 1.5625000000000036e-08A)
R_4_6_8_1 Node4_6_8 Node4_6_9 38499.999999999905
R_4_6_8_2 Node4_6_8 Node4_7_8 19250.000000499953
R_4_6_8_3 Node4_6_8 Node5_6_8 2.4639999999999938
C_4_6_8 Node4_6_8 GND 4.511718750000011e-10
I_4_6_9 GND Node4_6_9 PWL(0s 0A 3.33us 1.5625000000000036e-08A 6.66us 1.5625000000000036e-08A 9.99us 1.5625000000000036e-08A 13.32us 1.5625000000000036e-08A 16.65us 1.5625000000000036e-08A 19.98us 1.5625000000000036e-08A 23.310000000000002us 1.5625000000000036e-08A 26.64us 1.5625000000000036e-08A 29.97us 1.5625000000000036e-08A 33.3us 1.5625000000000036e-08A 36.63us 0.000781250000000002A 39.96us 0.000781250000000002A 43.29us 0.000781250000000002A 46.620000000000005us 0.000781250000000002A 49.95us 0.000781250000000002A 53.28us 0.000781250000000002A 56.61us 0.000781250000000002A 59.94us 0.000781250000000002A 63.27us 0.000781250000000002A 66.6us 0.000781250000000002A 69.93us 1.5625000000000036e-08A 73.26us 1.5625000000000036e-08A 76.59us 1.5625000000000036e-08A 79.92us 1.5625000000000036e-08A 83.25us 1.5625000000000036e-08A 86.58us 1.5625000000000036e-08A 89.91us 1.5625000000000036e-08A 93.24000000000001us 1.5625000000000036e-08A 96.57000000000001us 1.5625000000000036e-08A 99.9us 1.5625000000000036e-08A)
R_4_6_9_1 Node4_6_9 Node4_6_10 38499.999999999905
R_4_6_9_2 Node4_6_9 Node4_7_9 19250.000000499953
R_4_6_9_3 Node4_6_9 Node5_6_9 2.4639999999999938
C_4_6_9 Node4_6_9 GND 4.511718750000011e-10
I_4_6_10 GND Node4_6_10 PWL(0s 0A 3.33us 1.5625000000000036e-08A 6.66us 1.5625000000000036e-08A 9.99us 1.5625000000000036e-08A 13.32us 1.5625000000000036e-08A 16.65us 1.5625000000000036e-08A 19.98us 1.5625000000000036e-08A 23.310000000000002us 1.5625000000000036e-08A 26.64us 1.5625000000000036e-08A 29.97us 1.5625000000000036e-08A 33.3us 1.5625000000000036e-08A 36.63us 0.000781250000000002A 39.96us 0.000781250000000002A 43.29us 0.000781250000000002A 46.620000000000005us 0.000781250000000002A 49.95us 0.000781250000000002A 53.28us 0.000781250000000002A 56.61us 0.000781250000000002A 59.94us 0.000781250000000002A 63.27us 0.000781250000000002A 66.6us 0.000781250000000002A 69.93us 1.5625000000000036e-08A 73.26us 1.5625000000000036e-08A 76.59us 1.5625000000000036e-08A 79.92us 1.5625000000000036e-08A 83.25us 1.5625000000000036e-08A 86.58us 1.5625000000000036e-08A 89.91us 1.5625000000000036e-08A 93.24000000000001us 1.5625000000000036e-08A 96.57000000000001us 1.5625000000000036e-08A 99.9us 1.5625000000000036e-08A)
R_4_6_10_1 Node4_6_10 Node4_6_11 38499.999999999905
R_4_6_10_2 Node4_6_10 Node4_7_10 19250.000000499953
R_4_6_10_3 Node4_6_10 Node5_6_10 2.4639999999999938
C_4_6_10 Node4_6_10 GND 4.511718750000011e-10
I_4_6_11 GND Node4_6_11 PWL(0s 0A 3.33us 1.5625000000000036e-08A 6.66us 1.5625000000000036e-08A 9.99us 1.5625000000000036e-08A 13.32us 1.5625000000000036e-08A 16.65us 1.5625000000000036e-08A 19.98us 1.5625000000000036e-08A 23.310000000000002us 1.5625000000000036e-08A 26.64us 1.5625000000000036e-08A 29.97us 1.5625000000000036e-08A 33.3us 1.5625000000000036e-08A 36.63us 0.000781250000000002A 39.96us 0.000781250000000002A 43.29us 0.000781250000000002A 46.620000000000005us 0.000781250000000002A 49.95us 0.000781250000000002A 53.28us 0.000781250000000002A 56.61us 0.000781250000000002A 59.94us 0.000781250000000002A 63.27us 0.000781250000000002A 66.6us 0.000781250000000002A 69.93us 1.5625000000000036e-08A 73.26us 1.5625000000000036e-08A 76.59us 1.5625000000000036e-08A 79.92us 1.5625000000000036e-08A 83.25us 1.5625000000000036e-08A 86.58us 1.5625000000000036e-08A 89.91us 1.5625000000000036e-08A 93.24000000000001us 1.5625000000000036e-08A 96.57000000000001us 1.5625000000000036e-08A 99.9us 1.5625000000000036e-08A)
R_4_6_11_1 Node4_6_11 Node4_6_12 38499.999999999905
R_4_6_11_2 Node4_6_11 Node4_7_11 19250.000000499953
R_4_6_11_3 Node4_6_11 Node5_6_11 2.4639999999999938
C_4_6_11 Node4_6_11 GND 4.511718750000011e-10
I_4_6_12 GND Node4_6_12 PWL(0s 0A 3.33us 1.5625000000000036e-08A 6.66us 1.5625000000000036e-08A 9.99us 1.5625000000000036e-08A 13.32us 1.5625000000000036e-08A 16.65us 1.5625000000000036e-08A 19.98us 1.5625000000000036e-08A 23.310000000000002us 1.5625000000000036e-08A 26.64us 1.5625000000000036e-08A 29.97us 1.5625000000000036e-08A 33.3us 1.5625000000000036e-08A 36.63us 0.000781250000000002A 39.96us 0.000781250000000002A 43.29us 0.000781250000000002A 46.620000000000005us 0.000781250000000002A 49.95us 0.000781250000000002A 53.28us 0.000781250000000002A 56.61us 0.000781250000000002A 59.94us 0.000781250000000002A 63.27us 0.000781250000000002A 66.6us 0.000781250000000002A 69.93us 1.5625000000000036e-08A 73.26us 1.5625000000000036e-08A 76.59us 1.5625000000000036e-08A 79.92us 1.5625000000000036e-08A 83.25us 1.5625000000000036e-08A 86.58us 1.5625000000000036e-08A 89.91us 1.5625000000000036e-08A 93.24000000000001us 1.5625000000000036e-08A 96.57000000000001us 1.5625000000000036e-08A 99.9us 1.5625000000000036e-08A)
R_4_6_12_1 Node4_6_12 Node4_6_13 38499.999999999905
R_4_6_12_2 Node4_6_12 Node4_7_12 19250.000000499953
R_4_6_12_3 Node4_6_12 Node5_6_12 2.4639999999999938
C_4_6_12 Node4_6_12 GND 4.511718750000011e-10
I_4_6_13 GND Node4_6_13 PWL(0s 0A 3.33us 1.5625000000000036e-08A 6.66us 1.5625000000000036e-08A 9.99us 1.5625000000000036e-08A 13.32us 1.5625000000000036e-08A 16.65us 1.5625000000000036e-08A 19.98us 1.5625000000000036e-08A 23.310000000000002us 1.5625000000000036e-08A 26.64us 1.5625000000000036e-08A 29.97us 1.5625000000000036e-08A 33.3us 1.5625000000000036e-08A 36.63us 0.000781250000000002A 39.96us 0.000781250000000002A 43.29us 0.000781250000000002A 46.620000000000005us 0.000781250000000002A 49.95us 0.000781250000000002A 53.28us 0.000781250000000002A 56.61us 0.000781250000000002A 59.94us 0.000781250000000002A 63.27us 0.000781250000000002A 66.6us 0.000781250000000002A 69.93us 1.5625000000000036e-08A 73.26us 1.5625000000000036e-08A 76.59us 1.5625000000000036e-08A 79.92us 1.5625000000000036e-08A 83.25us 1.5625000000000036e-08A 86.58us 1.5625000000000036e-08A 89.91us 1.5625000000000036e-08A 93.24000000000001us 1.5625000000000036e-08A 96.57000000000001us 1.5625000000000036e-08A 99.9us 1.5625000000000036e-08A)
R_4_6_13_1 Node4_6_13 Node4_6_14 38499.999999999905
R_4_6_13_2 Node4_6_13 Node4_7_13 19250.000000499953
R_4_6_13_3 Node4_6_13 Node5_6_13 2.4639999999999938
C_4_6_13 Node4_6_13 GND 4.511718750000011e-10
I_4_6_14 GND Node4_6_14 PWL(0s 0A 3.33us 1.5625000000000036e-08A 6.66us 1.5625000000000036e-08A 9.99us 1.5625000000000036e-08A 13.32us 1.5625000000000036e-08A 16.65us 1.5625000000000036e-08A 19.98us 1.5625000000000036e-08A 23.310000000000002us 1.5625000000000036e-08A 26.64us 1.5625000000000036e-08A 29.97us 1.5625000000000036e-08A 33.3us 1.5625000000000036e-08A 36.63us 0.000781250000000002A 39.96us 0.000781250000000002A 43.29us 0.000781250000000002A 46.620000000000005us 0.000781250000000002A 49.95us 0.000781250000000002A 53.28us 0.000781250000000002A 56.61us 0.000781250000000002A 59.94us 0.000781250000000002A 63.27us 0.000781250000000002A 66.6us 0.000781250000000002A 69.93us 1.5625000000000036e-08A 73.26us 1.5625000000000036e-08A 76.59us 1.5625000000000036e-08A 79.92us 1.5625000000000036e-08A 83.25us 1.5625000000000036e-08A 86.58us 1.5625000000000036e-08A 89.91us 1.5625000000000036e-08A 93.24000000000001us 1.5625000000000036e-08A 96.57000000000001us 1.5625000000000036e-08A 99.9us 1.5625000000000036e-08A)
R_4_6_14_1 Node4_6_14 Node4_6_15 38499.99999999988
R_4_6_14_2 Node4_6_14 Node4_7_14 19250.000000499953
R_4_6_14_3 Node4_6_14 Node5_6_14 2.4639999999999938
C_4_6_14 Node4_6_14 GND 4.511718750000011e-10
I_4_6_15 GND Node4_6_15 PWL(0s 0A 3.33us 1.5625000000000052e-08A 6.66us 1.5625000000000052e-08A 9.99us 1.5625000000000052e-08A 13.32us 1.5625000000000052e-08A 16.65us 1.5625000000000052e-08A 19.98us 1.5625000000000052e-08A 23.310000000000002us 1.5625000000000052e-08A 26.64us 1.5625000000000052e-08A 29.97us 1.5625000000000052e-08A 33.3us 1.5625000000000052e-08A 36.63us 0.0007812500000000028A 39.96us 0.0007812500000000028A 43.29us 0.0007812500000000028A 46.620000000000005us 0.0007812500000000028A 49.95us 0.0007812500000000028A 53.28us 0.0007812500000000028A 56.61us 0.0007812500000000028A 59.94us 0.0007812500000000028A 63.27us 0.0007812500000000028A 66.6us 0.0007812500000000028A 69.93us 1.5625000000000052e-08A 73.26us 1.5625000000000052e-08A 76.59us 1.5625000000000052e-08A 79.92us 1.5625000000000052e-08A 83.25us 1.5625000000000052e-08A 86.58us 1.5625000000000052e-08A 89.91us 1.5625000000000052e-08A 93.24000000000001us 1.5625000000000052e-08A 96.57000000000001us 1.5625000000000052e-08A 99.9us 1.5625000000000052e-08A)
R_4_6_15_2 Node4_6_15 Node4_7_15 19250.00000049993
R_4_6_15_3 Node4_6_15 Node5_6_15 2.4639999999999915
C_4_6_15 Node4_6_15 GND 4.511718750000016e-10
I_4_7_0 GND Node4_7_0 PWL(0s 0A 3.33us 1.1718749999999999e-07A 6.66us 1.1718749999999999e-07A 9.99us 1.1718749999999999e-07A 13.32us 1.1718749999999999e-07A 16.65us 1.1718749999999999e-07A 19.98us 1.1718749999999999e-07A 23.310000000000002us 1.1718749999999999e-07A 26.64us 1.1718749999999999e-07A 29.97us 1.1718749999999999e-07A 33.3us 1.1718749999999999e-07A 36.63us 0.0625A 39.96us 0.0625A 43.29us 0.0625A 46.620000000000005us 0.0625A 49.95us 0.0625A 53.28us 0.0625A 56.61us 0.0625A 59.94us 0.0625A 63.27us 0.0625A 66.6us 0.0625A 69.93us 1.1718749999999999e-07A 73.26us 1.1718749999999999e-07A 76.59us 1.1718749999999999e-07A 79.92us 1.1718749999999999e-07A 83.25us 1.1718749999999999e-07A 86.58us 1.1718749999999999e-07A 89.91us 1.1718749999999999e-07A 93.24000000000001us 1.1718749999999999e-07A 96.57000000000001us 1.1718749999999999e-07A 99.9us 1.1718749999999999e-07A)
R_4_7_0_1 Node4_7_0 Node4_7_1 5133.333333333333
R_4_7_0_2 Node4_7_0 Node4_8_0 5133.333333333333
R_4_7_0_3 Node4_7_0 Node5_7_0 0.32853333333333334
C_4_7_0 Node4_7_0 GND 3.3837890625e-09
I_4_7_1 GND Node4_7_1 PWL(0s 0A 3.33us 1.1718749999999999e-07A 6.66us 1.1718749999999999e-07A 9.99us 1.1718749999999999e-07A 13.32us 1.1718749999999999e-07A 16.65us 1.1718749999999999e-07A 19.98us 1.1718749999999999e-07A 23.310000000000002us 1.1718749999999999e-07A 26.64us 1.1718749999999999e-07A 29.97us 1.1718749999999999e-07A 33.3us 1.1718749999999999e-07A 36.63us 0.0625A 39.96us 0.0625A 43.29us 0.0625A 46.620000000000005us 0.0625A 49.95us 0.0625A 53.28us 0.0625A 56.61us 0.0625A 59.94us 0.0625A 63.27us 0.0625A 66.6us 0.0625A 69.93us 1.1718749999999999e-07A 73.26us 1.1718749999999999e-07A 76.59us 1.1718749999999999e-07A 79.92us 1.1718749999999999e-07A 83.25us 1.1718749999999999e-07A 86.58us 1.1718749999999999e-07A 89.91us 1.1718749999999999e-07A 93.24000000000001us 1.1718749999999999e-07A 96.57000000000001us 1.1718749999999999e-07A 99.9us 1.1718749999999999e-07A)
R_4_7_1_1 Node4_7_1 Node4_7_2 5133.333333333333
R_4_7_1_2 Node4_7_1 Node4_8_1 5133.333333333333
R_4_7_1_3 Node4_7_1 Node5_7_1 0.32853333333333334
C_4_7_1 Node4_7_1 GND 3.3837890625e-09
I_4_7_2 GND Node4_7_2 PWL(0s 0A 3.33us 1.1718749999999999e-07A 6.66us 1.1718749999999999e-07A 9.99us 1.1718749999999999e-07A 13.32us 1.1718749999999999e-07A 16.65us 1.1718749999999999e-07A 19.98us 1.1718749999999999e-07A 23.310000000000002us 1.1718749999999999e-07A 26.64us 1.1718749999999999e-07A 29.97us 1.1718749999999999e-07A 33.3us 1.1718749999999999e-07A 36.63us 0.0625A 39.96us 0.0625A 43.29us 0.0625A 46.620000000000005us 0.0625A 49.95us 0.0625A 53.28us 0.0625A 56.61us 0.0625A 59.94us 0.0625A 63.27us 0.0625A 66.6us 0.0625A 69.93us 1.1718749999999999e-07A 73.26us 1.1718749999999999e-07A 76.59us 1.1718749999999999e-07A 79.92us 1.1718749999999999e-07A 83.25us 1.1718749999999999e-07A 86.58us 1.1718749999999999e-07A 89.91us 1.1718749999999999e-07A 93.24000000000001us 1.1718749999999999e-07A 96.57000000000001us 1.1718749999999999e-07A 99.9us 1.1718749999999999e-07A)
R_4_7_2_1 Node4_7_2 Node4_7_3 6066.666666666666
R_4_7_2_2 Node4_7_2 Node4_8_2 5133.333333333333
R_4_7_2_3 Node4_7_2 Node5_7_2 0.32853333333333334
C_4_7_2 Node4_7_2 GND 3.3837890625e-09
I_4_7_3 GND Node4_7_3 PWL(0s 0A 3.33us 8.59375e-08A 6.66us 8.59375e-08A 9.99us 8.59375e-08A 13.32us 8.59375e-08A 16.65us 8.59375e-08A 19.98us 8.59375e-08A 23.310000000000002us 8.59375e-08A 26.64us 8.59375e-08A 29.97us 8.59375e-08A 33.3us 8.59375e-08A 36.63us 0.015625000000000007A 39.96us 0.015625000000000007A 43.29us 0.015625000000000007A 46.620000000000005us 0.015625000000000007A 49.95us 0.015625000000000007A 53.28us 0.015625000000000007A 56.61us 0.015625000000000007A 59.94us 0.015625000000000007A 63.27us 0.015625000000000007A 66.6us 0.015625000000000007A 69.93us 8.59375e-08A 73.26us 8.59375e-08A 76.59us 8.59375e-08A 79.92us 8.59375e-08A 83.25us 8.59375e-08A 86.58us 8.59375e-08A 89.91us 8.59375e-08A 93.24000000000001us 8.59375e-08A 96.57000000000001us 8.59375e-08A 99.9us 8.59375e-08A)
R_4_7_3_1 Node4_7_3 Node4_7_4 7350.0
R_4_7_3_2 Node4_7_3 Node4_8_3 6999.999999999999
R_4_7_3_3 Node4_7_3 Node5_7_3 0.44800000000000006
C_4_7_3 Node4_7_3 GND 2.4814453125e-09
I_4_7_4 GND Node4_7_4 PWL(0s 0A 3.33us 7.812499999999999e-08A 6.66us 7.812499999999999e-08A 9.99us 7.812499999999999e-08A 13.32us 7.812499999999999e-08A 16.65us 7.812499999999999e-08A 19.98us 7.812499999999999e-08A 23.310000000000002us 7.812499999999999e-08A 26.64us 7.812499999999999e-08A 29.97us 7.812499999999999e-08A 33.3us 7.812499999999999e-08A 36.63us 0.00390625A 39.96us 0.00390625A 43.29us 0.00390625A 46.620000000000005us 0.00390625A 49.95us 0.00390625A 53.28us 0.00390625A 56.61us 0.00390625A 59.94us 0.00390625A 63.27us 0.00390625A 66.6us 0.00390625A 69.93us 7.812499999999999e-08A 73.26us 7.812499999999999e-08A 76.59us 7.812499999999999e-08A 79.92us 7.812499999999999e-08A 83.25us 7.812499999999999e-08A 86.58us 7.812499999999999e-08A 89.91us 7.812499999999999e-08A 93.24000000000001us 7.812499999999999e-08A 96.57000000000001us 7.812499999999999e-08A 99.9us 7.812499999999999e-08A)
R_4_7_4_1 Node4_7_4 Node4_7_5 7700.0
R_4_7_4_2 Node4_7_4 Node4_8_4 7700.0
R_4_7_4_3 Node4_7_4 Node5_7_4 0.49280000000000007
C_4_7_4 Node4_7_4 GND 2.255859375e-09
I_4_7_5 GND Node4_7_5 PWL(0s 0A 3.33us 7.812499999999999e-08A 6.66us 7.812499999999999e-08A 9.99us 7.812499999999999e-08A 13.32us 7.812499999999999e-08A 16.65us 7.812499999999999e-08A 19.98us 7.812499999999999e-08A 23.310000000000002us 7.812499999999999e-08A 26.64us 7.812499999999999e-08A 29.97us 7.812499999999999e-08A 33.3us 7.812499999999999e-08A 36.63us 0.00390625A 39.96us 0.00390625A 43.29us 0.00390625A 46.620000000000005us 0.00390625A 49.95us 0.00390625A 53.28us 0.00390625A 56.61us 0.00390625A 59.94us 0.00390625A 63.27us 0.00390625A 66.6us 0.00390625A 69.93us 7.812499999999999e-08A 73.26us 7.812499999999999e-08A 76.59us 7.812499999999999e-08A 79.92us 7.812499999999999e-08A 83.25us 7.812499999999999e-08A 86.58us 7.812499999999999e-08A 89.91us 7.812499999999999e-08A 93.24000000000001us 7.812499999999999e-08A 96.57000000000001us 7.812499999999999e-08A 99.9us 7.812499999999999e-08A)
R_4_7_5_1 Node4_7_5 Node4_7_6 13474.999999999996
R_4_7_5_2 Node4_7_5 Node4_8_5 7700.0
R_4_7_5_3 Node4_7_5 Node5_7_5 0.49280000000000007
C_4_7_5 Node4_7_5 GND 2.255859375e-09
I_4_7_6 GND Node4_7_6 PWL(0s 0A 3.33us 3.125000000000001e-08A 6.66us 3.125000000000001e-08A 9.99us 3.125000000000001e-08A 13.32us 3.125000000000001e-08A 16.65us 3.125000000000001e-08A 19.98us 3.125000000000001e-08A 23.310000000000002us 3.125000000000001e-08A 26.64us 3.125000000000001e-08A 29.97us 3.125000000000001e-08A 33.3us 3.125000000000001e-08A 36.63us 0.0015625000000000007A 39.96us 0.0015625000000000007A 43.29us 0.0015625000000000007A 46.620000000000005us 0.0015625000000000007A 49.95us 0.0015625000000000007A 53.28us 0.0015625000000000007A 56.61us 0.0015625000000000007A 59.94us 0.0015625000000000007A 63.27us 0.0015625000000000007A 66.6us 0.0015625000000000007A 69.93us 3.125000000000001e-08A 73.26us 3.125000000000001e-08A 76.59us 3.125000000000001e-08A 79.92us 3.125000000000001e-08A 83.25us 3.125000000000001e-08A 86.58us 3.125000000000001e-08A 89.91us 3.125000000000001e-08A 93.24000000000001us 3.125000000000001e-08A 96.57000000000001us 3.125000000000001e-08A 99.9us 3.125000000000001e-08A)
R_4_7_6_1 Node4_7_6 Node4_7_7 9625.000000499997
R_4_7_6_2 Node4_7_6 Node4_8_6 19249.999999999993
R_4_7_6_3 Node4_7_6 Node5_7_6 1.2319999999999995
C_4_7_6 Node4_7_6 GND 9.023437500000004e-10
R_4_7_7_1 Node4_7_7 Node4_7_8 1e-06
R_4_7_7_2 Node4_7_7 Node4_8_7 1e-06
R_4_7_7_3 Node4_7_7 Node5_7_7 1e-06
C_4_7_7 Node4_7_7 GND 0.0
R_4_7_8_1 Node4_7_8 Node4_7_9 1e-06
R_4_7_8_2 Node4_7_8 Node4_8_8 1e-06
R_4_7_8_3 Node4_7_8 Node5_7_8 1e-06
C_4_7_8 Node4_7_8 GND 0.0
R_4_7_9_1 Node4_7_9 Node4_7_10 1e-06
R_4_7_9_2 Node4_7_9 Node4_8_9 1e-06
R_4_7_9_3 Node4_7_9 Node5_7_9 1e-06
C_4_7_9 Node4_7_9 GND 0.0
R_4_7_10_1 Node4_7_10 Node4_7_11 1e-06
R_4_7_10_2 Node4_7_10 Node4_8_10 1e-06
R_4_7_10_3 Node4_7_10 Node5_7_10 1e-06
C_4_7_10 Node4_7_10 GND 0.0
R_4_7_11_1 Node4_7_11 Node4_7_12 1e-06
R_4_7_11_2 Node4_7_11 Node4_8_11 1e-06
R_4_7_11_3 Node4_7_11 Node5_7_11 1e-06
C_4_7_11 Node4_7_11 GND 0.0
R_4_7_12_1 Node4_7_12 Node4_7_13 1e-06
R_4_7_12_2 Node4_7_12 Node4_8_12 1e-06
R_4_7_12_3 Node4_7_12 Node5_7_12 1e-06
C_4_7_12 Node4_7_12 GND 0.0
R_4_7_13_1 Node4_7_13 Node4_7_14 1e-06
R_4_7_13_2 Node4_7_13 Node4_8_13 1e-06
R_4_7_13_3 Node4_7_13 Node5_7_13 1e-06
C_4_7_13 Node4_7_13 GND 0.0
R_4_7_14_1 Node4_7_14 Node4_7_15 1e-06
R_4_7_14_2 Node4_7_14 Node4_8_14 1e-06
R_4_7_14_3 Node4_7_14 Node5_7_14 1e-06
C_4_7_14 Node4_7_14 GND 0.0
R_4_7_15_2 Node4_7_15 Node4_8_15 1e-06
R_4_7_15_3 Node4_7_15 Node5_7_15 1e-06
C_4_7_15 Node4_7_15 GND 0.0
I_4_8_0 GND Node4_8_0 PWL(0s 0A 3.33us 1.1718749999999999e-07A 6.66us 1.1718749999999999e-07A 9.99us 1.1718749999999999e-07A 13.32us 1.1718749999999999e-07A 16.65us 1.1718749999999999e-07A 19.98us 1.1718749999999999e-07A 23.310000000000002us 1.1718749999999999e-07A 26.64us 1.1718749999999999e-07A 29.97us 1.1718749999999999e-07A 33.3us 1.1718749999999999e-07A 36.63us 0.0625A 39.96us 0.0625A 43.29us 0.0625A 46.620000000000005us 0.0625A 49.95us 0.0625A 53.28us 0.0625A 56.61us 0.0625A 59.94us 0.0625A 63.27us 0.0625A 66.6us 0.0625A 69.93us 1.1718749999999999e-07A 73.26us 1.1718749999999999e-07A 76.59us 1.1718749999999999e-07A 79.92us 1.1718749999999999e-07A 83.25us 1.1718749999999999e-07A 86.58us 1.1718749999999999e-07A 89.91us 1.1718749999999999e-07A 93.24000000000001us 1.1718749999999999e-07A 96.57000000000001us 1.1718749999999999e-07A 99.9us 1.1718749999999999e-07A)
R_4_8_0_1 Node4_8_0 Node4_8_1 5133.333333333333
R_4_8_0_2 Node4_8_0 Node4_9_0 6066.666666666668
R_4_8_0_3 Node4_8_0 Node5_8_0 0.32853333333333334
C_4_8_0 Node4_8_0 GND 3.3837890625e-09
I_4_8_1 GND Node4_8_1 PWL(0s 0A 3.33us 1.1718749999999999e-07A 6.66us 1.1718749999999999e-07A 9.99us 1.1718749999999999e-07A 13.32us 1.1718749999999999e-07A 16.65us 1.1718749999999999e-07A 19.98us 1.1718749999999999e-07A 23.310000000000002us 1.1718749999999999e-07A 26.64us 1.1718749999999999e-07A 29.97us 1.1718749999999999e-07A 33.3us 1.1718749999999999e-07A 36.63us 0.0625A 39.96us 0.0625A 43.29us 0.0625A 46.620000000000005us 0.0625A 49.95us 0.0625A 53.28us 0.0625A 56.61us 0.0625A 59.94us 0.0625A 63.27us 0.0625A 66.6us 0.0625A 69.93us 1.1718749999999999e-07A 73.26us 1.1718749999999999e-07A 76.59us 1.1718749999999999e-07A 79.92us 1.1718749999999999e-07A 83.25us 1.1718749999999999e-07A 86.58us 1.1718749999999999e-07A 89.91us 1.1718749999999999e-07A 93.24000000000001us 1.1718749999999999e-07A 96.57000000000001us 1.1718749999999999e-07A 99.9us 1.1718749999999999e-07A)
R_4_8_1_1 Node4_8_1 Node4_8_2 5133.333333333333
R_4_8_1_2 Node4_8_1 Node4_9_1 6066.666666666668
R_4_8_1_3 Node4_8_1 Node5_8_1 0.32853333333333334
C_4_8_1 Node4_8_1 GND 3.3837890625e-09
I_4_8_2 GND Node4_8_2 PWL(0s 0A 3.33us 1.1718749999999999e-07A 6.66us 1.1718749999999999e-07A 9.99us 1.1718749999999999e-07A 13.32us 1.1718749999999999e-07A 16.65us 1.1718749999999999e-07A 19.98us 1.1718749999999999e-07A 23.310000000000002us 1.1718749999999999e-07A 26.64us 1.1718749999999999e-07A 29.97us 1.1718749999999999e-07A 33.3us 1.1718749999999999e-07A 36.63us 0.0625A 39.96us 0.0625A 43.29us 0.0625A 46.620000000000005us 0.0625A 49.95us 0.0625A 53.28us 0.0625A 56.61us 0.0625A 59.94us 0.0625A 63.27us 0.0625A 66.6us 0.0625A 69.93us 1.1718749999999999e-07A 73.26us 1.1718749999999999e-07A 76.59us 1.1718749999999999e-07A 79.92us 1.1718749999999999e-07A 83.25us 1.1718749999999999e-07A 86.58us 1.1718749999999999e-07A 89.91us 1.1718749999999999e-07A 93.24000000000001us 1.1718749999999999e-07A 96.57000000000001us 1.1718749999999999e-07A 99.9us 1.1718749999999999e-07A)
R_4_8_2_1 Node4_8_2 Node4_8_3 6066.666666666666
R_4_8_2_2 Node4_8_2 Node4_9_2 6066.666666666668
R_4_8_2_3 Node4_8_2 Node5_8_2 0.32853333333333334
C_4_8_2 Node4_8_2 GND 3.3837890625e-09
I_4_8_3 GND Node4_8_3 PWL(0s 0A 3.33us 8.59375e-08A 6.66us 8.59375e-08A 9.99us 8.59375e-08A 13.32us 8.59375e-08A 16.65us 8.59375e-08A 19.98us 8.59375e-08A 23.310000000000002us 8.59375e-08A 26.64us 8.59375e-08A 29.97us 8.59375e-08A 33.3us 8.59375e-08A 36.63us 0.015625000000000007A 39.96us 0.015625000000000007A 43.29us 0.015625000000000007A 46.620000000000005us 0.015625000000000007A 49.95us 0.015625000000000007A 53.28us 0.015625000000000007A 56.61us 0.015625000000000007A 59.94us 0.015625000000000007A 63.27us 0.015625000000000007A 66.6us 0.015625000000000007A 69.93us 8.59375e-08A 73.26us 8.59375e-08A 76.59us 8.59375e-08A 79.92us 8.59375e-08A 83.25us 8.59375e-08A 86.58us 8.59375e-08A 89.91us 8.59375e-08A 93.24000000000001us 8.59375e-08A 96.57000000000001us 8.59375e-08A 99.9us 8.59375e-08A)
R_4_8_3_1 Node4_8_3 Node4_8_4 7350.0
R_4_8_3_2 Node4_8_3 Node4_9_3 7976.744186046513
R_4_8_3_3 Node4_8_3 Node5_8_3 0.44800000000000006
C_4_8_3 Node4_8_3 GND 2.4814453125e-09
I_4_8_4 GND Node4_8_4 PWL(0s 0A 3.33us 7.812499999999999e-08A 6.66us 7.812499999999999e-08A 9.99us 7.812499999999999e-08A 13.32us 7.812499999999999e-08A 16.65us 7.812499999999999e-08A 19.98us 7.812499999999999e-08A 23.310000000000002us 7.812499999999999e-08A 26.64us 7.812499999999999e-08A 29.97us 7.812499999999999e-08A 33.3us 7.812499999999999e-08A 36.63us 0.00390625A 39.96us 0.00390625A 43.29us 0.00390625A 46.620000000000005us 0.00390625A 49.95us 0.00390625A 53.28us 0.00390625A 56.61us 0.00390625A 59.94us 0.00390625A 63.27us 0.00390625A 66.6us 0.00390625A 69.93us 7.812499999999999e-08A 73.26us 7.812499999999999e-08A 76.59us 7.812499999999999e-08A 79.92us 7.812499999999999e-08A 83.25us 7.812499999999999e-08A 86.58us 7.812499999999999e-08A 89.91us 7.812499999999999e-08A 93.24000000000001us 7.812499999999999e-08A 96.57000000000001us 7.812499999999999e-08A 99.9us 7.812499999999999e-08A)
R_4_8_4_1 Node4_8_4 Node4_8_5 7700.0
R_4_8_4_2 Node4_8_4 Node4_9_4 8662.500000000004
R_4_8_4_3 Node4_8_4 Node5_8_4 0.49280000000000007
C_4_8_4 Node4_8_4 GND 2.255859375e-09
I_4_8_5 GND Node4_8_5 PWL(0s 0A 3.33us 7.812499999999999e-08A 6.66us 7.812499999999999e-08A 9.99us 7.812499999999999e-08A 13.32us 7.812499999999999e-08A 16.65us 7.812499999999999e-08A 19.98us 7.812499999999999e-08A 23.310000000000002us 7.812499999999999e-08A 26.64us 7.812499999999999e-08A 29.97us 7.812499999999999e-08A 33.3us 7.812499999999999e-08A 36.63us 0.00390625A 39.96us 0.00390625A 43.29us 0.00390625A 46.620000000000005us 0.00390625A 49.95us 0.00390625A 53.28us 0.00390625A 56.61us 0.00390625A 59.94us 0.00390625A 63.27us 0.00390625A 66.6us 0.00390625A 69.93us 7.812499999999999e-08A 73.26us 7.812499999999999e-08A 76.59us 7.812499999999999e-08A 79.92us 7.812499999999999e-08A 83.25us 7.812499999999999e-08A 86.58us 7.812499999999999e-08A 89.91us 7.812499999999999e-08A 93.24000000000001us 7.812499999999999e-08A 96.57000000000001us 7.812499999999999e-08A 99.9us 7.812499999999999e-08A)
R_4_8_5_1 Node4_8_5 Node4_8_6 13474.999999999996
R_4_8_5_2 Node4_8_5 Node4_9_5 8662.500000000004
R_4_8_5_3 Node4_8_5 Node5_8_5 0.49280000000000007
C_4_8_5 Node4_8_5 GND 2.255859375e-09
I_4_8_6 GND Node4_8_6 PWL(0s 0A 3.33us 3.125000000000001e-08A 6.66us 3.125000000000001e-08A 9.99us 3.125000000000001e-08A 13.32us 3.125000000000001e-08A 16.65us 3.125000000000001e-08A 19.98us 3.125000000000001e-08A 23.310000000000002us 3.125000000000001e-08A 26.64us 3.125000000000001e-08A 29.97us 3.125000000000001e-08A 33.3us 3.125000000000001e-08A 36.63us 0.0015625000000000007A 39.96us 0.0015625000000000007A 43.29us 0.0015625000000000007A 46.620000000000005us 0.0015625000000000007A 49.95us 0.0015625000000000007A 53.28us 0.0015625000000000007A 56.61us 0.0015625000000000007A 59.94us 0.0015625000000000007A 63.27us 0.0015625000000000007A 66.6us 0.0015625000000000007A 69.93us 3.125000000000001e-08A 73.26us 3.125000000000001e-08A 76.59us 3.125000000000001e-08A 79.92us 3.125000000000001e-08A 83.25us 3.125000000000001e-08A 86.58us 3.125000000000001e-08A 89.91us 3.125000000000001e-08A 93.24000000000001us 3.125000000000001e-08A 96.57000000000001us 3.125000000000001e-08A 99.9us 3.125000000000001e-08A)
R_4_8_6_1 Node4_8_6 Node4_8_7 9625.000000499997
R_4_8_6_2 Node4_8_6 Node4_9_6 18375.000000000004
R_4_8_6_3 Node4_8_6 Node5_8_6 1.2319999999999995
C_4_8_6 Node4_8_6 GND 9.023437500000004e-10
R_4_8_7_1 Node4_8_7 Node4_8_8 1e-06
R_4_8_7_2 Node4_8_7 Node4_9_7 19250.000000500033
R_4_8_7_3 Node4_8_7 Node5_8_7 1e-06
C_4_8_7 Node4_8_7 GND 0.0
R_4_8_8_1 Node4_8_8 Node4_8_9 1e-06
R_4_8_8_2 Node4_8_8 Node4_9_8 19250.000000500033
R_4_8_8_3 Node4_8_8 Node5_8_8 1e-06
C_4_8_8 Node4_8_8 GND 0.0
R_4_8_9_1 Node4_8_9 Node4_8_10 1e-06
R_4_8_9_2 Node4_8_9 Node4_9_9 19250.000000500033
R_4_8_9_3 Node4_8_9 Node5_8_9 1e-06
C_4_8_9 Node4_8_9 GND 0.0
R_4_8_10_1 Node4_8_10 Node4_8_11 1e-06
R_4_8_10_2 Node4_8_10 Node4_9_10 19250.000000500033
R_4_8_10_3 Node4_8_10 Node5_8_10 1e-06
C_4_8_10 Node4_8_10 GND 0.0
R_4_8_11_1 Node4_8_11 Node4_8_12 1e-06
R_4_8_11_2 Node4_8_11 Node4_9_11 19250.000000500033
R_4_8_11_3 Node4_8_11 Node5_8_11 1e-06
C_4_8_11 Node4_8_11 GND 0.0
R_4_8_12_1 Node4_8_12 Node4_8_13 1e-06
R_4_8_12_2 Node4_8_12 Node4_9_12 19250.000000500033
R_4_8_12_3 Node4_8_12 Node5_8_12 1e-06
C_4_8_12 Node4_8_12 GND 0.0
R_4_8_13_1 Node4_8_13 Node4_8_14 1e-06
R_4_8_13_2 Node4_8_13 Node4_9_13 19250.000000500033
R_4_8_13_3 Node4_8_13 Node5_8_13 1e-06
C_4_8_13 Node4_8_13 GND 0.0
R_4_8_14_1 Node4_8_14 Node4_8_15 1e-06
R_4_8_14_2 Node4_8_14 Node4_9_14 19250.000000500033
R_4_8_14_3 Node4_8_14 Node5_8_14 1e-06
C_4_8_14 Node4_8_14 GND 0.0
R_4_8_15_2 Node4_8_15 Node4_9_15 19250.000000500015
R_4_8_15_3 Node4_8_15 Node5_8_15 1e-06
C_4_8_15 Node4_8_15 GND 0.0
I_4_9_0 GND Node4_9_0 PWL(0s 0A 3.33us 8.593749999999994e-08A 6.66us 8.593749999999994e-08A 9.99us 8.593749999999994e-08A 13.32us 8.593749999999994e-08A 16.65us 8.593749999999994e-08A 19.98us 8.593749999999994e-08A 23.310000000000002us 8.593749999999994e-08A 26.64us 8.593749999999994e-08A 29.97us 8.593749999999994e-08A 33.3us 8.593749999999994e-08A 36.63us 0.038281249999999996A 39.96us 0.038281249999999996A 43.29us 0.038281249999999996A 46.620000000000005us 0.038281249999999996A 49.95us 0.038281249999999996A 53.28us 0.038281249999999996A 56.61us 0.038281249999999996A 59.94us 0.038281249999999996A 63.27us 0.038281249999999996A 66.6us 0.038281249999999996A 69.93us 8.593749999999994e-08A 73.26us 8.593749999999994e-08A 76.59us 8.593749999999994e-08A 79.92us 8.593749999999994e-08A 83.25us 8.593749999999994e-08A 86.58us 8.593749999999994e-08A 89.91us 8.593749999999994e-08A 93.24000000000001us 8.593749999999994e-08A 96.57000000000001us 8.593749999999994e-08A 99.9us 8.593749999999994e-08A)
R_4_9_0_1 Node4_9_0 Node4_9_1 7000.000000000004
R_4_9_0_2 Node4_9_0 Node4_10_0 11200.000000000002
R_4_9_0_3 Node4_9_0 Node5_9_0 0.44800000000000023
C_4_9_0 Node4_9_0 GND 2.481445312499999e-09
I_4_9_1 GND Node4_9_1 PWL(0s 0A 3.33us 8.593749999999994e-08A 6.66us 8.593749999999994e-08A 9.99us 8.593749999999994e-08A 13.32us 8.593749999999994e-08A 16.65us 8.593749999999994e-08A 19.98us 8.593749999999994e-08A 23.310000000000002us 8.593749999999994e-08A 26.64us 8.593749999999994e-08A 29.97us 8.593749999999994e-08A 33.3us 8.593749999999994e-08A 36.63us 0.038281249999999996A 39.96us 0.038281249999999996A 43.29us 0.038281249999999996A 46.620000000000005us 0.038281249999999996A 49.95us 0.038281249999999996A 53.28us 0.038281249999999996A 56.61us 0.038281249999999996A 59.94us 0.038281249999999996A 63.27us 0.038281249999999996A 66.6us 0.038281249999999996A 69.93us 8.593749999999994e-08A 73.26us 8.593749999999994e-08A 76.59us 8.593749999999994e-08A 79.92us 8.593749999999994e-08A 83.25us 8.593749999999994e-08A 86.58us 8.593749999999994e-08A 89.91us 8.593749999999994e-08A 93.24000000000001us 8.593749999999994e-08A 96.57000000000001us 8.593749999999994e-08A 99.9us 8.593749999999994e-08A)
R_4_9_1_1 Node4_9_1 Node4_9_2 7000.000000000004
R_4_9_1_2 Node4_9_1 Node4_10_1 11200.000000000002
R_4_9_1_3 Node4_9_1 Node5_9_1 0.44800000000000023
C_4_9_1 Node4_9_1 GND 2.481445312499999e-09
I_4_9_2 GND Node4_9_2 PWL(0s 0A 3.33us 8.593749999999994e-08A 6.66us 8.593749999999994e-08A 9.99us 8.593749999999994e-08A 13.32us 8.593749999999994e-08A 16.65us 8.593749999999994e-08A 19.98us 8.593749999999994e-08A 23.310000000000002us 8.593749999999994e-08A 26.64us 8.593749999999994e-08A 29.97us 8.593749999999994e-08A 33.3us 8.593749999999994e-08A 36.63us 0.038281249999999996A 39.96us 0.038281249999999996A 43.29us 0.038281249999999996A 46.620000000000005us 0.038281249999999996A 49.95us 0.038281249999999996A 53.28us 0.038281249999999996A 56.61us 0.038281249999999996A 59.94us 0.038281249999999996A 63.27us 0.038281249999999996A 66.6us 0.038281249999999996A 69.93us 8.593749999999994e-08A 73.26us 8.593749999999994e-08A 76.59us 8.593749999999994e-08A 79.92us 8.593749999999994e-08A 83.25us 8.593749999999994e-08A 86.58us 8.593749999999994e-08A 89.91us 8.593749999999994e-08A 93.24000000000001us 8.593749999999994e-08A 96.57000000000001us 8.593749999999994e-08A 99.9us 8.593749999999994e-08A)
R_4_9_2_1 Node4_9_2 Node4_9_3 7976.744186046516
R_4_9_2_2 Node4_9_2 Node4_10_2 11200.000000000002
R_4_9_2_3 Node4_9_2 Node5_9_2 0.44800000000000023
C_4_9_2 Node4_9_2 GND 2.481445312499999e-09
I_4_9_3 GND Node4_9_3 PWL(0s 0A 3.33us 6.718749999999997e-08A 6.66us 6.718749999999997e-08A 9.99us 6.718749999999997e-08A 13.32us 6.718749999999997e-08A 16.65us 6.718749999999997e-08A 19.98us 6.718749999999997e-08A 23.310000000000002us 6.718749999999997e-08A 26.64us 6.718749999999997e-08A 29.97us 6.718749999999997e-08A 33.3us 6.718749999999997e-08A 36.63us 0.010156249999999999A 39.96us 0.010156249999999999A 43.29us 0.010156249999999999A 46.620000000000005us 0.010156249999999999A 49.95us 0.010156249999999999A 53.28us 0.010156249999999999A 56.61us 0.010156249999999999A 59.94us 0.010156249999999999A 63.27us 0.010156249999999999A 66.6us 0.010156249999999999A 69.93us 6.718749999999997e-08A 73.26us 6.718749999999997e-08A 76.59us 6.718749999999997e-08A 79.92us 6.718749999999997e-08A 83.25us 6.718749999999997e-08A 86.58us 6.718749999999997e-08A 89.91us 6.718749999999997e-08A 93.24000000000001us 6.718749999999997e-08A 96.57000000000001us 6.718749999999997e-08A 99.9us 6.718749999999997e-08A)
R_4_9_3_1 Node4_9_3 Node4_9_4 9289.244186046517
R_4_9_3_2 Node4_9_3 Node4_10_3 12176.744186046515
R_4_9_3_3 Node4_9_3 Node5_9_3 0.5730232558139539
C_4_9_3 Node4_9_3 GND 1.940039062499999e-09
I_4_9_4 GND Node4_9_4 PWL(0s 0A 3.33us 6.249999999999996e-08A 6.66us 6.249999999999996e-08A 9.99us 6.249999999999996e-08A 13.32us 6.249999999999996e-08A 16.65us 6.249999999999996e-08A 19.98us 6.249999999999996e-08A 23.310000000000002us 6.249999999999996e-08A 26.64us 6.249999999999996e-08A 29.97us 6.249999999999996e-08A 33.3us 6.249999999999996e-08A 36.63us 0.003124999999999998A 39.96us 0.003124999999999998A 43.29us 0.003124999999999998A 46.620000000000005us 0.003124999999999998A 49.95us 0.003124999999999998A 53.28us 0.003124999999999998A 56.61us 0.003124999999999998A 59.94us 0.003124999999999998A 63.27us 0.003124999999999998A 66.6us 0.003124999999999998A 69.93us 6.249999999999996e-08A 73.26us 6.249999999999996e-08A 76.59us 6.249999999999996e-08A 79.92us 6.249999999999996e-08A 83.25us 6.249999999999996e-08A 86.58us 6.249999999999996e-08A 89.91us 6.249999999999996e-08A 93.24000000000001us 6.249999999999996e-08A 96.57000000000001us 6.249999999999996e-08A 99.9us 6.249999999999996e-08A)
R_4_9_4_1 Node4_9_4 Node4_9_5 9625.000000000005
R_4_9_4_2 Node4_9_4 Node4_10_4 12512.500000000004
R_4_9_4_3 Node4_9_4 Node5_9_4 0.6160000000000004
C_4_9_4 Node4_9_4 GND 1.804687499999999e-09
I_4_9_5 GND Node4_9_5 PWL(0s 0A 3.33us 6.249999999999996e-08A 6.66us 6.249999999999996e-08A 9.99us 6.249999999999996e-08A 13.32us 6.249999999999996e-08A 16.65us 6.249999999999996e-08A 19.98us 6.249999999999996e-08A 23.310000000000002us 6.249999999999996e-08A 26.64us 6.249999999999996e-08A 29.97us 6.249999999999996e-08A 33.3us 6.249999999999996e-08A 36.63us 0.003124999999999998A 39.96us 0.003124999999999998A 43.29us 0.003124999999999998A 46.620000000000005us 0.003124999999999998A 49.95us 0.003124999999999998A 53.28us 0.003124999999999998A 56.61us 0.003124999999999998A 59.94us 0.003124999999999998A 63.27us 0.003124999999999998A 66.6us 0.003124999999999998A 69.93us 6.249999999999996e-08A 73.26us 6.249999999999996e-08A 76.59us 6.249999999999996e-08A 79.92us 6.249999999999996e-08A 83.25us 6.249999999999996e-08A 86.58us 6.249999999999996e-08A 89.91us 6.249999999999996e-08A 93.24000000000001us 6.249999999999996e-08A 96.57000000000001us 6.249999999999996e-08A 99.9us 6.249999999999996e-08A)
R_4_9_5_1 Node4_9_5 Node4_9_6 13562.500000000011
R_4_9_5_2 Node4_9_5 Node4_10_5 12512.500000000004
R_4_9_5_3 Node4_9_5 Node5_9_5 0.6160000000000004
C_4_9_5 Node4_9_5 GND 1.804687499999999e-09
I_4_9_6 GND Node4_9_6 PWL(0s 0A 3.33us 3.4374999999999975e-08A 6.66us 3.4374999999999975e-08A 9.99us 3.4374999999999975e-08A 13.32us 3.4374999999999975e-08A 16.65us 3.4374999999999975e-08A 19.98us 3.4374999999999975e-08A 23.310000000000002us 3.4374999999999975e-08A 26.64us 3.4374999999999975e-08A 29.97us 3.4374999999999975e-08A 33.3us 3.4374999999999975e-08A 36.63us 0.001718749999999999A 39.96us 0.001718749999999999A 43.29us 0.001718749999999999A 46.620000000000005us 0.001718749999999999A 49.95us 0.001718749999999999A 53.28us 0.001718749999999999A 56.61us 0.001718749999999999A 59.94us 0.001718749999999999A 63.27us 0.001718749999999999A 66.6us 0.001718749999999999A 69.93us 3.4374999999999975e-08A 73.26us 3.4374999999999975e-08A 76.59us 3.4374999999999975e-08A 79.92us 3.4374999999999975e-08A 83.25us 3.4374999999999975e-08A 86.58us 3.4374999999999975e-08A 89.91us 3.4374999999999975e-08A 93.24000000000001us 3.4374999999999975e-08A 96.57000000000001us 3.4374999999999975e-08A 99.9us 3.4374999999999975e-08A)
R_4_9_6_1 Node4_9_6 Node4_9_7 28000.00000000004
R_4_9_6_2 Node4_9_6 Node4_10_6 16450.000000000007
R_4_9_6_3 Node4_9_6 Node5_9_6 1.1200000000000008
C_4_9_6 Node4_9_6 GND 9.925781249999993e-10
I_4_9_7 GND Node4_9_7 PWL(0s 0A 3.33us 1.562499999999997e-08A 6.66us 1.562499999999997e-08A 9.99us 1.562499999999997e-08A 13.32us 1.562499999999997e-08A 16.65us 1.562499999999997e-08A 19.98us 1.562499999999997e-08A 23.310000000000002us 1.562499999999997e-08A 26.64us 1.562499999999997e-08A 29.97us 1.562499999999997e-08A 33.3us 1.562499999999997e-08A 36.63us 0.0007812499999999986A 39.96us 0.0007812499999999986A 43.29us 0.0007812499999999986A 46.620000000000005us 0.0007812499999999986A 49.95us 0.0007812499999999986A 53.28us 0.0007812499999999986A 56.61us 0.0007812499999999986A 59.94us 0.0007812499999999986A 63.27us 0.0007812499999999986A 66.6us 0.0007812499999999986A 69.93us 1.562499999999997e-08A 73.26us 1.562499999999997e-08A 76.59us 1.562499999999997e-08A 79.92us 1.562499999999997e-08A 83.25us 1.562499999999997e-08A 86.58us 1.562499999999997e-08A 89.91us 1.562499999999997e-08A 93.24000000000001us 1.562499999999997e-08A 96.57000000000001us 1.562499999999997e-08A 99.9us 1.562499999999997e-08A)
R_4_9_7_1 Node4_9_7 Node4_9_8 38500.000000000065
R_4_9_7_2 Node4_9_7 Node4_10_7 26950.000000000033
R_4_9_7_3 Node4_9_7 Node5_9_7 2.4640000000000044
C_4_9_7 Node4_9_7 GND 4.511718749999992e-10
I_4_9_8 GND Node4_9_8 PWL(0s 0A 3.33us 1.562499999999997e-08A 6.66us 1.562499999999997e-08A 9.99us 1.562499999999997e-08A 13.32us 1.562499999999997e-08A 16.65us 1.562499999999997e-08A 19.98us 1.562499999999997e-08A 23.310000000000002us 1.562499999999997e-08A 26.64us 1.562499999999997e-08A 29.97us 1.562499999999997e-08A 33.3us 1.562499999999997e-08A 36.63us 0.0007812499999999986A 39.96us 0.0007812499999999986A 43.29us 0.0007812499999999986A 46.620000000000005us 0.0007812499999999986A 49.95us 0.0007812499999999986A 53.28us 0.0007812499999999986A 56.61us 0.0007812499999999986A 59.94us 0.0007812499999999986A 63.27us 0.0007812499999999986A 66.6us 0.0007812499999999986A 69.93us 1.562499999999997e-08A 73.26us 1.562499999999997e-08A 76.59us 1.562499999999997e-08A 79.92us 1.562499999999997e-08A 83.25us 1.562499999999997e-08A 86.58us 1.562499999999997e-08A 89.91us 1.562499999999997e-08A 93.24000000000001us 1.562499999999997e-08A 96.57000000000001us 1.562499999999997e-08A 99.9us 1.562499999999997e-08A)
R_4_9_8_1 Node4_9_8 Node4_9_9 38500.000000000065
R_4_9_8_2 Node4_9_8 Node4_10_8 26950.000000000033
R_4_9_8_3 Node4_9_8 Node5_9_8 2.4640000000000044
C_4_9_8 Node4_9_8 GND 4.511718749999992e-10
I_4_9_9 GND Node4_9_9 PWL(0s 0A 3.33us 1.562499999999997e-08A 6.66us 1.562499999999997e-08A 9.99us 1.562499999999997e-08A 13.32us 1.562499999999997e-08A 16.65us 1.562499999999997e-08A 19.98us 1.562499999999997e-08A 23.310000000000002us 1.562499999999997e-08A 26.64us 1.562499999999997e-08A 29.97us 1.562499999999997e-08A 33.3us 1.562499999999997e-08A 36.63us 0.0007812499999999986A 39.96us 0.0007812499999999986A 43.29us 0.0007812499999999986A 46.620000000000005us 0.0007812499999999986A 49.95us 0.0007812499999999986A 53.28us 0.0007812499999999986A 56.61us 0.0007812499999999986A 59.94us 0.0007812499999999986A 63.27us 0.0007812499999999986A 66.6us 0.0007812499999999986A 69.93us 1.562499999999997e-08A 73.26us 1.562499999999997e-08A 76.59us 1.562499999999997e-08A 79.92us 1.562499999999997e-08A 83.25us 1.562499999999997e-08A 86.58us 1.562499999999997e-08A 89.91us 1.562499999999997e-08A 93.24000000000001us 1.562499999999997e-08A 96.57000000000001us 1.562499999999997e-08A 99.9us 1.562499999999997e-08A)
R_4_9_9_1 Node4_9_9 Node4_9_10 38500.000000000065
R_4_9_9_2 Node4_9_9 Node4_10_9 26950.000000000033
R_4_9_9_3 Node4_9_9 Node5_9_9 2.4640000000000044
C_4_9_9 Node4_9_9 GND 4.511718749999992e-10
I_4_9_10 GND Node4_9_10 PWL(0s 0A 3.33us 1.562499999999997e-08A 6.66us 1.562499999999997e-08A 9.99us 1.562499999999997e-08A 13.32us 1.562499999999997e-08A 16.65us 1.562499999999997e-08A 19.98us 1.562499999999997e-08A 23.310000000000002us 1.562499999999997e-08A 26.64us 1.562499999999997e-08A 29.97us 1.562499999999997e-08A 33.3us 1.562499999999997e-08A 36.63us 0.0007812499999999986A 39.96us 0.0007812499999999986A 43.29us 0.0007812499999999986A 46.620000000000005us 0.0007812499999999986A 49.95us 0.0007812499999999986A 53.28us 0.0007812499999999986A 56.61us 0.0007812499999999986A 59.94us 0.0007812499999999986A 63.27us 0.0007812499999999986A 66.6us 0.0007812499999999986A 69.93us 1.562499999999997e-08A 73.26us 1.562499999999997e-08A 76.59us 1.562499999999997e-08A 79.92us 1.562499999999997e-08A 83.25us 1.562499999999997e-08A 86.58us 1.562499999999997e-08A 89.91us 1.562499999999997e-08A 93.24000000000001us 1.562499999999997e-08A 96.57000000000001us 1.562499999999997e-08A 99.9us 1.562499999999997e-08A)
R_4_9_10_1 Node4_9_10 Node4_9_11 38500.000000000065
R_4_9_10_2 Node4_9_10 Node4_10_10 26950.000000000033
R_4_9_10_3 Node4_9_10 Node5_9_10 2.4640000000000044
C_4_9_10 Node4_9_10 GND 4.511718749999992e-10
I_4_9_11 GND Node4_9_11 PWL(0s 0A 3.33us 1.562499999999997e-08A 6.66us 1.562499999999997e-08A 9.99us 1.562499999999997e-08A 13.32us 1.562499999999997e-08A 16.65us 1.562499999999997e-08A 19.98us 1.562499999999997e-08A 23.310000000000002us 1.562499999999997e-08A 26.64us 1.562499999999997e-08A 29.97us 1.562499999999997e-08A 33.3us 1.562499999999997e-08A 36.63us 0.0007812499999999986A 39.96us 0.0007812499999999986A 43.29us 0.0007812499999999986A 46.620000000000005us 0.0007812499999999986A 49.95us 0.0007812499999999986A 53.28us 0.0007812499999999986A 56.61us 0.0007812499999999986A 59.94us 0.0007812499999999986A 63.27us 0.0007812499999999986A 66.6us 0.0007812499999999986A 69.93us 1.562499999999997e-08A 73.26us 1.562499999999997e-08A 76.59us 1.562499999999997e-08A 79.92us 1.562499999999997e-08A 83.25us 1.562499999999997e-08A 86.58us 1.562499999999997e-08A 89.91us 1.562499999999997e-08A 93.24000000000001us 1.562499999999997e-08A 96.57000000000001us 1.562499999999997e-08A 99.9us 1.562499999999997e-08A)
R_4_9_11_1 Node4_9_11 Node4_9_12 38500.000000000065
R_4_9_11_2 Node4_9_11 Node4_10_11 26950.000000000033
R_4_9_11_3 Node4_9_11 Node5_9_11 2.4640000000000044
C_4_9_11 Node4_9_11 GND 4.511718749999992e-10
I_4_9_12 GND Node4_9_12 PWL(0s 0A 3.33us 1.562499999999997e-08A 6.66us 1.562499999999997e-08A 9.99us 1.562499999999997e-08A 13.32us 1.562499999999997e-08A 16.65us 1.562499999999997e-08A 19.98us 1.562499999999997e-08A 23.310000000000002us 1.562499999999997e-08A 26.64us 1.562499999999997e-08A 29.97us 1.562499999999997e-08A 33.3us 1.562499999999997e-08A 36.63us 0.0007812499999999986A 39.96us 0.0007812499999999986A 43.29us 0.0007812499999999986A 46.620000000000005us 0.0007812499999999986A 49.95us 0.0007812499999999986A 53.28us 0.0007812499999999986A 56.61us 0.0007812499999999986A 59.94us 0.0007812499999999986A 63.27us 0.0007812499999999986A 66.6us 0.0007812499999999986A 69.93us 1.562499999999997e-08A 73.26us 1.562499999999997e-08A 76.59us 1.562499999999997e-08A 79.92us 1.562499999999997e-08A 83.25us 1.562499999999997e-08A 86.58us 1.562499999999997e-08A 89.91us 1.562499999999997e-08A 93.24000000000001us 1.562499999999997e-08A 96.57000000000001us 1.562499999999997e-08A 99.9us 1.562499999999997e-08A)
R_4_9_12_1 Node4_9_12 Node4_9_13 38500.000000000065
R_4_9_12_2 Node4_9_12 Node4_10_12 26950.000000000033
R_4_9_12_3 Node4_9_12 Node5_9_12 2.4640000000000044
C_4_9_12 Node4_9_12 GND 4.511718749999992e-10
I_4_9_13 GND Node4_9_13 PWL(0s 0A 3.33us 1.562499999999997e-08A 6.66us 1.562499999999997e-08A 9.99us 1.562499999999997e-08A 13.32us 1.562499999999997e-08A 16.65us 1.562499999999997e-08A 19.98us 1.562499999999997e-08A 23.310000000000002us 1.562499999999997e-08A 26.64us 1.562499999999997e-08A 29.97us 1.562499999999997e-08A 33.3us 1.562499999999997e-08A 36.63us 0.0007812499999999986A 39.96us 0.0007812499999999986A 43.29us 0.0007812499999999986A 46.620000000000005us 0.0007812499999999986A 49.95us 0.0007812499999999986A 53.28us 0.0007812499999999986A 56.61us 0.0007812499999999986A 59.94us 0.0007812499999999986A 63.27us 0.0007812499999999986A 66.6us 0.0007812499999999986A 69.93us 1.562499999999997e-08A 73.26us 1.562499999999997e-08A 76.59us 1.562499999999997e-08A 79.92us 1.562499999999997e-08A 83.25us 1.562499999999997e-08A 86.58us 1.562499999999997e-08A 89.91us 1.562499999999997e-08A 93.24000000000001us 1.562499999999997e-08A 96.57000000000001us 1.562499999999997e-08A 99.9us 1.562499999999997e-08A)
R_4_9_13_1 Node4_9_13 Node4_9_14 38500.000000000065
R_4_9_13_2 Node4_9_13 Node4_10_13 26950.000000000033
R_4_9_13_3 Node4_9_13 Node5_9_13 2.4640000000000044
C_4_9_13 Node4_9_13 GND 4.511718749999992e-10
I_4_9_14 GND Node4_9_14 PWL(0s 0A 3.33us 1.562499999999997e-08A 6.66us 1.562499999999997e-08A 9.99us 1.562499999999997e-08A 13.32us 1.562499999999997e-08A 16.65us 1.562499999999997e-08A 19.98us 1.562499999999997e-08A 23.310000000000002us 1.562499999999997e-08A 26.64us 1.562499999999997e-08A 29.97us 1.562499999999997e-08A 33.3us 1.562499999999997e-08A 36.63us 0.0007812499999999986A 39.96us 0.0007812499999999986A 43.29us 0.0007812499999999986A 46.620000000000005us 0.0007812499999999986A 49.95us 0.0007812499999999986A 53.28us 0.0007812499999999986A 56.61us 0.0007812499999999986A 59.94us 0.0007812499999999986A 63.27us 0.0007812499999999986A 66.6us 0.0007812499999999986A 69.93us 1.562499999999997e-08A 73.26us 1.562499999999997e-08A 76.59us 1.562499999999997e-08A 79.92us 1.562499999999997e-08A 83.25us 1.562499999999997e-08A 86.58us 1.562499999999997e-08A 89.91us 1.562499999999997e-08A 93.24000000000001us 1.562499999999997e-08A 96.57000000000001us 1.562499999999997e-08A 99.9us 1.562499999999997e-08A)
R_4_9_14_1 Node4_9_14 Node4_9_15 38500.000000000044
R_4_9_14_2 Node4_9_14 Node4_10_14 26950.000000000033
R_4_9_14_3 Node4_9_14 Node5_9_14 2.4640000000000044
C_4_9_14 Node4_9_14 GND 4.511718749999992e-10
I_4_9_15 GND Node4_9_15 PWL(0s 0A 3.33us 1.5624999999999983e-08A 6.66us 1.5624999999999983e-08A 9.99us 1.5624999999999983e-08A 13.32us 1.5624999999999983e-08A 16.65us 1.5624999999999983e-08A 19.98us 1.5624999999999983e-08A 23.310000000000002us 1.5624999999999983e-08A 26.64us 1.5624999999999983e-08A 29.97us 1.5624999999999983e-08A 33.3us 1.5624999999999983e-08A 36.63us 0.0007812499999999994A 39.96us 0.0007812499999999994A 43.29us 0.0007812499999999994A 46.620000000000005us 0.0007812499999999994A 49.95us 0.0007812499999999994A 53.28us 0.0007812499999999994A 56.61us 0.0007812499999999994A 59.94us 0.0007812499999999994A 63.27us 0.0007812499999999994A 66.6us 0.0007812499999999994A 69.93us 1.5624999999999983e-08A 73.26us 1.5624999999999983e-08A 76.59us 1.5624999999999983e-08A 79.92us 1.5624999999999983e-08A 83.25us 1.5624999999999983e-08A 86.58us 1.5624999999999983e-08A 89.91us 1.5624999999999983e-08A 93.24000000000001us 1.5624999999999983e-08A 96.57000000000001us 1.5624999999999983e-08A 99.9us 1.5624999999999983e-08A)
R_4_9_15_2 Node4_9_15 Node4_10_15 26950.000000000007
R_4_9_15_3 Node4_9_15 Node5_9_15 2.464000000000002
C_4_9_15 Node4_9_15 GND 4.511718749999996e-10
I_4_10_0 GND Node4_10_0 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 0.001953125A 39.96us 0.001953125A 43.29us 0.001953125A 46.620000000000005us 0.001953125A 49.95us 0.001953125A 53.28us 0.001953125A 56.61us 0.001953125A 59.94us 0.001953125A 63.27us 0.001953125A 66.6us 0.001953125A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_4_10_0_1 Node4_10_0 Node4_10_1 15400.0
R_4_10_0_2 Node4_10_0 Node4_11_0 15400.0
R_4_10_0_3 Node4_10_0 Node5_10_0 0.9856000000000001
C_4_10_0 Node4_10_0 GND 1.1279296875e-09
I_4_10_1 GND Node4_10_1 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 0.001953125A 39.96us 0.001953125A 43.29us 0.001953125A 46.620000000000005us 0.001953125A 49.95us 0.001953125A 53.28us 0.001953125A 56.61us 0.001953125A 59.94us 0.001953125A 63.27us 0.001953125A 66.6us 0.001953125A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_4_10_1_1 Node4_10_1 Node4_10_2 15400.0
R_4_10_1_2 Node4_10_1 Node4_11_1 15400.0
R_4_10_1_3 Node4_10_1 Node5_10_1 0.9856000000000001
C_4_10_1 Node4_10_1 GND 1.1279296875e-09
I_4_10_2 GND Node4_10_2 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 0.001953125A 39.96us 0.001953125A 43.29us 0.001953125A 46.620000000000005us 0.001953125A 49.95us 0.001953125A 53.28us 0.001953125A 56.61us 0.001953125A 59.94us 0.001953125A 63.27us 0.001953125A 66.6us 0.001953125A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_4_10_2_1 Node4_10_2 Node4_10_3 15400.0
R_4_10_2_2 Node4_10_2 Node4_11_2 15400.0
R_4_10_2_3 Node4_10_2 Node5_10_2 0.9856000000000001
C_4_10_2 Node4_10_2 GND 1.1279296875e-09
I_4_10_3 GND Node4_10_3 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 0.001953125A 39.96us 0.001953125A 43.29us 0.001953125A 46.620000000000005us 0.001953125A 49.95us 0.001953125A 53.28us 0.001953125A 56.61us 0.001953125A 59.94us 0.001953125A 63.27us 0.001953125A 66.6us 0.001953125A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_4_10_3_1 Node4_10_3 Node4_10_4 15400.0
R_4_10_3_2 Node4_10_3 Node4_11_3 15400.0
R_4_10_3_3 Node4_10_3 Node5_10_3 0.9856000000000001
C_4_10_3 Node4_10_3 GND 1.1279296875e-09
I_4_10_4 GND Node4_10_4 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 0.001953125A 39.96us 0.001953125A 43.29us 0.001953125A 46.620000000000005us 0.001953125A 49.95us 0.001953125A 53.28us 0.001953125A 56.61us 0.001953125A 59.94us 0.001953125A 63.27us 0.001953125A 66.6us 0.001953125A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_4_10_4_1 Node4_10_4 Node4_10_5 15400.0
R_4_10_4_2 Node4_10_4 Node4_11_4 15400.0
R_4_10_4_3 Node4_10_4 Node5_10_4 0.9856000000000001
C_4_10_4 Node4_10_4 GND 1.1279296875e-09
I_4_10_5 GND Node4_10_5 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 0.001953125A 39.96us 0.001953125A 43.29us 0.001953125A 46.620000000000005us 0.001953125A 49.95us 0.001953125A 53.28us 0.001953125A 56.61us 0.001953125A 59.94us 0.001953125A 63.27us 0.001953125A 66.6us 0.001953125A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_4_10_5_1 Node4_10_5 Node4_10_6 15400.0
R_4_10_5_2 Node4_10_5 Node4_11_5 15400.0
R_4_10_5_3 Node4_10_5 Node5_10_5 0.9856000000000001
C_4_10_5 Node4_10_5 GND 1.1279296875e-09
I_4_10_6 GND Node4_10_6 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 0.001953125A 39.96us 0.001953125A 43.29us 0.001953125A 46.620000000000005us 0.001953125A 49.95us 0.001953125A 53.28us 0.001953125A 56.61us 0.001953125A 59.94us 0.001953125A 63.27us 0.001953125A 66.6us 0.001953125A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_4_10_6_1 Node4_10_6 Node4_10_7 15400.0
R_4_10_6_2 Node4_10_6 Node4_11_6 15400.0
R_4_10_6_3 Node4_10_6 Node5_10_6 0.9856000000000001
C_4_10_6 Node4_10_6 GND 1.1279296875e-09
I_4_10_7 GND Node4_10_7 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 0.001953125A 39.96us 0.001953125A 43.29us 0.001953125A 46.620000000000005us 0.001953125A 49.95us 0.001953125A 53.28us 0.001953125A 56.61us 0.001953125A 59.94us 0.001953125A 63.27us 0.001953125A 66.6us 0.001953125A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_4_10_7_1 Node4_10_7 Node4_10_8 15400.0
R_4_10_7_2 Node4_10_7 Node4_11_7 15400.0
R_4_10_7_3 Node4_10_7 Node5_10_7 0.9856000000000001
C_4_10_7 Node4_10_7 GND 1.1279296875e-09
I_4_10_8 GND Node4_10_8 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 0.001953125A 39.96us 0.001953125A 43.29us 0.001953125A 46.620000000000005us 0.001953125A 49.95us 0.001953125A 53.28us 0.001953125A 56.61us 0.001953125A 59.94us 0.001953125A 63.27us 0.001953125A 66.6us 0.001953125A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_4_10_8_1 Node4_10_8 Node4_10_9 15400.0
R_4_10_8_2 Node4_10_8 Node4_11_8 15400.0
R_4_10_8_3 Node4_10_8 Node5_10_8 0.9856000000000001
C_4_10_8 Node4_10_8 GND 1.1279296875e-09
I_4_10_9 GND Node4_10_9 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 0.001953125A 39.96us 0.001953125A 43.29us 0.001953125A 46.620000000000005us 0.001953125A 49.95us 0.001953125A 53.28us 0.001953125A 56.61us 0.001953125A 59.94us 0.001953125A 63.27us 0.001953125A 66.6us 0.001953125A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_4_10_9_1 Node4_10_9 Node4_10_10 15400.0
R_4_10_9_2 Node4_10_9 Node4_11_9 15400.0
R_4_10_9_3 Node4_10_9 Node5_10_9 0.9856000000000001
C_4_10_9 Node4_10_9 GND 1.1279296875e-09
I_4_10_10 GND Node4_10_10 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 0.001953125A 39.96us 0.001953125A 43.29us 0.001953125A 46.620000000000005us 0.001953125A 49.95us 0.001953125A 53.28us 0.001953125A 56.61us 0.001953125A 59.94us 0.001953125A 63.27us 0.001953125A 66.6us 0.001953125A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_4_10_10_1 Node4_10_10 Node4_10_11 15400.0
R_4_10_10_2 Node4_10_10 Node4_11_10 15400.0
R_4_10_10_3 Node4_10_10 Node5_10_10 0.9856000000000001
C_4_10_10 Node4_10_10 GND 1.1279296875e-09
I_4_10_11 GND Node4_10_11 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 0.001953125A 39.96us 0.001953125A 43.29us 0.001953125A 46.620000000000005us 0.001953125A 49.95us 0.001953125A 53.28us 0.001953125A 56.61us 0.001953125A 59.94us 0.001953125A 63.27us 0.001953125A 66.6us 0.001953125A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_4_10_11_1 Node4_10_11 Node4_10_12 15400.0
R_4_10_11_2 Node4_10_11 Node4_11_11 15400.0
R_4_10_11_3 Node4_10_11 Node5_10_11 0.9856000000000001
C_4_10_11 Node4_10_11 GND 1.1279296875e-09
I_4_10_12 GND Node4_10_12 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 0.001953125A 39.96us 0.001953125A 43.29us 0.001953125A 46.620000000000005us 0.001953125A 49.95us 0.001953125A 53.28us 0.001953125A 56.61us 0.001953125A 59.94us 0.001953125A 63.27us 0.001953125A 66.6us 0.001953125A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_4_10_12_1 Node4_10_12 Node4_10_13 15400.0
R_4_10_12_2 Node4_10_12 Node4_11_12 15400.0
R_4_10_12_3 Node4_10_12 Node5_10_12 0.9856000000000001
C_4_10_12 Node4_10_12 GND 1.1279296875e-09
I_4_10_13 GND Node4_10_13 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 0.001953125A 39.96us 0.001953125A 43.29us 0.001953125A 46.620000000000005us 0.001953125A 49.95us 0.001953125A 53.28us 0.001953125A 56.61us 0.001953125A 59.94us 0.001953125A 63.27us 0.001953125A 66.6us 0.001953125A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_4_10_13_1 Node4_10_13 Node4_10_14 15400.0
R_4_10_13_2 Node4_10_13 Node4_11_13 15400.0
R_4_10_13_3 Node4_10_13 Node5_10_13 0.9856000000000001
C_4_10_13 Node4_10_13 GND 1.1279296875e-09
I_4_10_14 GND Node4_10_14 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 0.001953125A 39.96us 0.001953125A 43.29us 0.001953125A 46.620000000000005us 0.001953125A 49.95us 0.001953125A 53.28us 0.001953125A 56.61us 0.001953125A 59.94us 0.001953125A 63.27us 0.001953125A 66.6us 0.001953125A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_4_10_14_1 Node4_10_14 Node4_10_15 15399.999999999993
R_4_10_14_2 Node4_10_14 Node4_11_14 15400.0
R_4_10_14_3 Node4_10_14 Node5_10_14 0.9856000000000001
C_4_10_14 Node4_10_14 GND 1.1279296875e-09
I_4_10_15 GND Node4_10_15 PWL(0s 0A 3.33us 3.906250000000002e-08A 6.66us 3.906250000000002e-08A 9.99us 3.906250000000002e-08A 13.32us 3.906250000000002e-08A 16.65us 3.906250000000002e-08A 19.98us 3.906250000000002e-08A 23.310000000000002us 3.906250000000002e-08A 26.64us 3.906250000000002e-08A 29.97us 3.906250000000002e-08A 33.3us 3.906250000000002e-08A 36.63us 0.0019531250000000017A 39.96us 0.0019531250000000017A 43.29us 0.0019531250000000017A 46.620000000000005us 0.0019531250000000017A 49.95us 0.0019531250000000017A 53.28us 0.0019531250000000017A 56.61us 0.0019531250000000017A 59.94us 0.0019531250000000017A 63.27us 0.0019531250000000017A 66.6us 0.0019531250000000017A 69.93us 3.906250000000002e-08A 73.26us 3.906250000000002e-08A 76.59us 3.906250000000002e-08A 79.92us 3.906250000000002e-08A 83.25us 3.906250000000002e-08A 86.58us 3.906250000000002e-08A 89.91us 3.906250000000002e-08A 93.24000000000001us 3.906250000000002e-08A 96.57000000000001us 3.906250000000002e-08A 99.9us 3.906250000000002e-08A)
R_4_10_15_2 Node4_10_15 Node4_11_15 15399.999999999987
R_4_10_15_3 Node4_10_15 Node5_10_15 0.9855999999999993
C_4_10_15 Node4_10_15 GND 1.127929687500001e-09
I_4_11_0 GND Node4_11_0 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 0.001953125A 39.96us 0.001953125A 43.29us 0.001953125A 46.620000000000005us 0.001953125A 49.95us 0.001953125A 53.28us 0.001953125A 56.61us 0.001953125A 59.94us 0.001953125A 63.27us 0.001953125A 66.6us 0.001953125A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_4_11_0_1 Node4_11_0 Node4_11_1 15400.0
R_4_11_0_2 Node4_11_0 Node4_12_0 15400.0
R_4_11_0_3 Node4_11_0 Node5_11_0 0.9856000000000001
C_4_11_0 Node4_11_0 GND 1.1279296875e-09
I_4_11_1 GND Node4_11_1 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 0.001953125A 39.96us 0.001953125A 43.29us 0.001953125A 46.620000000000005us 0.001953125A 49.95us 0.001953125A 53.28us 0.001953125A 56.61us 0.001953125A 59.94us 0.001953125A 63.27us 0.001953125A 66.6us 0.001953125A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_4_11_1_1 Node4_11_1 Node4_11_2 15400.0
R_4_11_1_2 Node4_11_1 Node4_12_1 15400.0
R_4_11_1_3 Node4_11_1 Node5_11_1 0.9856000000000001
C_4_11_1 Node4_11_1 GND 1.1279296875e-09
I_4_11_2 GND Node4_11_2 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 0.001953125A 39.96us 0.001953125A 43.29us 0.001953125A 46.620000000000005us 0.001953125A 49.95us 0.001953125A 53.28us 0.001953125A 56.61us 0.001953125A 59.94us 0.001953125A 63.27us 0.001953125A 66.6us 0.001953125A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_4_11_2_1 Node4_11_2 Node4_11_3 15400.0
R_4_11_2_2 Node4_11_2 Node4_12_2 15400.0
R_4_11_2_3 Node4_11_2 Node5_11_2 0.9856000000000001
C_4_11_2 Node4_11_2 GND 1.1279296875e-09
I_4_11_3 GND Node4_11_3 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 0.001953125A 39.96us 0.001953125A 43.29us 0.001953125A 46.620000000000005us 0.001953125A 49.95us 0.001953125A 53.28us 0.001953125A 56.61us 0.001953125A 59.94us 0.001953125A 63.27us 0.001953125A 66.6us 0.001953125A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_4_11_3_1 Node4_11_3 Node4_11_4 15400.0
R_4_11_3_2 Node4_11_3 Node4_12_3 15400.0
R_4_11_3_3 Node4_11_3 Node5_11_3 0.9856000000000001
C_4_11_3 Node4_11_3 GND 1.1279296875e-09
I_4_11_4 GND Node4_11_4 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 0.001953125A 39.96us 0.001953125A 43.29us 0.001953125A 46.620000000000005us 0.001953125A 49.95us 0.001953125A 53.28us 0.001953125A 56.61us 0.001953125A 59.94us 0.001953125A 63.27us 0.001953125A 66.6us 0.001953125A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_4_11_4_1 Node4_11_4 Node4_11_5 15400.0
R_4_11_4_2 Node4_11_4 Node4_12_4 15400.0
R_4_11_4_3 Node4_11_4 Node5_11_4 0.9856000000000001
C_4_11_4 Node4_11_4 GND 1.1279296875e-09
I_4_11_5 GND Node4_11_5 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 0.001953125A 39.96us 0.001953125A 43.29us 0.001953125A 46.620000000000005us 0.001953125A 49.95us 0.001953125A 53.28us 0.001953125A 56.61us 0.001953125A 59.94us 0.001953125A 63.27us 0.001953125A 66.6us 0.001953125A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_4_11_5_1 Node4_11_5 Node4_11_6 15400.0
R_4_11_5_2 Node4_11_5 Node4_12_5 15400.0
R_4_11_5_3 Node4_11_5 Node5_11_5 0.9856000000000001
C_4_11_5 Node4_11_5 GND 1.1279296875e-09
I_4_11_6 GND Node4_11_6 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 0.001953125A 39.96us 0.001953125A 43.29us 0.001953125A 46.620000000000005us 0.001953125A 49.95us 0.001953125A 53.28us 0.001953125A 56.61us 0.001953125A 59.94us 0.001953125A 63.27us 0.001953125A 66.6us 0.001953125A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_4_11_6_1 Node4_11_6 Node4_11_7 15400.0
R_4_11_6_2 Node4_11_6 Node4_12_6 15400.0
R_4_11_6_3 Node4_11_6 Node5_11_6 0.9856000000000001
C_4_11_6 Node4_11_6 GND 1.1279296875e-09
I_4_11_7 GND Node4_11_7 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 0.001953125A 39.96us 0.001953125A 43.29us 0.001953125A 46.620000000000005us 0.001953125A 49.95us 0.001953125A 53.28us 0.001953125A 56.61us 0.001953125A 59.94us 0.001953125A 63.27us 0.001953125A 66.6us 0.001953125A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_4_11_7_1 Node4_11_7 Node4_11_8 15400.0
R_4_11_7_2 Node4_11_7 Node4_12_7 15400.0
R_4_11_7_3 Node4_11_7 Node5_11_7 0.9856000000000001
C_4_11_7 Node4_11_7 GND 1.1279296875e-09
I_4_11_8 GND Node4_11_8 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 0.001953125A 39.96us 0.001953125A 43.29us 0.001953125A 46.620000000000005us 0.001953125A 49.95us 0.001953125A 53.28us 0.001953125A 56.61us 0.001953125A 59.94us 0.001953125A 63.27us 0.001953125A 66.6us 0.001953125A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_4_11_8_1 Node4_11_8 Node4_11_9 15400.0
R_4_11_8_2 Node4_11_8 Node4_12_8 15400.0
R_4_11_8_3 Node4_11_8 Node5_11_8 0.9856000000000001
C_4_11_8 Node4_11_8 GND 1.1279296875e-09
I_4_11_9 GND Node4_11_9 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 0.001953125A 39.96us 0.001953125A 43.29us 0.001953125A 46.620000000000005us 0.001953125A 49.95us 0.001953125A 53.28us 0.001953125A 56.61us 0.001953125A 59.94us 0.001953125A 63.27us 0.001953125A 66.6us 0.001953125A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_4_11_9_1 Node4_11_9 Node4_11_10 15400.0
R_4_11_9_2 Node4_11_9 Node4_12_9 15400.0
R_4_11_9_3 Node4_11_9 Node5_11_9 0.9856000000000001
C_4_11_9 Node4_11_9 GND 1.1279296875e-09
I_4_11_10 GND Node4_11_10 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 0.001953125A 39.96us 0.001953125A 43.29us 0.001953125A 46.620000000000005us 0.001953125A 49.95us 0.001953125A 53.28us 0.001953125A 56.61us 0.001953125A 59.94us 0.001953125A 63.27us 0.001953125A 66.6us 0.001953125A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_4_11_10_1 Node4_11_10 Node4_11_11 15400.0
R_4_11_10_2 Node4_11_10 Node4_12_10 15400.0
R_4_11_10_3 Node4_11_10 Node5_11_10 0.9856000000000001
C_4_11_10 Node4_11_10 GND 1.1279296875e-09
I_4_11_11 GND Node4_11_11 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 0.001953125A 39.96us 0.001953125A 43.29us 0.001953125A 46.620000000000005us 0.001953125A 49.95us 0.001953125A 53.28us 0.001953125A 56.61us 0.001953125A 59.94us 0.001953125A 63.27us 0.001953125A 66.6us 0.001953125A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_4_11_11_1 Node4_11_11 Node4_11_12 15400.0
R_4_11_11_2 Node4_11_11 Node4_12_11 15400.0
R_4_11_11_3 Node4_11_11 Node5_11_11 0.9856000000000001
C_4_11_11 Node4_11_11 GND 1.1279296875e-09
I_4_11_12 GND Node4_11_12 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 0.001953125A 39.96us 0.001953125A 43.29us 0.001953125A 46.620000000000005us 0.001953125A 49.95us 0.001953125A 53.28us 0.001953125A 56.61us 0.001953125A 59.94us 0.001953125A 63.27us 0.001953125A 66.6us 0.001953125A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_4_11_12_1 Node4_11_12 Node4_11_13 15400.0
R_4_11_12_2 Node4_11_12 Node4_12_12 15400.0
R_4_11_12_3 Node4_11_12 Node5_11_12 0.9856000000000001
C_4_11_12 Node4_11_12 GND 1.1279296875e-09
I_4_11_13 GND Node4_11_13 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 0.001953125A 39.96us 0.001953125A 43.29us 0.001953125A 46.620000000000005us 0.001953125A 49.95us 0.001953125A 53.28us 0.001953125A 56.61us 0.001953125A 59.94us 0.001953125A 63.27us 0.001953125A 66.6us 0.001953125A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_4_11_13_1 Node4_11_13 Node4_11_14 15400.0
R_4_11_13_2 Node4_11_13 Node4_12_13 15400.0
R_4_11_13_3 Node4_11_13 Node5_11_13 0.9856000000000001
C_4_11_13 Node4_11_13 GND 1.1279296875e-09
I_4_11_14 GND Node4_11_14 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 0.001953125A 39.96us 0.001953125A 43.29us 0.001953125A 46.620000000000005us 0.001953125A 49.95us 0.001953125A 53.28us 0.001953125A 56.61us 0.001953125A 59.94us 0.001953125A 63.27us 0.001953125A 66.6us 0.001953125A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_4_11_14_1 Node4_11_14 Node4_11_15 15399.999999999993
R_4_11_14_2 Node4_11_14 Node4_12_14 15400.0
R_4_11_14_3 Node4_11_14 Node5_11_14 0.9856000000000001
C_4_11_14 Node4_11_14 GND 1.1279296875e-09
I_4_11_15 GND Node4_11_15 PWL(0s 0A 3.33us 3.906250000000002e-08A 6.66us 3.906250000000002e-08A 9.99us 3.906250000000002e-08A 13.32us 3.906250000000002e-08A 16.65us 3.906250000000002e-08A 19.98us 3.906250000000002e-08A 23.310000000000002us 3.906250000000002e-08A 26.64us 3.906250000000002e-08A 29.97us 3.906250000000002e-08A 33.3us 3.906250000000002e-08A 36.63us 0.0019531250000000017A 39.96us 0.0019531250000000017A 43.29us 0.0019531250000000017A 46.620000000000005us 0.0019531250000000017A 49.95us 0.0019531250000000017A 53.28us 0.0019531250000000017A 56.61us 0.0019531250000000017A 59.94us 0.0019531250000000017A 63.27us 0.0019531250000000017A 66.6us 0.0019531250000000017A 69.93us 3.906250000000002e-08A 73.26us 3.906250000000002e-08A 76.59us 3.906250000000002e-08A 79.92us 3.906250000000002e-08A 83.25us 3.906250000000002e-08A 86.58us 3.906250000000002e-08A 89.91us 3.906250000000002e-08A 93.24000000000001us 3.906250000000002e-08A 96.57000000000001us 3.906250000000002e-08A 99.9us 3.906250000000002e-08A)
R_4_11_15_2 Node4_11_15 Node4_12_15 15399.999999999987
R_4_11_15_3 Node4_11_15 Node5_11_15 0.9855999999999993
C_4_11_15 Node4_11_15 GND 1.127929687500001e-09
I_4_12_0 GND Node4_12_0 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 0.001953125A 39.96us 0.001953125A 43.29us 0.001953125A 46.620000000000005us 0.001953125A 49.95us 0.001953125A 53.28us 0.001953125A 56.61us 0.001953125A 59.94us 0.001953125A 63.27us 0.001953125A 66.6us 0.001953125A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_4_12_0_1 Node4_12_0 Node4_12_1 15400.0
R_4_12_0_2 Node4_12_0 Node4_13_0 15400.0
R_4_12_0_3 Node4_12_0 Node5_12_0 0.9856000000000001
C_4_12_0 Node4_12_0 GND 1.1279296875e-09
I_4_12_1 GND Node4_12_1 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 0.001953125A 39.96us 0.001953125A 43.29us 0.001953125A 46.620000000000005us 0.001953125A 49.95us 0.001953125A 53.28us 0.001953125A 56.61us 0.001953125A 59.94us 0.001953125A 63.27us 0.001953125A 66.6us 0.001953125A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_4_12_1_1 Node4_12_1 Node4_12_2 15400.0
R_4_12_1_2 Node4_12_1 Node4_13_1 15400.0
R_4_12_1_3 Node4_12_1 Node5_12_1 0.9856000000000001
C_4_12_1 Node4_12_1 GND 1.1279296875e-09
I_4_12_2 GND Node4_12_2 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 0.001953125A 39.96us 0.001953125A 43.29us 0.001953125A 46.620000000000005us 0.001953125A 49.95us 0.001953125A 53.28us 0.001953125A 56.61us 0.001953125A 59.94us 0.001953125A 63.27us 0.001953125A 66.6us 0.001953125A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_4_12_2_1 Node4_12_2 Node4_12_3 15400.0
R_4_12_2_2 Node4_12_2 Node4_13_2 15400.0
R_4_12_2_3 Node4_12_2 Node5_12_2 0.9856000000000001
C_4_12_2 Node4_12_2 GND 1.1279296875e-09
I_4_12_3 GND Node4_12_3 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 0.001953125A 39.96us 0.001953125A 43.29us 0.001953125A 46.620000000000005us 0.001953125A 49.95us 0.001953125A 53.28us 0.001953125A 56.61us 0.001953125A 59.94us 0.001953125A 63.27us 0.001953125A 66.6us 0.001953125A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_4_12_3_1 Node4_12_3 Node4_12_4 15400.0
R_4_12_3_2 Node4_12_3 Node4_13_3 15400.0
R_4_12_3_3 Node4_12_3 Node5_12_3 0.9856000000000001
C_4_12_3 Node4_12_3 GND 1.1279296875e-09
I_4_12_4 GND Node4_12_4 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 0.001953125A 39.96us 0.001953125A 43.29us 0.001953125A 46.620000000000005us 0.001953125A 49.95us 0.001953125A 53.28us 0.001953125A 56.61us 0.001953125A 59.94us 0.001953125A 63.27us 0.001953125A 66.6us 0.001953125A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_4_12_4_1 Node4_12_4 Node4_12_5 15400.0
R_4_12_4_2 Node4_12_4 Node4_13_4 15400.0
R_4_12_4_3 Node4_12_4 Node5_12_4 0.9856000000000001
C_4_12_4 Node4_12_4 GND 1.1279296875e-09
I_4_12_5 GND Node4_12_5 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 0.001953125A 39.96us 0.001953125A 43.29us 0.001953125A 46.620000000000005us 0.001953125A 49.95us 0.001953125A 53.28us 0.001953125A 56.61us 0.001953125A 59.94us 0.001953125A 63.27us 0.001953125A 66.6us 0.001953125A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_4_12_5_1 Node4_12_5 Node4_12_6 15400.0
R_4_12_5_2 Node4_12_5 Node4_13_5 15400.0
R_4_12_5_3 Node4_12_5 Node5_12_5 0.9856000000000001
C_4_12_5 Node4_12_5 GND 1.1279296875e-09
I_4_12_6 GND Node4_12_6 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 0.001953125A 39.96us 0.001953125A 43.29us 0.001953125A 46.620000000000005us 0.001953125A 49.95us 0.001953125A 53.28us 0.001953125A 56.61us 0.001953125A 59.94us 0.001953125A 63.27us 0.001953125A 66.6us 0.001953125A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_4_12_6_1 Node4_12_6 Node4_12_7 15400.0
R_4_12_6_2 Node4_12_6 Node4_13_6 15400.0
R_4_12_6_3 Node4_12_6 Node5_12_6 0.9856000000000001
C_4_12_6 Node4_12_6 GND 1.1279296875e-09
I_4_12_7 GND Node4_12_7 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 0.001953125A 39.96us 0.001953125A 43.29us 0.001953125A 46.620000000000005us 0.001953125A 49.95us 0.001953125A 53.28us 0.001953125A 56.61us 0.001953125A 59.94us 0.001953125A 63.27us 0.001953125A 66.6us 0.001953125A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_4_12_7_1 Node4_12_7 Node4_12_8 15400.0
R_4_12_7_2 Node4_12_7 Node4_13_7 15400.0
R_4_12_7_3 Node4_12_7 Node5_12_7 0.9856000000000001
C_4_12_7 Node4_12_7 GND 1.1279296875e-09
I_4_12_8 GND Node4_12_8 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 0.001953125A 39.96us 0.001953125A 43.29us 0.001953125A 46.620000000000005us 0.001953125A 49.95us 0.001953125A 53.28us 0.001953125A 56.61us 0.001953125A 59.94us 0.001953125A 63.27us 0.001953125A 66.6us 0.001953125A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_4_12_8_1 Node4_12_8 Node4_12_9 15400.0
R_4_12_8_2 Node4_12_8 Node4_13_8 15400.0
R_4_12_8_3 Node4_12_8 Node5_12_8 0.9856000000000001
C_4_12_8 Node4_12_8 GND 1.1279296875e-09
I_4_12_9 GND Node4_12_9 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 0.001953125A 39.96us 0.001953125A 43.29us 0.001953125A 46.620000000000005us 0.001953125A 49.95us 0.001953125A 53.28us 0.001953125A 56.61us 0.001953125A 59.94us 0.001953125A 63.27us 0.001953125A 66.6us 0.001953125A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_4_12_9_1 Node4_12_9 Node4_12_10 15400.0
R_4_12_9_2 Node4_12_9 Node4_13_9 15400.0
R_4_12_9_3 Node4_12_9 Node5_12_9 0.9856000000000001
C_4_12_9 Node4_12_9 GND 1.1279296875e-09
I_4_12_10 GND Node4_12_10 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 0.001953125A 39.96us 0.001953125A 43.29us 0.001953125A 46.620000000000005us 0.001953125A 49.95us 0.001953125A 53.28us 0.001953125A 56.61us 0.001953125A 59.94us 0.001953125A 63.27us 0.001953125A 66.6us 0.001953125A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_4_12_10_1 Node4_12_10 Node4_12_11 15400.0
R_4_12_10_2 Node4_12_10 Node4_13_10 15400.0
R_4_12_10_3 Node4_12_10 Node5_12_10 0.9856000000000001
C_4_12_10 Node4_12_10 GND 1.1279296875e-09
I_4_12_11 GND Node4_12_11 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 0.001953125A 39.96us 0.001953125A 43.29us 0.001953125A 46.620000000000005us 0.001953125A 49.95us 0.001953125A 53.28us 0.001953125A 56.61us 0.001953125A 59.94us 0.001953125A 63.27us 0.001953125A 66.6us 0.001953125A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_4_12_11_1 Node4_12_11 Node4_12_12 15400.0
R_4_12_11_2 Node4_12_11 Node4_13_11 15400.0
R_4_12_11_3 Node4_12_11 Node5_12_11 0.9856000000000001
C_4_12_11 Node4_12_11 GND 1.1279296875e-09
I_4_12_12 GND Node4_12_12 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 0.001953125A 39.96us 0.001953125A 43.29us 0.001953125A 46.620000000000005us 0.001953125A 49.95us 0.001953125A 53.28us 0.001953125A 56.61us 0.001953125A 59.94us 0.001953125A 63.27us 0.001953125A 66.6us 0.001953125A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_4_12_12_1 Node4_12_12 Node4_12_13 15400.0
R_4_12_12_2 Node4_12_12 Node4_13_12 15400.0
R_4_12_12_3 Node4_12_12 Node5_12_12 0.9856000000000001
C_4_12_12 Node4_12_12 GND 1.1279296875e-09
I_4_12_13 GND Node4_12_13 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 0.001953125A 39.96us 0.001953125A 43.29us 0.001953125A 46.620000000000005us 0.001953125A 49.95us 0.001953125A 53.28us 0.001953125A 56.61us 0.001953125A 59.94us 0.001953125A 63.27us 0.001953125A 66.6us 0.001953125A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_4_12_13_1 Node4_12_13 Node4_12_14 15400.0
R_4_12_13_2 Node4_12_13 Node4_13_13 15400.0
R_4_12_13_3 Node4_12_13 Node5_12_13 0.9856000000000001
C_4_12_13 Node4_12_13 GND 1.1279296875e-09
I_4_12_14 GND Node4_12_14 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 0.001953125A 39.96us 0.001953125A 43.29us 0.001953125A 46.620000000000005us 0.001953125A 49.95us 0.001953125A 53.28us 0.001953125A 56.61us 0.001953125A 59.94us 0.001953125A 63.27us 0.001953125A 66.6us 0.001953125A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_4_12_14_1 Node4_12_14 Node4_12_15 15399.999999999993
R_4_12_14_2 Node4_12_14 Node4_13_14 15400.0
R_4_12_14_3 Node4_12_14 Node5_12_14 0.9856000000000001
C_4_12_14 Node4_12_14 GND 1.1279296875e-09
I_4_12_15 GND Node4_12_15 PWL(0s 0A 3.33us 3.906250000000002e-08A 6.66us 3.906250000000002e-08A 9.99us 3.906250000000002e-08A 13.32us 3.906250000000002e-08A 16.65us 3.906250000000002e-08A 19.98us 3.906250000000002e-08A 23.310000000000002us 3.906250000000002e-08A 26.64us 3.906250000000002e-08A 29.97us 3.906250000000002e-08A 33.3us 3.906250000000002e-08A 36.63us 0.0019531250000000017A 39.96us 0.0019531250000000017A 43.29us 0.0019531250000000017A 46.620000000000005us 0.0019531250000000017A 49.95us 0.0019531250000000017A 53.28us 0.0019531250000000017A 56.61us 0.0019531250000000017A 59.94us 0.0019531250000000017A 63.27us 0.0019531250000000017A 66.6us 0.0019531250000000017A 69.93us 3.906250000000002e-08A 73.26us 3.906250000000002e-08A 76.59us 3.906250000000002e-08A 79.92us 3.906250000000002e-08A 83.25us 3.906250000000002e-08A 86.58us 3.906250000000002e-08A 89.91us 3.906250000000002e-08A 93.24000000000001us 3.906250000000002e-08A 96.57000000000001us 3.906250000000002e-08A 99.9us 3.906250000000002e-08A)
R_4_12_15_2 Node4_12_15 Node4_13_15 15399.999999999987
R_4_12_15_3 Node4_12_15 Node5_12_15 0.9855999999999993
C_4_12_15 Node4_12_15 GND 1.127929687500001e-09
I_4_13_0 GND Node4_13_0 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 0.001953125A 39.96us 0.001953125A 43.29us 0.001953125A 46.620000000000005us 0.001953125A 49.95us 0.001953125A 53.28us 0.001953125A 56.61us 0.001953125A 59.94us 0.001953125A 63.27us 0.001953125A 66.6us 0.001953125A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_4_13_0_1 Node4_13_0 Node4_13_1 15400.0
R_4_13_0_2 Node4_13_0 Node4_14_0 15400.0
R_4_13_0_3 Node4_13_0 Node5_13_0 0.9856000000000001
C_4_13_0 Node4_13_0 GND 1.1279296875e-09
I_4_13_1 GND Node4_13_1 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 0.001953125A 39.96us 0.001953125A 43.29us 0.001953125A 46.620000000000005us 0.001953125A 49.95us 0.001953125A 53.28us 0.001953125A 56.61us 0.001953125A 59.94us 0.001953125A 63.27us 0.001953125A 66.6us 0.001953125A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_4_13_1_1 Node4_13_1 Node4_13_2 15400.0
R_4_13_1_2 Node4_13_1 Node4_14_1 15400.0
R_4_13_1_3 Node4_13_1 Node5_13_1 0.9856000000000001
C_4_13_1 Node4_13_1 GND 1.1279296875e-09
I_4_13_2 GND Node4_13_2 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 0.001953125A 39.96us 0.001953125A 43.29us 0.001953125A 46.620000000000005us 0.001953125A 49.95us 0.001953125A 53.28us 0.001953125A 56.61us 0.001953125A 59.94us 0.001953125A 63.27us 0.001953125A 66.6us 0.001953125A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_4_13_2_1 Node4_13_2 Node4_13_3 15400.0
R_4_13_2_2 Node4_13_2 Node4_14_2 15400.0
R_4_13_2_3 Node4_13_2 Node5_13_2 0.9856000000000001
C_4_13_2 Node4_13_2 GND 1.1279296875e-09
I_4_13_3 GND Node4_13_3 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 0.001953125A 39.96us 0.001953125A 43.29us 0.001953125A 46.620000000000005us 0.001953125A 49.95us 0.001953125A 53.28us 0.001953125A 56.61us 0.001953125A 59.94us 0.001953125A 63.27us 0.001953125A 66.6us 0.001953125A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_4_13_3_1 Node4_13_3 Node4_13_4 15400.0
R_4_13_3_2 Node4_13_3 Node4_14_3 15400.0
R_4_13_3_3 Node4_13_3 Node5_13_3 0.9856000000000001
C_4_13_3 Node4_13_3 GND 1.1279296875e-09
I_4_13_4 GND Node4_13_4 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 0.001953125A 39.96us 0.001953125A 43.29us 0.001953125A 46.620000000000005us 0.001953125A 49.95us 0.001953125A 53.28us 0.001953125A 56.61us 0.001953125A 59.94us 0.001953125A 63.27us 0.001953125A 66.6us 0.001953125A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_4_13_4_1 Node4_13_4 Node4_13_5 15400.0
R_4_13_4_2 Node4_13_4 Node4_14_4 15400.0
R_4_13_4_3 Node4_13_4 Node5_13_4 0.9856000000000001
C_4_13_4 Node4_13_4 GND 1.1279296875e-09
I_4_13_5 GND Node4_13_5 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 0.001953125A 39.96us 0.001953125A 43.29us 0.001953125A 46.620000000000005us 0.001953125A 49.95us 0.001953125A 53.28us 0.001953125A 56.61us 0.001953125A 59.94us 0.001953125A 63.27us 0.001953125A 66.6us 0.001953125A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_4_13_5_1 Node4_13_5 Node4_13_6 15400.0
R_4_13_5_2 Node4_13_5 Node4_14_5 15400.0
R_4_13_5_3 Node4_13_5 Node5_13_5 0.9856000000000001
C_4_13_5 Node4_13_5 GND 1.1279296875e-09
I_4_13_6 GND Node4_13_6 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 0.001953125A 39.96us 0.001953125A 43.29us 0.001953125A 46.620000000000005us 0.001953125A 49.95us 0.001953125A 53.28us 0.001953125A 56.61us 0.001953125A 59.94us 0.001953125A 63.27us 0.001953125A 66.6us 0.001953125A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_4_13_6_1 Node4_13_6 Node4_13_7 15400.0
R_4_13_6_2 Node4_13_6 Node4_14_6 15400.0
R_4_13_6_3 Node4_13_6 Node5_13_6 0.9856000000000001
C_4_13_6 Node4_13_6 GND 1.1279296875e-09
I_4_13_7 GND Node4_13_7 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 0.001953125A 39.96us 0.001953125A 43.29us 0.001953125A 46.620000000000005us 0.001953125A 49.95us 0.001953125A 53.28us 0.001953125A 56.61us 0.001953125A 59.94us 0.001953125A 63.27us 0.001953125A 66.6us 0.001953125A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_4_13_7_1 Node4_13_7 Node4_13_8 15400.0
R_4_13_7_2 Node4_13_7 Node4_14_7 15400.0
R_4_13_7_3 Node4_13_7 Node5_13_7 0.9856000000000001
C_4_13_7 Node4_13_7 GND 1.1279296875e-09
I_4_13_8 GND Node4_13_8 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 0.001953125A 39.96us 0.001953125A 43.29us 0.001953125A 46.620000000000005us 0.001953125A 49.95us 0.001953125A 53.28us 0.001953125A 56.61us 0.001953125A 59.94us 0.001953125A 63.27us 0.001953125A 66.6us 0.001953125A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_4_13_8_1 Node4_13_8 Node4_13_9 15400.0
R_4_13_8_2 Node4_13_8 Node4_14_8 15400.0
R_4_13_8_3 Node4_13_8 Node5_13_8 0.9856000000000001
C_4_13_8 Node4_13_8 GND 1.1279296875e-09
I_4_13_9 GND Node4_13_9 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 0.001953125A 39.96us 0.001953125A 43.29us 0.001953125A 46.620000000000005us 0.001953125A 49.95us 0.001953125A 53.28us 0.001953125A 56.61us 0.001953125A 59.94us 0.001953125A 63.27us 0.001953125A 66.6us 0.001953125A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_4_13_9_1 Node4_13_9 Node4_13_10 15400.0
R_4_13_9_2 Node4_13_9 Node4_14_9 15400.0
R_4_13_9_3 Node4_13_9 Node5_13_9 0.9856000000000001
C_4_13_9 Node4_13_9 GND 1.1279296875e-09
I_4_13_10 GND Node4_13_10 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 0.001953125A 39.96us 0.001953125A 43.29us 0.001953125A 46.620000000000005us 0.001953125A 49.95us 0.001953125A 53.28us 0.001953125A 56.61us 0.001953125A 59.94us 0.001953125A 63.27us 0.001953125A 66.6us 0.001953125A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_4_13_10_1 Node4_13_10 Node4_13_11 15400.0
R_4_13_10_2 Node4_13_10 Node4_14_10 15400.0
R_4_13_10_3 Node4_13_10 Node5_13_10 0.9856000000000001
C_4_13_10 Node4_13_10 GND 1.1279296875e-09
I_4_13_11 GND Node4_13_11 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 0.001953125A 39.96us 0.001953125A 43.29us 0.001953125A 46.620000000000005us 0.001953125A 49.95us 0.001953125A 53.28us 0.001953125A 56.61us 0.001953125A 59.94us 0.001953125A 63.27us 0.001953125A 66.6us 0.001953125A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_4_13_11_1 Node4_13_11 Node4_13_12 15400.0
R_4_13_11_2 Node4_13_11 Node4_14_11 15400.0
R_4_13_11_3 Node4_13_11 Node5_13_11 0.9856000000000001
C_4_13_11 Node4_13_11 GND 1.1279296875e-09
I_4_13_12 GND Node4_13_12 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 0.001953125A 39.96us 0.001953125A 43.29us 0.001953125A 46.620000000000005us 0.001953125A 49.95us 0.001953125A 53.28us 0.001953125A 56.61us 0.001953125A 59.94us 0.001953125A 63.27us 0.001953125A 66.6us 0.001953125A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_4_13_12_1 Node4_13_12 Node4_13_13 15400.0
R_4_13_12_2 Node4_13_12 Node4_14_12 15400.0
R_4_13_12_3 Node4_13_12 Node5_13_12 0.9856000000000001
C_4_13_12 Node4_13_12 GND 1.1279296875e-09
I_4_13_13 GND Node4_13_13 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 0.001953125A 39.96us 0.001953125A 43.29us 0.001953125A 46.620000000000005us 0.001953125A 49.95us 0.001953125A 53.28us 0.001953125A 56.61us 0.001953125A 59.94us 0.001953125A 63.27us 0.001953125A 66.6us 0.001953125A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_4_13_13_1 Node4_13_13 Node4_13_14 15400.0
R_4_13_13_2 Node4_13_13 Node4_14_13 15400.0
R_4_13_13_3 Node4_13_13 Node5_13_13 0.9856000000000001
C_4_13_13 Node4_13_13 GND 1.1279296875e-09
I_4_13_14 GND Node4_13_14 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 0.001953125A 39.96us 0.001953125A 43.29us 0.001953125A 46.620000000000005us 0.001953125A 49.95us 0.001953125A 53.28us 0.001953125A 56.61us 0.001953125A 59.94us 0.001953125A 63.27us 0.001953125A 66.6us 0.001953125A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_4_13_14_1 Node4_13_14 Node4_13_15 15399.999999999993
R_4_13_14_2 Node4_13_14 Node4_14_14 15400.0
R_4_13_14_3 Node4_13_14 Node5_13_14 0.9856000000000001
C_4_13_14 Node4_13_14 GND 1.1279296875e-09
I_4_13_15 GND Node4_13_15 PWL(0s 0A 3.33us 3.906250000000002e-08A 6.66us 3.906250000000002e-08A 9.99us 3.906250000000002e-08A 13.32us 3.906250000000002e-08A 16.65us 3.906250000000002e-08A 19.98us 3.906250000000002e-08A 23.310000000000002us 3.906250000000002e-08A 26.64us 3.906250000000002e-08A 29.97us 3.906250000000002e-08A 33.3us 3.906250000000002e-08A 36.63us 0.0019531250000000017A 39.96us 0.0019531250000000017A 43.29us 0.0019531250000000017A 46.620000000000005us 0.0019531250000000017A 49.95us 0.0019531250000000017A 53.28us 0.0019531250000000017A 56.61us 0.0019531250000000017A 59.94us 0.0019531250000000017A 63.27us 0.0019531250000000017A 66.6us 0.0019531250000000017A 69.93us 3.906250000000002e-08A 73.26us 3.906250000000002e-08A 76.59us 3.906250000000002e-08A 79.92us 3.906250000000002e-08A 83.25us 3.906250000000002e-08A 86.58us 3.906250000000002e-08A 89.91us 3.906250000000002e-08A 93.24000000000001us 3.906250000000002e-08A 96.57000000000001us 3.906250000000002e-08A 99.9us 3.906250000000002e-08A)
R_4_13_15_2 Node4_13_15 Node4_14_15 15399.999999999987
R_4_13_15_3 Node4_13_15 Node5_13_15 0.9855999999999993
C_4_13_15 Node4_13_15 GND 1.127929687500001e-09
I_4_14_0 GND Node4_14_0 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 0.001953125A 39.96us 0.001953125A 43.29us 0.001953125A 46.620000000000005us 0.001953125A 49.95us 0.001953125A 53.28us 0.001953125A 56.61us 0.001953125A 59.94us 0.001953125A 63.27us 0.001953125A 66.6us 0.001953125A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_4_14_0_1 Node4_14_0 Node4_14_1 15400.0
R_4_14_0_2 Node4_14_0 Node4_15_0 15400.0
R_4_14_0_3 Node4_14_0 Node5_14_0 0.9856000000000001
C_4_14_0 Node4_14_0 GND 1.1279296875e-09
I_4_14_1 GND Node4_14_1 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 0.001953125A 39.96us 0.001953125A 43.29us 0.001953125A 46.620000000000005us 0.001953125A 49.95us 0.001953125A 53.28us 0.001953125A 56.61us 0.001953125A 59.94us 0.001953125A 63.27us 0.001953125A 66.6us 0.001953125A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_4_14_1_1 Node4_14_1 Node4_14_2 15400.0
R_4_14_1_2 Node4_14_1 Node4_15_1 15400.0
R_4_14_1_3 Node4_14_1 Node5_14_1 0.9856000000000001
C_4_14_1 Node4_14_1 GND 1.1279296875e-09
I_4_14_2 GND Node4_14_2 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 0.001953125A 39.96us 0.001953125A 43.29us 0.001953125A 46.620000000000005us 0.001953125A 49.95us 0.001953125A 53.28us 0.001953125A 56.61us 0.001953125A 59.94us 0.001953125A 63.27us 0.001953125A 66.6us 0.001953125A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_4_14_2_1 Node4_14_2 Node4_14_3 15400.0
R_4_14_2_2 Node4_14_2 Node4_15_2 15400.0
R_4_14_2_3 Node4_14_2 Node5_14_2 0.9856000000000001
C_4_14_2 Node4_14_2 GND 1.1279296875e-09
I_4_14_3 GND Node4_14_3 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 0.001953125A 39.96us 0.001953125A 43.29us 0.001953125A 46.620000000000005us 0.001953125A 49.95us 0.001953125A 53.28us 0.001953125A 56.61us 0.001953125A 59.94us 0.001953125A 63.27us 0.001953125A 66.6us 0.001953125A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_4_14_3_1 Node4_14_3 Node4_14_4 15400.0
R_4_14_3_2 Node4_14_3 Node4_15_3 15400.0
R_4_14_3_3 Node4_14_3 Node5_14_3 0.9856000000000001
C_4_14_3 Node4_14_3 GND 1.1279296875e-09
I_4_14_4 GND Node4_14_4 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 0.001953125A 39.96us 0.001953125A 43.29us 0.001953125A 46.620000000000005us 0.001953125A 49.95us 0.001953125A 53.28us 0.001953125A 56.61us 0.001953125A 59.94us 0.001953125A 63.27us 0.001953125A 66.6us 0.001953125A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_4_14_4_1 Node4_14_4 Node4_14_5 15400.0
R_4_14_4_2 Node4_14_4 Node4_15_4 15400.0
R_4_14_4_3 Node4_14_4 Node5_14_4 0.9856000000000001
C_4_14_4 Node4_14_4 GND 1.1279296875e-09
I_4_14_5 GND Node4_14_5 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 0.001953125A 39.96us 0.001953125A 43.29us 0.001953125A 46.620000000000005us 0.001953125A 49.95us 0.001953125A 53.28us 0.001953125A 56.61us 0.001953125A 59.94us 0.001953125A 63.27us 0.001953125A 66.6us 0.001953125A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_4_14_5_1 Node4_14_5 Node4_14_6 15400.0
R_4_14_5_2 Node4_14_5 Node4_15_5 15400.0
R_4_14_5_3 Node4_14_5 Node5_14_5 0.9856000000000001
C_4_14_5 Node4_14_5 GND 1.1279296875e-09
I_4_14_6 GND Node4_14_6 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 0.001953125A 39.96us 0.001953125A 43.29us 0.001953125A 46.620000000000005us 0.001953125A 49.95us 0.001953125A 53.28us 0.001953125A 56.61us 0.001953125A 59.94us 0.001953125A 63.27us 0.001953125A 66.6us 0.001953125A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_4_14_6_1 Node4_14_6 Node4_14_7 15400.0
R_4_14_6_2 Node4_14_6 Node4_15_6 15400.0
R_4_14_6_3 Node4_14_6 Node5_14_6 0.9856000000000001
C_4_14_6 Node4_14_6 GND 1.1279296875e-09
I_4_14_7 GND Node4_14_7 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 0.001953125A 39.96us 0.001953125A 43.29us 0.001953125A 46.620000000000005us 0.001953125A 49.95us 0.001953125A 53.28us 0.001953125A 56.61us 0.001953125A 59.94us 0.001953125A 63.27us 0.001953125A 66.6us 0.001953125A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_4_14_7_1 Node4_14_7 Node4_14_8 15400.0
R_4_14_7_2 Node4_14_7 Node4_15_7 15400.0
R_4_14_7_3 Node4_14_7 Node5_14_7 0.9856000000000001
C_4_14_7 Node4_14_7 GND 1.1279296875e-09
I_4_14_8 GND Node4_14_8 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 0.001953125A 39.96us 0.001953125A 43.29us 0.001953125A 46.620000000000005us 0.001953125A 49.95us 0.001953125A 53.28us 0.001953125A 56.61us 0.001953125A 59.94us 0.001953125A 63.27us 0.001953125A 66.6us 0.001953125A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_4_14_8_1 Node4_14_8 Node4_14_9 15400.0
R_4_14_8_2 Node4_14_8 Node4_15_8 15400.0
R_4_14_8_3 Node4_14_8 Node5_14_8 0.9856000000000001
C_4_14_8 Node4_14_8 GND 1.1279296875e-09
I_4_14_9 GND Node4_14_9 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 0.001953125A 39.96us 0.001953125A 43.29us 0.001953125A 46.620000000000005us 0.001953125A 49.95us 0.001953125A 53.28us 0.001953125A 56.61us 0.001953125A 59.94us 0.001953125A 63.27us 0.001953125A 66.6us 0.001953125A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_4_14_9_1 Node4_14_9 Node4_14_10 15400.0
R_4_14_9_2 Node4_14_9 Node4_15_9 15400.0
R_4_14_9_3 Node4_14_9 Node5_14_9 0.9856000000000001
C_4_14_9 Node4_14_9 GND 1.1279296875e-09
I_4_14_10 GND Node4_14_10 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 0.001953125A 39.96us 0.001953125A 43.29us 0.001953125A 46.620000000000005us 0.001953125A 49.95us 0.001953125A 53.28us 0.001953125A 56.61us 0.001953125A 59.94us 0.001953125A 63.27us 0.001953125A 66.6us 0.001953125A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_4_14_10_1 Node4_14_10 Node4_14_11 15400.0
R_4_14_10_2 Node4_14_10 Node4_15_10 15400.0
R_4_14_10_3 Node4_14_10 Node5_14_10 0.9856000000000001
C_4_14_10 Node4_14_10 GND 1.1279296875e-09
I_4_14_11 GND Node4_14_11 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 0.001953125A 39.96us 0.001953125A 43.29us 0.001953125A 46.620000000000005us 0.001953125A 49.95us 0.001953125A 53.28us 0.001953125A 56.61us 0.001953125A 59.94us 0.001953125A 63.27us 0.001953125A 66.6us 0.001953125A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_4_14_11_1 Node4_14_11 Node4_14_12 15400.0
R_4_14_11_2 Node4_14_11 Node4_15_11 15400.0
R_4_14_11_3 Node4_14_11 Node5_14_11 0.9856000000000001
C_4_14_11 Node4_14_11 GND 1.1279296875e-09
I_4_14_12 GND Node4_14_12 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 0.001953125A 39.96us 0.001953125A 43.29us 0.001953125A 46.620000000000005us 0.001953125A 49.95us 0.001953125A 53.28us 0.001953125A 56.61us 0.001953125A 59.94us 0.001953125A 63.27us 0.001953125A 66.6us 0.001953125A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_4_14_12_1 Node4_14_12 Node4_14_13 15400.0
R_4_14_12_2 Node4_14_12 Node4_15_12 15400.0
R_4_14_12_3 Node4_14_12 Node5_14_12 0.9856000000000001
C_4_14_12 Node4_14_12 GND 1.1279296875e-09
I_4_14_13 GND Node4_14_13 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 0.001953125A 39.96us 0.001953125A 43.29us 0.001953125A 46.620000000000005us 0.001953125A 49.95us 0.001953125A 53.28us 0.001953125A 56.61us 0.001953125A 59.94us 0.001953125A 63.27us 0.001953125A 66.6us 0.001953125A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_4_14_13_1 Node4_14_13 Node4_14_14 15400.0
R_4_14_13_2 Node4_14_13 Node4_15_13 15400.0
R_4_14_13_3 Node4_14_13 Node5_14_13 0.9856000000000001
C_4_14_13 Node4_14_13 GND 1.1279296875e-09
I_4_14_14 GND Node4_14_14 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 0.001953125A 39.96us 0.001953125A 43.29us 0.001953125A 46.620000000000005us 0.001953125A 49.95us 0.001953125A 53.28us 0.001953125A 56.61us 0.001953125A 59.94us 0.001953125A 63.27us 0.001953125A 66.6us 0.001953125A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_4_14_14_1 Node4_14_14 Node4_14_15 15399.999999999993
R_4_14_14_2 Node4_14_14 Node4_15_14 15400.0
R_4_14_14_3 Node4_14_14 Node5_14_14 0.9856000000000001
C_4_14_14 Node4_14_14 GND 1.1279296875e-09
I_4_14_15 GND Node4_14_15 PWL(0s 0A 3.33us 3.906250000000002e-08A 6.66us 3.906250000000002e-08A 9.99us 3.906250000000002e-08A 13.32us 3.906250000000002e-08A 16.65us 3.906250000000002e-08A 19.98us 3.906250000000002e-08A 23.310000000000002us 3.906250000000002e-08A 26.64us 3.906250000000002e-08A 29.97us 3.906250000000002e-08A 33.3us 3.906250000000002e-08A 36.63us 0.0019531250000000017A 39.96us 0.0019531250000000017A 43.29us 0.0019531250000000017A 46.620000000000005us 0.0019531250000000017A 49.95us 0.0019531250000000017A 53.28us 0.0019531250000000017A 56.61us 0.0019531250000000017A 59.94us 0.0019531250000000017A 63.27us 0.0019531250000000017A 66.6us 0.0019531250000000017A 69.93us 3.906250000000002e-08A 73.26us 3.906250000000002e-08A 76.59us 3.906250000000002e-08A 79.92us 3.906250000000002e-08A 83.25us 3.906250000000002e-08A 86.58us 3.906250000000002e-08A 89.91us 3.906250000000002e-08A 93.24000000000001us 3.906250000000002e-08A 96.57000000000001us 3.906250000000002e-08A 99.9us 3.906250000000002e-08A)
R_4_14_15_2 Node4_14_15 Node4_15_15 15399.999999999985
R_4_14_15_3 Node4_14_15 Node5_14_15 0.9855999999999993
C_4_14_15 Node4_14_15 GND 1.127929687500001e-09
I_4_15_0 GND Node4_15_0 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 0.001953125A 39.96us 0.001953125A 43.29us 0.001953125A 46.620000000000005us 0.001953125A 49.95us 0.001953125A 53.28us 0.001953125A 56.61us 0.001953125A 59.94us 0.001953125A 63.27us 0.001953125A 66.6us 0.001953125A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_4_15_0_1 Node4_15_0 Node4_15_1 15400.0
R_4_15_0_3 Node4_15_0 Node5_15_0 0.9856000000000001
C_4_15_0 Node4_15_0 GND 1.1279296875e-09
I_4_15_1 GND Node4_15_1 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 0.001953125A 39.96us 0.001953125A 43.29us 0.001953125A 46.620000000000005us 0.001953125A 49.95us 0.001953125A 53.28us 0.001953125A 56.61us 0.001953125A 59.94us 0.001953125A 63.27us 0.001953125A 66.6us 0.001953125A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_4_15_1_1 Node4_15_1 Node4_15_2 15400.0
R_4_15_1_3 Node4_15_1 Node5_15_1 0.9856000000000001
C_4_15_1 Node4_15_1 GND 1.1279296875e-09
I_4_15_2 GND Node4_15_2 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 0.001953125A 39.96us 0.001953125A 43.29us 0.001953125A 46.620000000000005us 0.001953125A 49.95us 0.001953125A 53.28us 0.001953125A 56.61us 0.001953125A 59.94us 0.001953125A 63.27us 0.001953125A 66.6us 0.001953125A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_4_15_2_1 Node4_15_2 Node4_15_3 15400.0
R_4_15_2_3 Node4_15_2 Node5_15_2 0.9856000000000001
C_4_15_2 Node4_15_2 GND 1.1279296875e-09
I_4_15_3 GND Node4_15_3 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 0.001953125A 39.96us 0.001953125A 43.29us 0.001953125A 46.620000000000005us 0.001953125A 49.95us 0.001953125A 53.28us 0.001953125A 56.61us 0.001953125A 59.94us 0.001953125A 63.27us 0.001953125A 66.6us 0.001953125A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_4_15_3_1 Node4_15_3 Node4_15_4 15400.0
R_4_15_3_3 Node4_15_3 Node5_15_3 0.9856000000000001
C_4_15_3 Node4_15_3 GND 1.1279296875e-09
I_4_15_4 GND Node4_15_4 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 0.001953125A 39.96us 0.001953125A 43.29us 0.001953125A 46.620000000000005us 0.001953125A 49.95us 0.001953125A 53.28us 0.001953125A 56.61us 0.001953125A 59.94us 0.001953125A 63.27us 0.001953125A 66.6us 0.001953125A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_4_15_4_1 Node4_15_4 Node4_15_5 15400.0
R_4_15_4_3 Node4_15_4 Node5_15_4 0.9856000000000001
C_4_15_4 Node4_15_4 GND 1.1279296875e-09
I_4_15_5 GND Node4_15_5 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 0.001953125A 39.96us 0.001953125A 43.29us 0.001953125A 46.620000000000005us 0.001953125A 49.95us 0.001953125A 53.28us 0.001953125A 56.61us 0.001953125A 59.94us 0.001953125A 63.27us 0.001953125A 66.6us 0.001953125A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_4_15_5_1 Node4_15_5 Node4_15_6 15400.0
R_4_15_5_3 Node4_15_5 Node5_15_5 0.9856000000000001
C_4_15_5 Node4_15_5 GND 1.1279296875e-09
I_4_15_6 GND Node4_15_6 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 0.001953125A 39.96us 0.001953125A 43.29us 0.001953125A 46.620000000000005us 0.001953125A 49.95us 0.001953125A 53.28us 0.001953125A 56.61us 0.001953125A 59.94us 0.001953125A 63.27us 0.001953125A 66.6us 0.001953125A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_4_15_6_1 Node4_15_6 Node4_15_7 15400.0
R_4_15_6_3 Node4_15_6 Node5_15_6 0.9856000000000001
C_4_15_6 Node4_15_6 GND 1.1279296875e-09
I_4_15_7 GND Node4_15_7 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 0.001953125A 39.96us 0.001953125A 43.29us 0.001953125A 46.620000000000005us 0.001953125A 49.95us 0.001953125A 53.28us 0.001953125A 56.61us 0.001953125A 59.94us 0.001953125A 63.27us 0.001953125A 66.6us 0.001953125A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_4_15_7_1 Node4_15_7 Node4_15_8 15400.0
R_4_15_7_3 Node4_15_7 Node5_15_7 0.9856000000000001
C_4_15_7 Node4_15_7 GND 1.1279296875e-09
I_4_15_8 GND Node4_15_8 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 0.001953125A 39.96us 0.001953125A 43.29us 0.001953125A 46.620000000000005us 0.001953125A 49.95us 0.001953125A 53.28us 0.001953125A 56.61us 0.001953125A 59.94us 0.001953125A 63.27us 0.001953125A 66.6us 0.001953125A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_4_15_8_1 Node4_15_8 Node4_15_9 15400.0
R_4_15_8_3 Node4_15_8 Node5_15_8 0.9856000000000001
C_4_15_8 Node4_15_8 GND 1.1279296875e-09
I_4_15_9 GND Node4_15_9 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 0.001953125A 39.96us 0.001953125A 43.29us 0.001953125A 46.620000000000005us 0.001953125A 49.95us 0.001953125A 53.28us 0.001953125A 56.61us 0.001953125A 59.94us 0.001953125A 63.27us 0.001953125A 66.6us 0.001953125A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_4_15_9_1 Node4_15_9 Node4_15_10 15400.0
R_4_15_9_3 Node4_15_9 Node5_15_9 0.9856000000000001
C_4_15_9 Node4_15_9 GND 1.1279296875e-09
I_4_15_10 GND Node4_15_10 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 0.001953125A 39.96us 0.001953125A 43.29us 0.001953125A 46.620000000000005us 0.001953125A 49.95us 0.001953125A 53.28us 0.001953125A 56.61us 0.001953125A 59.94us 0.001953125A 63.27us 0.001953125A 66.6us 0.001953125A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_4_15_10_1 Node4_15_10 Node4_15_11 15400.0
R_4_15_10_3 Node4_15_10 Node5_15_10 0.9856000000000001
C_4_15_10 Node4_15_10 GND 1.1279296875e-09
I_4_15_11 GND Node4_15_11 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 0.001953125A 39.96us 0.001953125A 43.29us 0.001953125A 46.620000000000005us 0.001953125A 49.95us 0.001953125A 53.28us 0.001953125A 56.61us 0.001953125A 59.94us 0.001953125A 63.27us 0.001953125A 66.6us 0.001953125A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_4_15_11_1 Node4_15_11 Node4_15_12 15400.0
R_4_15_11_3 Node4_15_11 Node5_15_11 0.9856000000000001
C_4_15_11 Node4_15_11 GND 1.1279296875e-09
I_4_15_12 GND Node4_15_12 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 0.001953125A 39.96us 0.001953125A 43.29us 0.001953125A 46.620000000000005us 0.001953125A 49.95us 0.001953125A 53.28us 0.001953125A 56.61us 0.001953125A 59.94us 0.001953125A 63.27us 0.001953125A 66.6us 0.001953125A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_4_15_12_1 Node4_15_12 Node4_15_13 15400.0
R_4_15_12_3 Node4_15_12 Node5_15_12 0.9856000000000001
C_4_15_12 Node4_15_12 GND 1.1279296875e-09
I_4_15_13 GND Node4_15_13 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 0.001953125A 39.96us 0.001953125A 43.29us 0.001953125A 46.620000000000005us 0.001953125A 49.95us 0.001953125A 53.28us 0.001953125A 56.61us 0.001953125A 59.94us 0.001953125A 63.27us 0.001953125A 66.6us 0.001953125A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_4_15_13_1 Node4_15_13 Node4_15_14 15400.0
R_4_15_13_3 Node4_15_13 Node5_15_13 0.9856000000000001
C_4_15_13 Node4_15_13 GND 1.1279296875e-09
I_4_15_14 GND Node4_15_14 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 0.001953125A 39.96us 0.001953125A 43.29us 0.001953125A 46.620000000000005us 0.001953125A 49.95us 0.001953125A 53.28us 0.001953125A 56.61us 0.001953125A 59.94us 0.001953125A 63.27us 0.001953125A 66.6us 0.001953125A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_4_15_14_1 Node4_15_14 Node4_15_15 15399.999999999993
R_4_15_14_3 Node4_15_14 Node5_15_14 0.9856000000000001
C_4_15_14 Node4_15_14 GND 1.1279296875e-09
I_4_15_15 GND Node4_15_15 PWL(0s 0A 3.33us 3.9062500000000036e-08A 6.66us 3.9062500000000036e-08A 9.99us 3.9062500000000036e-08A 13.32us 3.9062500000000036e-08A 16.65us 3.9062500000000036e-08A 19.98us 3.9062500000000036e-08A 23.310000000000002us 3.9062500000000036e-08A 26.64us 3.9062500000000036e-08A 29.97us 3.9062500000000036e-08A 33.3us 3.9062500000000036e-08A 36.63us 0.001953125000000002A 39.96us 0.001953125000000002A 43.29us 0.001953125000000002A 46.620000000000005us 0.001953125000000002A 49.95us 0.001953125000000002A 53.28us 0.001953125000000002A 56.61us 0.001953125000000002A 59.94us 0.001953125000000002A 63.27us 0.001953125000000002A 66.6us 0.001953125000000002A 69.93us 3.9062500000000036e-08A 73.26us 3.9062500000000036e-08A 76.59us 3.9062500000000036e-08A 79.92us 3.9062500000000036e-08A 83.25us 3.9062500000000036e-08A 86.58us 3.9062500000000036e-08A 89.91us 3.9062500000000036e-08A 93.24000000000001us 3.9062500000000036e-08A 96.57000000000001us 3.9062500000000036e-08A 99.9us 3.9062500000000036e-08A)
R_4_15_15_3 Node4_15_15 Node5_15_15 0.985599999999999
C_4_15_15 Node4_15_15 GND 1.1279296875000012e-09
R_5_0_0_1 Node5_0_0 Node5_0_1 7240000.0000000065
R_5_0_0_2 Node5_0_0 Node5_1_0 7240000.000000003
R_5_0_0_3 Node5_0_0 Node6_0_0 18.53440000000002
C_5_0_0 Node5_0_0 GND 3.416015624999997e-10
R_5_0_1_1 Node5_0_1 Node5_0_2 7240000.0000000065
R_5_0_1_2 Node5_0_1 Node5_1_1 7240000.000000003
R_5_0_1_3 Node5_0_1 Node6_0_1 18.53440000000002
C_5_0_1 Node5_0_1 GND 3.416015624999997e-10
R_5_0_2_1 Node5_0_2 Node5_0_3 7240000.0000000065
R_5_0_2_2 Node5_0_2 Node5_1_2 7240000.000000003
R_5_0_2_3 Node5_0_2 Node6_0_2 18.53440000000002
C_5_0_2 Node5_0_2 GND 3.416015624999997e-10
R_5_0_3_1 Node5_0_3 Node5_0_4 7240000.0000000065
R_5_0_3_2 Node5_0_3 Node5_1_3 7240000.000000003
R_5_0_3_3 Node5_0_3 Node6_0_3 18.53440000000002
C_5_0_3 Node5_0_3 GND 3.416015624999997e-10
R_5_0_4_1 Node5_0_4 Node5_0_5 7240000.0000000065
R_5_0_4_2 Node5_0_4 Node5_1_4 7240000.000000003
R_5_0_4_3 Node5_0_4 Node6_0_4 18.53440000000002
C_5_0_4 Node5_0_4 GND 3.416015624999997e-10
R_5_0_5_1 Node5_0_5 Node5_0_6 7240000.0000000065
R_5_0_5_2 Node5_0_5 Node5_1_5 7240000.000000003
R_5_0_5_3 Node5_0_5 Node6_0_5 18.53440000000002
C_5_0_5 Node5_0_5 GND 3.416015624999997e-10
R_5_0_6_1 Node5_0_6 Node5_0_7 7240000.0000000065
R_5_0_6_2 Node5_0_6 Node5_1_6 7240000.000000003
R_5_0_6_3 Node5_0_6 Node6_0_6 18.53440000000002
C_5_0_6 Node5_0_6 GND 3.416015624999997e-10
R_5_0_7_1 Node5_0_7 Node5_0_8 7240000.0000000065
R_5_0_7_2 Node5_0_7 Node5_1_7 7240000.000000003
R_5_0_7_3 Node5_0_7 Node6_0_7 18.53440000000002
C_5_0_7 Node5_0_7 GND 3.416015624999997e-10
R_5_0_8_1 Node5_0_8 Node5_0_9 7240000.0000000065
R_5_0_8_2 Node5_0_8 Node5_1_8 7240000.000000003
R_5_0_8_3 Node5_0_8 Node6_0_8 18.53440000000002
C_5_0_8 Node5_0_8 GND 3.416015624999997e-10
R_5_0_9_1 Node5_0_9 Node5_0_10 7240000.0000000065
R_5_0_9_2 Node5_0_9 Node5_1_9 7240000.000000003
R_5_0_9_3 Node5_0_9 Node6_0_9 18.53440000000002
C_5_0_9 Node5_0_9 GND 3.416015624999997e-10
R_5_0_10_1 Node5_0_10 Node5_0_11 7240000.0000000065
R_5_0_10_2 Node5_0_10 Node5_1_10 7240000.000000003
R_5_0_10_3 Node5_0_10 Node6_0_10 18.53440000000002
C_5_0_10 Node5_0_10 GND 3.416015624999997e-10
R_5_0_11_1 Node5_0_11 Node5_0_12 7240000.0000000065
R_5_0_11_2 Node5_0_11 Node5_1_11 7240000.000000003
R_5_0_11_3 Node5_0_11 Node6_0_11 18.53440000000002
C_5_0_11 Node5_0_11 GND 3.416015624999997e-10
R_5_0_12_1 Node5_0_12 Node5_0_13 7240000.0000000065
R_5_0_12_2 Node5_0_12 Node5_1_12 7240000.000000003
R_5_0_12_3 Node5_0_12 Node6_0_12 18.53440000000002
C_5_0_12 Node5_0_12 GND 3.416015624999997e-10
R_5_0_13_1 Node5_0_13 Node5_0_14 7240000.0000000065
R_5_0_13_2 Node5_0_13 Node5_1_13 7240000.000000003
R_5_0_13_3 Node5_0_13 Node6_0_13 18.53440000000002
C_5_0_13 Node5_0_13 GND 3.416015624999997e-10
R_5_0_14_1 Node5_0_14 Node5_0_15 7240000.000000003
R_5_0_14_2 Node5_0_14 Node5_1_14 7240000.000000003
R_5_0_14_3 Node5_0_14 Node6_0_14 18.53440000000002
C_5_0_14 Node5_0_14 GND 3.416015624999997e-10
R_5_0_15_2 Node5_0_15 Node5_1_15 7239999.999999996
R_5_0_15_3 Node5_0_15 Node6_0_15 18.5344
C_5_0_15 Node5_0_15 GND 3.416015625e-10
R_5_1_0_1 Node5_1_0 Node5_1_1 7239999.999999999
R_5_1_0_2 Node5_1_0 Node5_2_0 7239999.999999999
R_5_1_0_3 Node5_1_0 Node6_1_0 18.5344
C_5_1_0 Node5_1_0 GND 3.416015625e-10
R_5_1_1_1 Node5_1_1 Node5_1_2 7239999.999999999
R_5_1_1_2 Node5_1_1 Node5_2_1 7239999.999999999
R_5_1_1_3 Node5_1_1 Node6_1_1 18.5344
C_5_1_1 Node5_1_1 GND 3.416015625e-10
R_5_1_2_1 Node5_1_2 Node5_1_3 7239999.999999999
R_5_1_2_2 Node5_1_2 Node5_2_2 7239999.999999999
R_5_1_2_3 Node5_1_2 Node6_1_2 18.5344
C_5_1_2 Node5_1_2 GND 3.416015625e-10
R_5_1_3_1 Node5_1_3 Node5_1_4 7239999.999999999
R_5_1_3_2 Node5_1_3 Node5_2_3 7239999.999999999
R_5_1_3_3 Node5_1_3 Node6_1_3 18.5344
C_5_1_3 Node5_1_3 GND 3.416015625e-10
R_5_1_4_1 Node5_1_4 Node5_1_5 7239999.999999999
R_5_1_4_2 Node5_1_4 Node5_2_4 7239999.999999999
R_5_1_4_3 Node5_1_4 Node6_1_4 18.5344
C_5_1_4 Node5_1_4 GND 3.416015625e-10
R_5_1_5_1 Node5_1_5 Node5_1_6 7239999.999999999
R_5_1_5_2 Node5_1_5 Node5_2_5 7239999.999999999
R_5_1_5_3 Node5_1_5 Node6_1_5 18.5344
C_5_1_5 Node5_1_5 GND 3.416015625e-10
R_5_1_6_1 Node5_1_6 Node5_1_7 7239999.999999999
R_5_1_6_2 Node5_1_6 Node5_2_6 7239999.999999999
R_5_1_6_3 Node5_1_6 Node6_1_6 18.5344
C_5_1_6 Node5_1_6 GND 3.416015625e-10
R_5_1_7_1 Node5_1_7 Node5_1_8 7239999.999999999
R_5_1_7_2 Node5_1_7 Node5_2_7 7239999.999999999
R_5_1_7_3 Node5_1_7 Node6_1_7 18.5344
C_5_1_7 Node5_1_7 GND 3.416015625e-10
R_5_1_8_1 Node5_1_8 Node5_1_9 7239999.999999999
R_5_1_8_2 Node5_1_8 Node5_2_8 7239999.999999999
R_5_1_8_3 Node5_1_8 Node6_1_8 18.5344
C_5_1_8 Node5_1_8 GND 3.416015625e-10
R_5_1_9_1 Node5_1_9 Node5_1_10 7239999.999999999
R_5_1_9_2 Node5_1_9 Node5_2_9 7239999.999999999
R_5_1_9_3 Node5_1_9 Node6_1_9 18.5344
C_5_1_9 Node5_1_9 GND 3.416015625e-10
R_5_1_10_1 Node5_1_10 Node5_1_11 7239999.999999999
R_5_1_10_2 Node5_1_10 Node5_2_10 7239999.999999999
R_5_1_10_3 Node5_1_10 Node6_1_10 18.5344
C_5_1_10 Node5_1_10 GND 3.416015625e-10
R_5_1_11_1 Node5_1_11 Node5_1_12 7239999.999999999
R_5_1_11_2 Node5_1_11 Node5_2_11 7239999.999999999
R_5_1_11_3 Node5_1_11 Node6_1_11 18.5344
C_5_1_11 Node5_1_11 GND 3.416015625e-10
R_5_1_12_1 Node5_1_12 Node5_1_13 7239999.999999999
R_5_1_12_2 Node5_1_12 Node5_2_12 7239999.999999999
R_5_1_12_3 Node5_1_12 Node6_1_12 18.5344
C_5_1_12 Node5_1_12 GND 3.416015625e-10
R_5_1_13_1 Node5_1_13 Node5_1_14 7239999.999999999
R_5_1_13_2 Node5_1_13 Node5_2_13 7239999.999999999
R_5_1_13_3 Node5_1_13 Node6_1_13 18.5344
C_5_1_13 Node5_1_13 GND 3.416015625e-10
R_5_1_14_1 Node5_1_14 Node5_1_15 7239999.999999996
R_5_1_14_2 Node5_1_14 Node5_2_14 7239999.999999999
R_5_1_14_3 Node5_1_14 Node6_1_14 18.5344
C_5_1_14 Node5_1_14 GND 3.416015625e-10
R_5_1_15_2 Node5_1_15 Node5_2_15 7239999.999999993
R_5_1_15_3 Node5_1_15 Node6_1_15 18.534399999999987
C_5_1_15 Node5_1_15 GND 3.4160156250000033e-10
R_5_2_0_1 Node5_2_0 Node5_2_1 7239999.999999999
R_5_2_0_2 Node5_2_0 Node5_3_0 7239999.999999999
R_5_2_0_3 Node5_2_0 Node6_2_0 18.5344
C_5_2_0 Node5_2_0 GND 3.416015625e-10
R_5_2_1_1 Node5_2_1 Node5_2_2 7239999.999999999
R_5_2_1_2 Node5_2_1 Node5_3_1 7239999.999999999
R_5_2_1_3 Node5_2_1 Node6_2_1 18.5344
C_5_2_1 Node5_2_1 GND 3.416015625e-10
R_5_2_2_1 Node5_2_2 Node5_2_3 7239999.999999999
R_5_2_2_2 Node5_2_2 Node5_3_2 7239999.999999999
R_5_2_2_3 Node5_2_2 Node6_2_2 18.5344
C_5_2_2 Node5_2_2 GND 3.416015625e-10
R_5_2_3_1 Node5_2_3 Node5_2_4 7239999.999999999
R_5_2_3_2 Node5_2_3 Node5_3_3 7239999.999999999
R_5_2_3_3 Node5_2_3 Node6_2_3 18.5344
C_5_2_3 Node5_2_3 GND 3.416015625e-10
R_5_2_4_1 Node5_2_4 Node5_2_5 7239999.999999999
R_5_2_4_2 Node5_2_4 Node5_3_4 7239999.999999999
R_5_2_4_3 Node5_2_4 Node6_2_4 18.5344
C_5_2_4 Node5_2_4 GND 3.416015625e-10
R_5_2_5_1 Node5_2_5 Node5_2_6 7239999.999999999
R_5_2_5_2 Node5_2_5 Node5_3_5 7239999.999999999
R_5_2_5_3 Node5_2_5 Node6_2_5 18.5344
C_5_2_5 Node5_2_5 GND 3.416015625e-10
R_5_2_6_1 Node5_2_6 Node5_2_7 7239999.999999999
R_5_2_6_2 Node5_2_6 Node5_3_6 7239999.999999999
R_5_2_6_3 Node5_2_6 Node6_2_6 18.5344
C_5_2_6 Node5_2_6 GND 3.416015625e-10
R_5_2_7_1 Node5_2_7 Node5_2_8 7239999.999999999
R_5_2_7_2 Node5_2_7 Node5_3_7 7239999.999999999
R_5_2_7_3 Node5_2_7 Node6_2_7 18.5344
C_5_2_7 Node5_2_7 GND 3.416015625e-10
R_5_2_8_1 Node5_2_8 Node5_2_9 7239999.999999999
R_5_2_8_2 Node5_2_8 Node5_3_8 7239999.999999999
R_5_2_8_3 Node5_2_8 Node6_2_8 18.5344
C_5_2_8 Node5_2_8 GND 3.416015625e-10
R_5_2_9_1 Node5_2_9 Node5_2_10 7239999.999999999
R_5_2_9_2 Node5_2_9 Node5_3_9 7239999.999999999
R_5_2_9_3 Node5_2_9 Node6_2_9 18.5344
C_5_2_9 Node5_2_9 GND 3.416015625e-10
R_5_2_10_1 Node5_2_10 Node5_2_11 7239999.999999999
R_5_2_10_2 Node5_2_10 Node5_3_10 7239999.999999999
R_5_2_10_3 Node5_2_10 Node6_2_10 18.5344
C_5_2_10 Node5_2_10 GND 3.416015625e-10
R_5_2_11_1 Node5_2_11 Node5_2_12 7239999.999999999
R_5_2_11_2 Node5_2_11 Node5_3_11 7239999.999999999
R_5_2_11_3 Node5_2_11 Node6_2_11 18.5344
C_5_2_11 Node5_2_11 GND 3.416015625e-10
R_5_2_12_1 Node5_2_12 Node5_2_13 7239999.999999999
R_5_2_12_2 Node5_2_12 Node5_3_12 7239999.999999999
R_5_2_12_3 Node5_2_12 Node6_2_12 18.5344
C_5_2_12 Node5_2_12 GND 3.416015625e-10
R_5_2_13_1 Node5_2_13 Node5_2_14 7239999.999999999
R_5_2_13_2 Node5_2_13 Node5_3_13 7239999.999999999
R_5_2_13_3 Node5_2_13 Node6_2_13 18.5344
C_5_2_13 Node5_2_13 GND 3.416015625e-10
R_5_2_14_1 Node5_2_14 Node5_2_15 7239999.999999996
R_5_2_14_2 Node5_2_14 Node5_3_14 7239999.999999999
R_5_2_14_3 Node5_2_14 Node6_2_14 18.5344
C_5_2_14 Node5_2_14 GND 3.416015625e-10
R_5_2_15_2 Node5_2_15 Node5_3_15 7239999.999999993
R_5_2_15_3 Node5_2_15 Node6_2_15 18.534399999999987
C_5_2_15 Node5_2_15 GND 3.4160156250000033e-10
R_5_3_0_1 Node5_3_0 Node5_3_1 7239999.999999999
R_5_3_0_2 Node5_3_0 Node5_4_0 7239999.999999999
R_5_3_0_3 Node5_3_0 Node6_3_0 18.5344
C_5_3_0 Node5_3_0 GND 3.416015625e-10
R_5_3_1_1 Node5_3_1 Node5_3_2 7239999.999999999
R_5_3_1_2 Node5_3_1 Node5_4_1 7239999.999999999
R_5_3_1_3 Node5_3_1 Node6_3_1 18.5344
C_5_3_1 Node5_3_1 GND 3.416015625e-10
R_5_3_2_1 Node5_3_2 Node5_3_3 7239999.999999999
R_5_3_2_2 Node5_3_2 Node5_4_2 7239999.999999999
R_5_3_2_3 Node5_3_2 Node6_3_2 18.5344
C_5_3_2 Node5_3_2 GND 3.416015625e-10
R_5_3_3_1 Node5_3_3 Node5_3_4 7239999.999999999
R_5_3_3_2 Node5_3_3 Node5_4_3 7239999.999999999
R_5_3_3_3 Node5_3_3 Node6_3_3 18.5344
C_5_3_3 Node5_3_3 GND 3.416015625e-10
R_5_3_4_1 Node5_3_4 Node5_3_5 7239999.999999999
R_5_3_4_2 Node5_3_4 Node5_4_4 7239999.999999999
R_5_3_4_3 Node5_3_4 Node6_3_4 18.5344
C_5_3_4 Node5_3_4 GND 3.416015625e-10
R_5_3_5_1 Node5_3_5 Node5_3_6 7239999.999999999
R_5_3_5_2 Node5_3_5 Node5_4_5 7239999.999999999
R_5_3_5_3 Node5_3_5 Node6_3_5 18.5344
C_5_3_5 Node5_3_5 GND 3.416015625e-10
R_5_3_6_1 Node5_3_6 Node5_3_7 7239999.999999999
R_5_3_6_2 Node5_3_6 Node5_4_6 7239999.999999999
R_5_3_6_3 Node5_3_6 Node6_3_6 18.5344
C_5_3_6 Node5_3_6 GND 3.416015625e-10
R_5_3_7_1 Node5_3_7 Node5_3_8 7239999.999999999
R_5_3_7_2 Node5_3_7 Node5_4_7 7239999.999999999
R_5_3_7_3 Node5_3_7 Node6_3_7 18.5344
C_5_3_7 Node5_3_7 GND 3.416015625e-10
R_5_3_8_1 Node5_3_8 Node5_3_9 7239999.999999999
R_5_3_8_2 Node5_3_8 Node5_4_8 7239999.999999999
R_5_3_8_3 Node5_3_8 Node6_3_8 18.5344
C_5_3_8 Node5_3_8 GND 3.416015625e-10
R_5_3_9_1 Node5_3_9 Node5_3_10 7239999.999999999
R_5_3_9_2 Node5_3_9 Node5_4_9 7239999.999999999
R_5_3_9_3 Node5_3_9 Node6_3_9 18.5344
C_5_3_9 Node5_3_9 GND 3.416015625e-10
R_5_3_10_1 Node5_3_10 Node5_3_11 7239999.999999999
R_5_3_10_2 Node5_3_10 Node5_4_10 7239999.999999999
R_5_3_10_3 Node5_3_10 Node6_3_10 18.5344
C_5_3_10 Node5_3_10 GND 3.416015625e-10
R_5_3_11_1 Node5_3_11 Node5_3_12 7239999.999999999
R_5_3_11_2 Node5_3_11 Node5_4_11 7239999.999999999
R_5_3_11_3 Node5_3_11 Node6_3_11 18.5344
C_5_3_11 Node5_3_11 GND 3.416015625e-10
R_5_3_12_1 Node5_3_12 Node5_3_13 7239999.999999999
R_5_3_12_2 Node5_3_12 Node5_4_12 7239999.999999999
R_5_3_12_3 Node5_3_12 Node6_3_12 18.5344
C_5_3_12 Node5_3_12 GND 3.416015625e-10
R_5_3_13_1 Node5_3_13 Node5_3_14 7239999.999999999
R_5_3_13_2 Node5_3_13 Node5_4_13 7239999.999999999
R_5_3_13_3 Node5_3_13 Node6_3_13 18.5344
C_5_3_13 Node5_3_13 GND 3.416015625e-10
R_5_3_14_1 Node5_3_14 Node5_3_15 7239999.999999996
R_5_3_14_2 Node5_3_14 Node5_4_14 7239999.999999999
R_5_3_14_3 Node5_3_14 Node6_3_14 18.5344
C_5_3_14 Node5_3_14 GND 3.416015625e-10
R_5_3_15_2 Node5_3_15 Node5_4_15 7239999.999999993
R_5_3_15_3 Node5_3_15 Node6_3_15 18.534399999999987
C_5_3_15 Node5_3_15 GND 3.4160156250000033e-10
R_5_4_0_1 Node5_4_0 Node5_4_1 7239999.999999999
R_5_4_0_2 Node5_4_0 Node5_5_0 7239999.999999999
R_5_4_0_3 Node5_4_0 Node6_4_0 18.5344
C_5_4_0 Node5_4_0 GND 3.416015625e-10
R_5_4_1_1 Node5_4_1 Node5_4_2 7239999.999999999
R_5_4_1_2 Node5_4_1 Node5_5_1 7239999.999999999
R_5_4_1_3 Node5_4_1 Node6_4_1 18.5344
C_5_4_1 Node5_4_1 GND 3.416015625e-10
R_5_4_2_1 Node5_4_2 Node5_4_3 7239999.999999999
R_5_4_2_2 Node5_4_2 Node5_5_2 7239999.999999999
R_5_4_2_3 Node5_4_2 Node6_4_2 18.5344
C_5_4_2 Node5_4_2 GND 3.416015625e-10
R_5_4_3_1 Node5_4_3 Node5_4_4 7239999.999999999
R_5_4_3_2 Node5_4_3 Node5_5_3 7239999.999999999
R_5_4_3_3 Node5_4_3 Node6_4_3 18.5344
C_5_4_3 Node5_4_3 GND 3.416015625e-10
R_5_4_4_1 Node5_4_4 Node5_4_5 7239999.999999999
R_5_4_4_2 Node5_4_4 Node5_5_4 7239999.999999999
R_5_4_4_3 Node5_4_4 Node6_4_4 18.5344
C_5_4_4 Node5_4_4 GND 3.416015625e-10
R_5_4_5_1 Node5_4_5 Node5_4_6 7239999.999999999
R_5_4_5_2 Node5_4_5 Node5_5_5 7239999.999999999
R_5_4_5_3 Node5_4_5 Node6_4_5 18.5344
C_5_4_5 Node5_4_5 GND 3.416015625e-10
R_5_4_6_1 Node5_4_6 Node5_4_7 7239999.999999999
R_5_4_6_2 Node5_4_6 Node5_5_6 7239999.999999999
R_5_4_6_3 Node5_4_6 Node6_4_6 18.5344
C_5_4_6 Node5_4_6 GND 3.416015625e-10
R_5_4_7_1 Node5_4_7 Node5_4_8 7239999.999999999
R_5_4_7_2 Node5_4_7 Node5_5_7 7239999.999999999
R_5_4_7_3 Node5_4_7 Node6_4_7 18.5344
C_5_4_7 Node5_4_7 GND 3.416015625e-10
R_5_4_8_1 Node5_4_8 Node5_4_9 7239999.999999999
R_5_4_8_2 Node5_4_8 Node5_5_8 7239999.999999999
R_5_4_8_3 Node5_4_8 Node6_4_8 18.5344
C_5_4_8 Node5_4_8 GND 3.416015625e-10
R_5_4_9_1 Node5_4_9 Node5_4_10 7239999.999999999
R_5_4_9_2 Node5_4_9 Node5_5_9 7239999.999999999
R_5_4_9_3 Node5_4_9 Node6_4_9 18.5344
C_5_4_9 Node5_4_9 GND 3.416015625e-10
R_5_4_10_1 Node5_4_10 Node5_4_11 7239999.999999999
R_5_4_10_2 Node5_4_10 Node5_5_10 7239999.999999999
R_5_4_10_3 Node5_4_10 Node6_4_10 18.5344
C_5_4_10 Node5_4_10 GND 3.416015625e-10
R_5_4_11_1 Node5_4_11 Node5_4_12 7239999.999999999
R_5_4_11_2 Node5_4_11 Node5_5_11 7239999.999999999
R_5_4_11_3 Node5_4_11 Node6_4_11 18.5344
C_5_4_11 Node5_4_11 GND 3.416015625e-10
R_5_4_12_1 Node5_4_12 Node5_4_13 7239999.999999999
R_5_4_12_2 Node5_4_12 Node5_5_12 7239999.999999999
R_5_4_12_3 Node5_4_12 Node6_4_12 18.5344
C_5_4_12 Node5_4_12 GND 3.416015625e-10
R_5_4_13_1 Node5_4_13 Node5_4_14 7239999.999999999
R_5_4_13_2 Node5_4_13 Node5_5_13 7239999.999999999
R_5_4_13_3 Node5_4_13 Node6_4_13 18.5344
C_5_4_13 Node5_4_13 GND 3.416015625e-10
R_5_4_14_1 Node5_4_14 Node5_4_15 7239999.999999996
R_5_4_14_2 Node5_4_14 Node5_5_14 7239999.999999999
R_5_4_14_3 Node5_4_14 Node6_4_14 18.5344
C_5_4_14 Node5_4_14 GND 3.416015625e-10
R_5_4_15_2 Node5_4_15 Node5_5_15 7239999.999999993
R_5_4_15_3 Node5_4_15 Node6_4_15 18.534399999999987
C_5_4_15 Node5_4_15 GND 3.4160156250000033e-10
R_5_5_0_1 Node5_5_0 Node5_5_1 7239999.999999999
R_5_5_0_2 Node5_5_0 Node5_6_0 7239999.999999999
R_5_5_0_3 Node5_5_0 Node6_5_0 18.5344
C_5_5_0 Node5_5_0 GND 3.416015625e-10
R_5_5_1_1 Node5_5_1 Node5_5_2 7239999.999999999
R_5_5_1_2 Node5_5_1 Node5_6_1 7239999.999999999
R_5_5_1_3 Node5_5_1 Node6_5_1 18.5344
C_5_5_1 Node5_5_1 GND 3.416015625e-10
R_5_5_2_1 Node5_5_2 Node5_5_3 7239999.999999999
R_5_5_2_2 Node5_5_2 Node5_6_2 7239999.999999999
R_5_5_2_3 Node5_5_2 Node6_5_2 18.5344
C_5_5_2 Node5_5_2 GND 3.416015625e-10
R_5_5_3_1 Node5_5_3 Node5_5_4 7239999.999999999
R_5_5_3_2 Node5_5_3 Node5_6_3 7239999.999999999
R_5_5_3_3 Node5_5_3 Node6_5_3 18.5344
C_5_5_3 Node5_5_3 GND 3.416015625e-10
R_5_5_4_1 Node5_5_4 Node5_5_5 7239999.999999999
R_5_5_4_2 Node5_5_4 Node5_6_4 7239999.999999999
R_5_5_4_3 Node5_5_4 Node6_5_4 18.5344
C_5_5_4 Node5_5_4 GND 3.416015625e-10
R_5_5_5_1 Node5_5_5 Node5_5_6 7239999.999999999
R_5_5_5_2 Node5_5_5 Node5_6_5 7239999.999999999
R_5_5_5_3 Node5_5_5 Node6_5_5 18.5344
C_5_5_5 Node5_5_5 GND 3.416015625e-10
R_5_5_6_1 Node5_5_6 Node5_5_7 7239999.999999999
R_5_5_6_2 Node5_5_6 Node5_6_6 7239999.999999999
R_5_5_6_3 Node5_5_6 Node6_5_6 18.5344
C_5_5_6 Node5_5_6 GND 3.416015625e-10
R_5_5_7_1 Node5_5_7 Node5_5_8 7239999.999999999
R_5_5_7_2 Node5_5_7 Node5_6_7 7239999.999999999
R_5_5_7_3 Node5_5_7 Node6_5_7 18.5344
C_5_5_7 Node5_5_7 GND 3.416015625e-10
R_5_5_8_1 Node5_5_8 Node5_5_9 7239999.999999999
R_5_5_8_2 Node5_5_8 Node5_6_8 7239999.999999999
R_5_5_8_3 Node5_5_8 Node6_5_8 18.5344
C_5_5_8 Node5_5_8 GND 3.416015625e-10
R_5_5_9_1 Node5_5_9 Node5_5_10 7239999.999999999
R_5_5_9_2 Node5_5_9 Node5_6_9 7239999.999999997
R_5_5_9_3 Node5_5_9 Node6_5_9 18.5344
C_5_5_9 Node5_5_9 GND 3.416015625e-10
R_5_5_10_1 Node5_5_10 Node5_5_11 7239999.999999999
R_5_5_10_2 Node5_5_10 Node5_6_10 7239999.999999999
R_5_5_10_3 Node5_5_10 Node6_5_10 18.5344
C_5_5_10 Node5_5_10 GND 3.416015625e-10
R_5_5_11_1 Node5_5_11 Node5_5_12 7239999.999999999
R_5_5_11_2 Node5_5_11 Node5_6_11 7239999.999999999
R_5_5_11_3 Node5_5_11 Node6_5_11 18.5344
C_5_5_11 Node5_5_11 GND 3.416015625e-10
R_5_5_12_1 Node5_5_12 Node5_5_13 7239999.999999999
R_5_5_12_2 Node5_5_12 Node5_6_12 7239999.999999999
R_5_5_12_3 Node5_5_12 Node6_5_12 18.5344
C_5_5_12 Node5_5_12 GND 3.416015625e-10
R_5_5_13_1 Node5_5_13 Node5_5_14 7239999.999999999
R_5_5_13_2 Node5_5_13 Node5_6_13 7239999.999999999
R_5_5_13_3 Node5_5_13 Node6_5_13 18.5344
C_5_5_13 Node5_5_13 GND 3.416015625e-10
R_5_5_14_1 Node5_5_14 Node5_5_15 7239999.999999996
R_5_5_14_2 Node5_5_14 Node5_6_14 7239999.999999999
R_5_5_14_3 Node5_5_14 Node6_5_14 18.5344
C_5_5_14 Node5_5_14 GND 3.416015625e-10
R_5_5_15_2 Node5_5_15 Node5_6_15 7239999.999999993
R_5_5_15_3 Node5_5_15 Node6_5_15 18.534399999999987
C_5_5_15 Node5_5_15 GND 3.4160156250000033e-10
R_5_6_0_1 Node5_6_0 Node5_6_1 7239999.999999999
R_5_6_0_2 Node5_6_0 Node5_7_0 7239999.999999999
R_5_6_0_3 Node5_6_0 Node6_6_0 18.5344
C_5_6_0 Node5_6_0 GND 3.416015625e-10
R_5_6_1_1 Node5_6_1 Node5_6_2 7239999.999999999
R_5_6_1_2 Node5_6_1 Node5_7_1 7239999.999999999
R_5_6_1_3 Node5_6_1 Node6_6_1 18.5344
C_5_6_1 Node5_6_1 GND 3.416015625e-10
R_5_6_2_1 Node5_6_2 Node5_6_3 7239999.999999999
R_5_6_2_2 Node5_6_2 Node5_7_2 7239999.999999999
R_5_6_2_3 Node5_6_2 Node6_6_2 18.5344
C_5_6_2 Node5_6_2 GND 3.416015625e-10
R_5_6_3_1 Node5_6_3 Node5_6_4 7239999.999999999
R_5_6_3_2 Node5_6_3 Node5_7_3 7239999.999999999
R_5_6_3_3 Node5_6_3 Node6_6_3 18.5344
C_5_6_3 Node5_6_3 GND 3.416015625e-10
R_5_6_4_1 Node5_6_4 Node5_6_5 7239999.999999999
R_5_6_4_2 Node5_6_4 Node5_7_4 7239999.999999999
R_5_6_4_3 Node5_6_4 Node6_6_4 18.5344
C_5_6_4 Node5_6_4 GND 3.416015625e-10
R_5_6_5_1 Node5_6_5 Node5_6_6 7239999.999999999
R_5_6_5_2 Node5_6_5 Node5_7_5 7239999.999999999
R_5_6_5_3 Node5_6_5 Node6_6_5 18.5344
C_5_6_5 Node5_6_5 GND 3.416015625e-10
R_5_6_6_1 Node5_6_6 Node5_6_7 7239999.999999999
R_5_6_6_2 Node5_6_6 Node5_7_6 7239999.999999999
R_5_6_6_3 Node5_6_6 Node6_6_6 18.5344
C_5_6_6 Node5_6_6 GND 3.4160156250000007e-10
R_5_6_7_1 Node5_6_7 Node5_6_8 7239999.999999999
R_5_6_7_2 Node5_6_7 Node5_7_7 7239999.999999999
R_5_6_7_3 Node5_6_7 Node6_6_7 18.5344
C_5_6_7 Node5_6_7 GND 3.416015625e-10
R_5_6_8_1 Node5_6_8 Node5_6_9 7239999.999999997
R_5_6_8_2 Node5_6_8 Node5_7_8 7239999.999999999
R_5_6_8_3 Node5_6_8 Node6_6_8 18.5344
C_5_6_8 Node5_6_8 GND 3.416015625e-10
R_5_6_9_1 Node5_6_9 Node5_6_10 7239999.999999997
R_5_6_9_2 Node5_6_9 Node5_7_9 7239999.999999994
R_5_6_9_3 Node5_6_9 Node6_6_9 18.534399999999994
C_5_6_9 Node5_6_9 GND 3.4160156250000023e-10
R_5_6_10_1 Node5_6_10 Node5_6_11 7239999.999999999
R_5_6_10_2 Node5_6_10 Node5_7_10 7239999.999999999
R_5_6_10_3 Node5_6_10 Node6_6_10 18.5344
C_5_6_10 Node5_6_10 GND 3.416015625e-10
R_5_6_11_1 Node5_6_11 Node5_6_12 7239999.999999999
R_5_6_11_2 Node5_6_11 Node5_7_11 7239999.999999999
R_5_6_11_3 Node5_6_11 Node6_6_11 18.5344
C_5_6_11 Node5_6_11 GND 3.416015625e-10
R_5_6_12_1 Node5_6_12 Node5_6_13 7239999.999999999
R_5_6_12_2 Node5_6_12 Node5_7_12 7239999.999999999
R_5_6_12_3 Node5_6_12 Node6_6_12 18.5344
C_5_6_12 Node5_6_12 GND 3.416015625e-10
R_5_6_13_1 Node5_6_13 Node5_6_14 7239999.999999999
R_5_6_13_2 Node5_6_13 Node5_7_13 7239999.999999999
R_5_6_13_3 Node5_6_13 Node6_6_13 18.5344
C_5_6_13 Node5_6_13 GND 3.416015625e-10
R_5_6_14_1 Node5_6_14 Node5_6_15 7239999.999999996
R_5_6_14_2 Node5_6_14 Node5_7_14 7239999.999999999
R_5_6_14_3 Node5_6_14 Node6_6_14 18.5344
C_5_6_14 Node5_6_14 GND 3.416015625e-10
R_5_6_15_2 Node5_6_15 Node5_7_15 7239999.999999993
R_5_6_15_3 Node5_6_15 Node6_6_15 18.534399999999987
C_5_6_15 Node5_6_15 GND 3.4160156250000033e-10
R_5_7_0_1 Node5_7_0 Node5_7_1 7239999.999999999
R_5_7_0_2 Node5_7_0 Node5_8_0 7239999.999999999
R_5_7_0_3 Node5_7_0 Node6_7_0 18.5344
C_5_7_0 Node5_7_0 GND 3.416015625e-10
R_5_7_1_1 Node5_7_1 Node5_7_2 7239999.999999999
R_5_7_1_2 Node5_7_1 Node5_8_1 7239999.999999999
R_5_7_1_3 Node5_7_1 Node6_7_1 18.5344
C_5_7_1 Node5_7_1 GND 3.416015625e-10
R_5_7_2_1 Node5_7_2 Node5_7_3 7239999.999999999
R_5_7_2_2 Node5_7_2 Node5_8_2 7239999.999999999
R_5_7_2_3 Node5_7_2 Node6_7_2 18.5344
C_5_7_2 Node5_7_2 GND 3.416015625e-10
R_5_7_3_1 Node5_7_3 Node5_7_4 7239999.999999999
R_5_7_3_2 Node5_7_3 Node5_8_3 7239999.999999999
R_5_7_3_3 Node5_7_3 Node6_7_3 18.5344
C_5_7_3 Node5_7_3 GND 3.416015625e-10
R_5_7_4_1 Node5_7_4 Node5_7_5 7239999.999999999
R_5_7_4_2 Node5_7_4 Node5_8_4 7239999.999999999
R_5_7_4_3 Node5_7_4 Node6_7_4 18.5344
C_5_7_4 Node5_7_4 GND 3.416015625e-10
R_5_7_5_1 Node5_7_5 Node5_7_6 7239999.999999999
R_5_7_5_2 Node5_7_5 Node5_8_5 7239999.999999999
R_5_7_5_3 Node5_7_5 Node6_7_5 18.5344
C_5_7_5 Node5_7_5 GND 3.416015625e-10
R_5_7_6_1 Node5_7_6 Node5_7_7 7239999.999999999
R_5_7_6_2 Node5_7_6 Node5_8_6 7239999.999999999
R_5_7_6_3 Node5_7_6 Node6_7_6 18.5344
C_5_7_6 Node5_7_6 GND 3.416015625e-10
R_5_7_7_1 Node5_7_7 Node5_7_8 7239999.999999999
R_5_7_7_2 Node5_7_7 Node5_8_7 7239999.999999999
R_5_7_7_3 Node5_7_7 Node6_7_7 18.5344
C_5_7_7 Node5_7_7 GND 3.416015625e-10
R_5_7_8_1 Node5_7_8 Node5_7_9 7239999.999999996
R_5_7_8_2 Node5_7_8 Node5_8_8 7239999.999999999
R_5_7_8_3 Node5_7_8 Node6_7_8 18.5344
C_5_7_8 Node5_7_8 GND 3.416015625e-10
R_5_7_9_1 Node5_7_9 Node5_7_10 7239999.999999996
R_5_7_9_2 Node5_7_9 Node5_8_9 7239999.999999993
R_5_7_9_3 Node5_7_9 Node6_7_9 18.534399999999987
C_5_7_9 Node5_7_9 GND 3.4160156250000033e-10
R_5_7_10_1 Node5_7_10 Node5_7_11 7239999.999999999
R_5_7_10_2 Node5_7_10 Node5_8_10 7239999.999999999
R_5_7_10_3 Node5_7_10 Node6_7_10 18.5344
C_5_7_10 Node5_7_10 GND 3.416015625e-10
R_5_7_11_1 Node5_7_11 Node5_7_12 7239999.999999999
R_5_7_11_2 Node5_7_11 Node5_8_11 7239999.999999999
R_5_7_11_3 Node5_7_11 Node6_7_11 18.5344
C_5_7_11 Node5_7_11 GND 3.416015625e-10
R_5_7_12_1 Node5_7_12 Node5_7_13 7239999.999999999
R_5_7_12_2 Node5_7_12 Node5_8_12 7239999.999999999
R_5_7_12_3 Node5_7_12 Node6_7_12 18.5344
C_5_7_12 Node5_7_12 GND 3.416015625e-10
R_5_7_13_1 Node5_7_13 Node5_7_14 7239999.999999999
R_5_7_13_2 Node5_7_13 Node5_8_13 7239999.999999999
R_5_7_13_3 Node5_7_13 Node6_7_13 18.5344
C_5_7_13 Node5_7_13 GND 3.416015625e-10
R_5_7_14_1 Node5_7_14 Node5_7_15 7239999.999999996
R_5_7_14_2 Node5_7_14 Node5_8_14 7239999.999999999
R_5_7_14_3 Node5_7_14 Node6_7_14 18.5344
C_5_7_14 Node5_7_14 GND 3.416015625e-10
R_5_7_15_2 Node5_7_15 Node5_8_15 7239999.999999993
R_5_7_15_3 Node5_7_15 Node6_7_15 18.534399999999987
C_5_7_15 Node5_7_15 GND 3.4160156250000033e-10
R_5_8_0_1 Node5_8_0 Node5_8_1 7239999.999999999
R_5_8_0_2 Node5_8_0 Node5_9_0 7240000.000000002
R_5_8_0_3 Node5_8_0 Node6_8_0 18.5344
C_5_8_0 Node5_8_0 GND 3.416015625e-10
R_5_8_1_1 Node5_8_1 Node5_8_2 7239999.999999999
R_5_8_1_2 Node5_8_1 Node5_9_1 7240000.000000002
R_5_8_1_3 Node5_8_1 Node6_8_1 18.5344
C_5_8_1 Node5_8_1 GND 3.416015625e-10
R_5_8_2_1 Node5_8_2 Node5_8_3 7239999.999999999
R_5_8_2_2 Node5_8_2 Node5_9_2 7240000.000000002
R_5_8_2_3 Node5_8_2 Node6_8_2 18.5344
C_5_8_2 Node5_8_2 GND 3.416015625e-10
R_5_8_3_1 Node5_8_3 Node5_8_4 7239999.999999999
R_5_8_3_2 Node5_8_3 Node5_9_3 7240000.000000002
R_5_8_3_3 Node5_8_3 Node6_8_3 18.5344
C_5_8_3 Node5_8_3 GND 3.416015625e-10
R_5_8_4_1 Node5_8_4 Node5_8_5 7239999.999999999
R_5_8_4_2 Node5_8_4 Node5_9_4 7240000.000000002
R_5_8_4_3 Node5_8_4 Node6_8_4 18.5344
C_5_8_4 Node5_8_4 GND 3.416015625e-10
R_5_8_5_1 Node5_8_5 Node5_8_6 7239999.999999999
R_5_8_5_2 Node5_8_5 Node5_9_5 7240000.000000002
R_5_8_5_3 Node5_8_5 Node6_8_5 18.5344
C_5_8_5 Node5_8_5 GND 3.416015625e-10
R_5_8_6_1 Node5_8_6 Node5_8_7 7239999.999999999
R_5_8_6_2 Node5_8_6 Node5_9_6 7240000.000000002
R_5_8_6_3 Node5_8_6 Node6_8_6 18.5344
C_5_8_6 Node5_8_6 GND 3.416015625e-10
R_5_8_7_1 Node5_8_7 Node5_8_8 7239999.999999999
R_5_8_7_2 Node5_8_7 Node5_9_7 7240000.000000002
R_5_8_7_3 Node5_8_7 Node6_8_7 18.5344
C_5_8_7 Node5_8_7 GND 3.416015625e-10
R_5_8_8_1 Node5_8_8 Node5_8_9 7239999.999999996
R_5_8_8_2 Node5_8_8 Node5_9_8 7240000.000000002
R_5_8_8_3 Node5_8_8 Node6_8_8 18.5344
C_5_8_8 Node5_8_8 GND 3.416015625e-10
R_5_8_9_1 Node5_8_9 Node5_8_10 7239999.999999996
R_5_8_9_2 Node5_8_9 Node5_9_9 7239999.999999996
R_5_8_9_3 Node5_8_9 Node6_8_9 18.534399999999987
C_5_8_9 Node5_8_9 GND 3.4160156250000033e-10
R_5_8_10_1 Node5_8_10 Node5_8_11 7239999.999999999
R_5_8_10_2 Node5_8_10 Node5_9_10 7240000.000000002
R_5_8_10_3 Node5_8_10 Node6_8_10 18.5344
C_5_8_10 Node5_8_10 GND 3.416015625e-10
R_5_8_11_1 Node5_8_11 Node5_8_12 7239999.999999999
R_5_8_11_2 Node5_8_11 Node5_9_11 7240000.000000002
R_5_8_11_3 Node5_8_11 Node6_8_11 18.5344
C_5_8_11 Node5_8_11 GND 3.416015625e-10
R_5_8_12_1 Node5_8_12 Node5_8_13 7239999.999999999
R_5_8_12_2 Node5_8_12 Node5_9_12 7240000.000000002
R_5_8_12_3 Node5_8_12 Node6_8_12 18.5344
C_5_8_12 Node5_8_12 GND 3.416015625e-10
R_5_8_13_1 Node5_8_13 Node5_8_14 7239999.999999999
R_5_8_13_2 Node5_8_13 Node5_9_13 7240000.000000002
R_5_8_13_3 Node5_8_13 Node6_8_13 18.5344
C_5_8_13 Node5_8_13 GND 3.416015625e-10
R_5_8_14_1 Node5_8_14 Node5_8_15 7239999.999999996
R_5_8_14_2 Node5_8_14 Node5_9_14 7240000.000000002
R_5_8_14_3 Node5_8_14 Node6_8_14 18.5344
C_5_8_14 Node5_8_14 GND 3.416015625e-10
R_5_8_15_2 Node5_8_15 Node5_9_15 7239999.999999996
R_5_8_15_3 Node5_8_15 Node6_8_15 18.534399999999987
C_5_8_15 Node5_8_15 GND 3.4160156250000033e-10
R_5_9_0_1 Node5_9_0 Node5_9_1 7240000.000000005
R_5_9_0_2 Node5_9_0 Node5_10_0 7240000.000000002
R_5_9_0_3 Node5_9_0 Node6_9_0 18.534400000000016
C_5_9_0 Node5_9_0 GND 3.4160156249999976e-10
R_5_9_1_1 Node5_9_1 Node5_9_2 7240000.000000005
R_5_9_1_2 Node5_9_1 Node5_10_1 7240000.000000002
R_5_9_1_3 Node5_9_1 Node6_9_1 18.534400000000016
C_5_9_1 Node5_9_1 GND 3.416015624999997e-10
R_5_9_2_1 Node5_9_2 Node5_9_3 7240000.000000005
R_5_9_2_2 Node5_9_2 Node5_10_2 7240000.000000002
R_5_9_2_3 Node5_9_2 Node6_9_2 18.534400000000016
C_5_9_2 Node5_9_2 GND 3.416015624999997e-10
R_5_9_3_1 Node5_9_3 Node5_9_4 7240000.000000005
R_5_9_3_2 Node5_9_3 Node5_10_3 7240000.000000002
R_5_9_3_3 Node5_9_3 Node6_9_3 18.534400000000016
C_5_9_3 Node5_9_3 GND 3.416015624999997e-10
R_5_9_4_1 Node5_9_4 Node5_9_5 7240000.000000005
R_5_9_4_2 Node5_9_4 Node5_10_4 7240000.000000002
R_5_9_4_3 Node5_9_4 Node6_9_4 18.534400000000016
C_5_9_4 Node5_9_4 GND 3.416015624999997e-10
R_5_9_5_1 Node5_9_5 Node5_9_6 7240000.000000005
R_5_9_5_2 Node5_9_5 Node5_10_5 7240000.000000002
R_5_9_5_3 Node5_9_5 Node6_9_5 18.534400000000016
C_5_9_5 Node5_9_5 GND 3.416015624999997e-10
R_5_9_6_1 Node5_9_6 Node5_9_7 7240000.000000005
R_5_9_6_2 Node5_9_6 Node5_10_6 7240000.000000002
R_5_9_6_3 Node5_9_6 Node6_9_6 18.534400000000016
C_5_9_6 Node5_9_6 GND 3.416015624999997e-10
R_5_9_7_1 Node5_9_7 Node5_9_8 7240000.000000005
R_5_9_7_2 Node5_9_7 Node5_10_7 7240000.000000002
R_5_9_7_3 Node5_9_7 Node6_9_7 18.534400000000016
C_5_9_7 Node5_9_7 GND 3.416015624999997e-10
R_5_9_8_1 Node5_9_8 Node5_9_9 7240000.000000003
R_5_9_8_2 Node5_9_8 Node5_10_8 7240000.000000002
R_5_9_8_3 Node5_9_8 Node6_9_8 18.534400000000016
C_5_9_8 Node5_9_8 GND 3.416015624999997e-10
R_5_9_9_1 Node5_9_9 Node5_9_10 7240000.000000003
R_5_9_9_2 Node5_9_9 Node5_10_9 7240000.0
R_5_9_9_3 Node5_9_9 Node6_9_9 18.53440000000001
C_5_9_9 Node5_9_9 GND 3.416015624999999e-10
R_5_9_10_1 Node5_9_10 Node5_9_11 7240000.000000005
R_5_9_10_2 Node5_9_10 Node5_10_10 7240000.000000002
R_5_9_10_3 Node5_9_10 Node6_9_10 18.534400000000016
C_5_9_10 Node5_9_10 GND 3.416015624999997e-10
R_5_9_11_1 Node5_9_11 Node5_9_12 7240000.000000005
R_5_9_11_2 Node5_9_11 Node5_10_11 7240000.000000002
R_5_9_11_3 Node5_9_11 Node6_9_11 18.534400000000016
C_5_9_11 Node5_9_11 GND 3.416015624999997e-10
R_5_9_12_1 Node5_9_12 Node5_9_13 7240000.000000005
R_5_9_12_2 Node5_9_12 Node5_10_12 7240000.000000002
R_5_9_12_3 Node5_9_12 Node6_9_12 18.534400000000016
C_5_9_12 Node5_9_12 GND 3.416015624999997e-10
R_5_9_13_1 Node5_9_13 Node5_9_14 7240000.000000005
R_5_9_13_2 Node5_9_13 Node5_10_13 7240000.000000002
R_5_9_13_3 Node5_9_13 Node6_9_13 18.534400000000016
C_5_9_13 Node5_9_13 GND 3.416015624999997e-10
R_5_9_14_1 Node5_9_14 Node5_9_15 7240000.000000002
R_5_9_14_2 Node5_9_14 Node5_10_14 7240000.000000002
R_5_9_14_3 Node5_9_14 Node6_9_14 18.534400000000016
C_5_9_14 Node5_9_14 GND 3.416015624999997e-10
R_5_9_15_2 Node5_9_15 Node5_10_15 7239999.999999996
R_5_9_15_3 Node5_9_15 Node6_9_15 18.5344
C_5_9_15 Node5_9_15 GND 3.416015625e-10
R_5_10_0_1 Node5_10_0 Node5_10_1 7239999.999999999
R_5_10_0_2 Node5_10_0 Node5_11_0 7239999.999999999
R_5_10_0_3 Node5_10_0 Node6_10_0 18.5344
C_5_10_0 Node5_10_0 GND 3.416015625e-10
R_5_10_1_1 Node5_10_1 Node5_10_2 7239999.999999999
R_5_10_1_2 Node5_10_1 Node5_11_1 7239999.999999999
R_5_10_1_3 Node5_10_1 Node6_10_1 18.5344
C_5_10_1 Node5_10_1 GND 3.416015625e-10
R_5_10_2_1 Node5_10_2 Node5_10_3 7239999.999999999
R_5_10_2_2 Node5_10_2 Node5_11_2 7239999.999999999
R_5_10_2_3 Node5_10_2 Node6_10_2 18.5344
C_5_10_2 Node5_10_2 GND 3.416015625e-10
R_5_10_3_1 Node5_10_3 Node5_10_4 7239999.999999999
R_5_10_3_2 Node5_10_3 Node5_11_3 7239999.999999999
R_5_10_3_3 Node5_10_3 Node6_10_3 18.5344
C_5_10_3 Node5_10_3 GND 3.416015625e-10
R_5_10_4_1 Node5_10_4 Node5_10_5 7239999.999999999
R_5_10_4_2 Node5_10_4 Node5_11_4 7239999.999999999
R_5_10_4_3 Node5_10_4 Node6_10_4 18.5344
C_5_10_4 Node5_10_4 GND 3.416015625e-10
R_5_10_5_1 Node5_10_5 Node5_10_6 7239999.999999999
R_5_10_5_2 Node5_10_5 Node5_11_5 7239999.999999999
R_5_10_5_3 Node5_10_5 Node6_10_5 18.5344
C_5_10_5 Node5_10_5 GND 3.416015625e-10
R_5_10_6_1 Node5_10_6 Node5_10_7 7239999.999999999
R_5_10_6_2 Node5_10_6 Node5_11_6 7239999.999999999
R_5_10_6_3 Node5_10_6 Node6_10_6 18.5344
C_5_10_6 Node5_10_6 GND 3.416015625e-10
R_5_10_7_1 Node5_10_7 Node5_10_8 7239999.999999999
R_5_10_7_2 Node5_10_7 Node5_11_7 7239999.999999999
R_5_10_7_3 Node5_10_7 Node6_10_7 18.5344
C_5_10_7 Node5_10_7 GND 3.416015625e-10
R_5_10_8_1 Node5_10_8 Node5_10_9 7239999.999999999
R_5_10_8_2 Node5_10_8 Node5_11_8 7239999.999999999
R_5_10_8_3 Node5_10_8 Node6_10_8 18.5344
C_5_10_8 Node5_10_8 GND 3.416015625e-10
R_5_10_9_1 Node5_10_9 Node5_10_10 7239999.999999999
R_5_10_9_2 Node5_10_9 Node5_11_9 7239999.999999999
R_5_10_9_3 Node5_10_9 Node6_10_9 18.5344
C_5_10_9 Node5_10_9 GND 3.416015625e-10
R_5_10_10_1 Node5_10_10 Node5_10_11 7239999.999999999
R_5_10_10_2 Node5_10_10 Node5_11_10 7239999.999999999
R_5_10_10_3 Node5_10_10 Node6_10_10 18.5344
C_5_10_10 Node5_10_10 GND 3.416015625e-10
R_5_10_11_1 Node5_10_11 Node5_10_12 7239999.999999999
R_5_10_11_2 Node5_10_11 Node5_11_11 7239999.999999999
R_5_10_11_3 Node5_10_11 Node6_10_11 18.5344
C_5_10_11 Node5_10_11 GND 3.416015625e-10
R_5_10_12_1 Node5_10_12 Node5_10_13 7239999.999999999
R_5_10_12_2 Node5_10_12 Node5_11_12 7239999.999999999
R_5_10_12_3 Node5_10_12 Node6_10_12 18.5344
C_5_10_12 Node5_10_12 GND 3.416015625e-10
R_5_10_13_1 Node5_10_13 Node5_10_14 7239999.999999999
R_5_10_13_2 Node5_10_13 Node5_11_13 7239999.999999999
R_5_10_13_3 Node5_10_13 Node6_10_13 18.5344
C_5_10_13 Node5_10_13 GND 3.416015625e-10
R_5_10_14_1 Node5_10_14 Node5_10_15 7239999.999999996
R_5_10_14_2 Node5_10_14 Node5_11_14 7239999.999999999
R_5_10_14_3 Node5_10_14 Node6_10_14 18.5344
C_5_10_14 Node5_10_14 GND 3.416015625e-10
R_5_10_15_2 Node5_10_15 Node5_11_15 7239999.999999993
R_5_10_15_3 Node5_10_15 Node6_10_15 18.534399999999987
C_5_10_15 Node5_10_15 GND 3.4160156250000033e-10
R_5_11_0_1 Node5_11_0 Node5_11_1 7239999.999999999
R_5_11_0_2 Node5_11_0 Node5_12_0 7239999.999999999
R_5_11_0_3 Node5_11_0 Node6_11_0 18.5344
C_5_11_0 Node5_11_0 GND 3.416015625e-10
R_5_11_1_1 Node5_11_1 Node5_11_2 7239999.999999999
R_5_11_1_2 Node5_11_1 Node5_12_1 7239999.999999999
R_5_11_1_3 Node5_11_1 Node6_11_1 18.5344
C_5_11_1 Node5_11_1 GND 3.416015625e-10
R_5_11_2_1 Node5_11_2 Node5_11_3 7239999.999999999
R_5_11_2_2 Node5_11_2 Node5_12_2 7239999.999999999
R_5_11_2_3 Node5_11_2 Node6_11_2 18.5344
C_5_11_2 Node5_11_2 GND 3.416015625e-10
R_5_11_3_1 Node5_11_3 Node5_11_4 7239999.999999999
R_5_11_3_2 Node5_11_3 Node5_12_3 7239999.999999999
R_5_11_3_3 Node5_11_3 Node6_11_3 18.5344
C_5_11_3 Node5_11_3 GND 3.416015625e-10
R_5_11_4_1 Node5_11_4 Node5_11_5 7239999.999999999
R_5_11_4_2 Node5_11_4 Node5_12_4 7239999.999999999
R_5_11_4_3 Node5_11_4 Node6_11_4 18.5344
C_5_11_4 Node5_11_4 GND 3.416015625e-10
R_5_11_5_1 Node5_11_5 Node5_11_6 7239999.999999999
R_5_11_5_2 Node5_11_5 Node5_12_5 7239999.999999999
R_5_11_5_3 Node5_11_5 Node6_11_5 18.5344
C_5_11_5 Node5_11_5 GND 3.416015625e-10
R_5_11_6_1 Node5_11_6 Node5_11_7 7239999.999999999
R_5_11_6_2 Node5_11_6 Node5_12_6 7239999.999999999
R_5_11_6_3 Node5_11_6 Node6_11_6 18.5344
C_5_11_6 Node5_11_6 GND 3.416015625e-10
R_5_11_7_1 Node5_11_7 Node5_11_8 7239999.999999999
R_5_11_7_2 Node5_11_7 Node5_12_7 7239999.999999999
R_5_11_7_3 Node5_11_7 Node6_11_7 18.5344
C_5_11_7 Node5_11_7 GND 3.416015625e-10
R_5_11_8_1 Node5_11_8 Node5_11_9 7239999.999999999
R_5_11_8_2 Node5_11_8 Node5_12_8 7239999.999999999
R_5_11_8_3 Node5_11_8 Node6_11_8 18.5344
C_5_11_8 Node5_11_8 GND 3.416015625e-10
R_5_11_9_1 Node5_11_9 Node5_11_10 7239999.999999999
R_5_11_9_2 Node5_11_9 Node5_12_9 7239999.999999999
R_5_11_9_3 Node5_11_9 Node6_11_9 18.5344
C_5_11_9 Node5_11_9 GND 3.416015625e-10
R_5_11_10_1 Node5_11_10 Node5_11_11 7239999.999999999
R_5_11_10_2 Node5_11_10 Node5_12_10 7239999.999999999
R_5_11_10_3 Node5_11_10 Node6_11_10 18.5344
C_5_11_10 Node5_11_10 GND 3.416015625e-10
R_5_11_11_1 Node5_11_11 Node5_11_12 7239999.999999999
R_5_11_11_2 Node5_11_11 Node5_12_11 7239999.999999999
R_5_11_11_3 Node5_11_11 Node6_11_11 18.5344
C_5_11_11 Node5_11_11 GND 3.416015625e-10
R_5_11_12_1 Node5_11_12 Node5_11_13 7239999.999999999
R_5_11_12_2 Node5_11_12 Node5_12_12 7239999.999999999
R_5_11_12_3 Node5_11_12 Node6_11_12 18.5344
C_5_11_12 Node5_11_12 GND 3.416015625e-10
R_5_11_13_1 Node5_11_13 Node5_11_14 7239999.999999999
R_5_11_13_2 Node5_11_13 Node5_12_13 7239999.999999999
R_5_11_13_3 Node5_11_13 Node6_11_13 18.5344
C_5_11_13 Node5_11_13 GND 3.416015625e-10
R_5_11_14_1 Node5_11_14 Node5_11_15 7239999.999999996
R_5_11_14_2 Node5_11_14 Node5_12_14 7239999.999999999
R_5_11_14_3 Node5_11_14 Node6_11_14 18.5344
C_5_11_14 Node5_11_14 GND 3.416015625e-10
R_5_11_15_2 Node5_11_15 Node5_12_15 7239999.999999993
R_5_11_15_3 Node5_11_15 Node6_11_15 18.534399999999987
C_5_11_15 Node5_11_15 GND 3.4160156250000033e-10
R_5_12_0_1 Node5_12_0 Node5_12_1 7239999.999999999
R_5_12_0_2 Node5_12_0 Node5_13_0 7239999.999999999
R_5_12_0_3 Node5_12_0 Node6_12_0 18.5344
C_5_12_0 Node5_12_0 GND 3.416015625e-10
R_5_12_1_1 Node5_12_1 Node5_12_2 7239999.999999999
R_5_12_1_2 Node5_12_1 Node5_13_1 7239999.999999999
R_5_12_1_3 Node5_12_1 Node6_12_1 18.5344
C_5_12_1 Node5_12_1 GND 3.416015625e-10
R_5_12_2_1 Node5_12_2 Node5_12_3 7239999.999999999
R_5_12_2_2 Node5_12_2 Node5_13_2 7239999.999999999
R_5_12_2_3 Node5_12_2 Node6_12_2 18.5344
C_5_12_2 Node5_12_2 GND 3.416015625e-10
R_5_12_3_1 Node5_12_3 Node5_12_4 7239999.999999999
R_5_12_3_2 Node5_12_3 Node5_13_3 7239999.999999999
R_5_12_3_3 Node5_12_3 Node6_12_3 18.5344
C_5_12_3 Node5_12_3 GND 3.416015625e-10
R_5_12_4_1 Node5_12_4 Node5_12_5 7239999.999999999
R_5_12_4_2 Node5_12_4 Node5_13_4 7239999.999999999
R_5_12_4_3 Node5_12_4 Node6_12_4 18.5344
C_5_12_4 Node5_12_4 GND 3.416015625e-10
R_5_12_5_1 Node5_12_5 Node5_12_6 7239999.999999999
R_5_12_5_2 Node5_12_5 Node5_13_5 7239999.999999999
R_5_12_5_3 Node5_12_5 Node6_12_5 18.5344
C_5_12_5 Node5_12_5 GND 3.416015625e-10
R_5_12_6_1 Node5_12_6 Node5_12_7 7239999.999999999
R_5_12_6_2 Node5_12_6 Node5_13_6 7239999.999999999
R_5_12_6_3 Node5_12_6 Node6_12_6 18.5344
C_5_12_6 Node5_12_6 GND 3.416015625e-10
R_5_12_7_1 Node5_12_7 Node5_12_8 7239999.999999999
R_5_12_7_2 Node5_12_7 Node5_13_7 7239999.999999999
R_5_12_7_3 Node5_12_7 Node6_12_7 18.5344
C_5_12_7 Node5_12_7 GND 3.416015625e-10
R_5_12_8_1 Node5_12_8 Node5_12_9 7239999.999999999
R_5_12_8_2 Node5_12_8 Node5_13_8 7239999.999999999
R_5_12_8_3 Node5_12_8 Node6_12_8 18.5344
C_5_12_8 Node5_12_8 GND 3.416015625e-10
R_5_12_9_1 Node5_12_9 Node5_12_10 7239999.999999999
R_5_12_9_2 Node5_12_9 Node5_13_9 7239999.999999999
R_5_12_9_3 Node5_12_9 Node6_12_9 18.5344
C_5_12_9 Node5_12_9 GND 3.416015625e-10
R_5_12_10_1 Node5_12_10 Node5_12_11 7239999.999999999
R_5_12_10_2 Node5_12_10 Node5_13_10 7239999.999999999
R_5_12_10_3 Node5_12_10 Node6_12_10 18.5344
C_5_12_10 Node5_12_10 GND 3.416015625e-10
R_5_12_11_1 Node5_12_11 Node5_12_12 7239999.999999999
R_5_12_11_2 Node5_12_11 Node5_13_11 7239999.999999999
R_5_12_11_3 Node5_12_11 Node6_12_11 18.5344
C_5_12_11 Node5_12_11 GND 3.416015625e-10
R_5_12_12_1 Node5_12_12 Node5_12_13 7239999.999999999
R_5_12_12_2 Node5_12_12 Node5_13_12 7239999.999999999
R_5_12_12_3 Node5_12_12 Node6_12_12 18.5344
C_5_12_12 Node5_12_12 GND 3.416015625e-10
R_5_12_13_1 Node5_12_13 Node5_12_14 7239999.999999999
R_5_12_13_2 Node5_12_13 Node5_13_13 7239999.999999999
R_5_12_13_3 Node5_12_13 Node6_12_13 18.5344
C_5_12_13 Node5_12_13 GND 3.416015625e-10
R_5_12_14_1 Node5_12_14 Node5_12_15 7239999.999999996
R_5_12_14_2 Node5_12_14 Node5_13_14 7239999.999999999
R_5_12_14_3 Node5_12_14 Node6_12_14 18.5344
C_5_12_14 Node5_12_14 GND 3.416015625e-10
R_5_12_15_2 Node5_12_15 Node5_13_15 7239999.999999993
R_5_12_15_3 Node5_12_15 Node6_12_15 18.534399999999987
C_5_12_15 Node5_12_15 GND 3.4160156250000033e-10
R_5_13_0_1 Node5_13_0 Node5_13_1 7239999.999999999
R_5_13_0_2 Node5_13_0 Node5_14_0 7239999.999999999
R_5_13_0_3 Node5_13_0 Node6_13_0 18.5344
C_5_13_0 Node5_13_0 GND 3.416015625e-10
R_5_13_1_1 Node5_13_1 Node5_13_2 7239999.999999999
R_5_13_1_2 Node5_13_1 Node5_14_1 7239999.999999999
R_5_13_1_3 Node5_13_1 Node6_13_1 18.5344
C_5_13_1 Node5_13_1 GND 3.416015625e-10
R_5_13_2_1 Node5_13_2 Node5_13_3 7239999.999999999
R_5_13_2_2 Node5_13_2 Node5_14_2 7239999.999999999
R_5_13_2_3 Node5_13_2 Node6_13_2 18.5344
C_5_13_2 Node5_13_2 GND 3.416015625e-10
R_5_13_3_1 Node5_13_3 Node5_13_4 7239999.999999999
R_5_13_3_2 Node5_13_3 Node5_14_3 7239999.999999999
R_5_13_3_3 Node5_13_3 Node6_13_3 18.5344
C_5_13_3 Node5_13_3 GND 3.416015625e-10
R_5_13_4_1 Node5_13_4 Node5_13_5 7239999.999999999
R_5_13_4_2 Node5_13_4 Node5_14_4 7239999.999999999
R_5_13_4_3 Node5_13_4 Node6_13_4 18.5344
C_5_13_4 Node5_13_4 GND 3.416015625e-10
R_5_13_5_1 Node5_13_5 Node5_13_6 7239999.999999999
R_5_13_5_2 Node5_13_5 Node5_14_5 7239999.999999999
R_5_13_5_3 Node5_13_5 Node6_13_5 18.5344
C_5_13_5 Node5_13_5 GND 3.416015625e-10
R_5_13_6_1 Node5_13_6 Node5_13_7 7239999.999999999
R_5_13_6_2 Node5_13_6 Node5_14_6 7239999.999999999
R_5_13_6_3 Node5_13_6 Node6_13_6 18.5344
C_5_13_6 Node5_13_6 GND 3.416015625e-10
R_5_13_7_1 Node5_13_7 Node5_13_8 7239999.999999999
R_5_13_7_2 Node5_13_7 Node5_14_7 7239999.999999999
R_5_13_7_3 Node5_13_7 Node6_13_7 18.5344
C_5_13_7 Node5_13_7 GND 3.416015625e-10
R_5_13_8_1 Node5_13_8 Node5_13_9 7239999.999999999
R_5_13_8_2 Node5_13_8 Node5_14_8 7239999.999999999
R_5_13_8_3 Node5_13_8 Node6_13_8 18.5344
C_5_13_8 Node5_13_8 GND 3.416015625e-10
R_5_13_9_1 Node5_13_9 Node5_13_10 7239999.999999999
R_5_13_9_2 Node5_13_9 Node5_14_9 7239999.999999999
R_5_13_9_3 Node5_13_9 Node6_13_9 18.5344
C_5_13_9 Node5_13_9 GND 3.416015625e-10
R_5_13_10_1 Node5_13_10 Node5_13_11 7239999.999999999
R_5_13_10_2 Node5_13_10 Node5_14_10 7239999.999999999
R_5_13_10_3 Node5_13_10 Node6_13_10 18.5344
C_5_13_10 Node5_13_10 GND 3.416015625e-10
R_5_13_11_1 Node5_13_11 Node5_13_12 7239999.999999999
R_5_13_11_2 Node5_13_11 Node5_14_11 7239999.999999999
R_5_13_11_3 Node5_13_11 Node6_13_11 18.5344
C_5_13_11 Node5_13_11 GND 3.416015625e-10
R_5_13_12_1 Node5_13_12 Node5_13_13 7239999.999999999
R_5_13_12_2 Node5_13_12 Node5_14_12 7239999.999999999
R_5_13_12_3 Node5_13_12 Node6_13_12 18.5344
C_5_13_12 Node5_13_12 GND 3.416015625e-10
R_5_13_13_1 Node5_13_13 Node5_13_14 7239999.999999999
R_5_13_13_2 Node5_13_13 Node5_14_13 7239999.999999999
R_5_13_13_3 Node5_13_13 Node6_13_13 18.5344
C_5_13_13 Node5_13_13 GND 3.416015625e-10
R_5_13_14_1 Node5_13_14 Node5_13_15 7239999.999999996
R_5_13_14_2 Node5_13_14 Node5_14_14 7239999.999999999
R_5_13_14_3 Node5_13_14 Node6_13_14 18.5344
C_5_13_14 Node5_13_14 GND 3.416015625e-10
R_5_13_15_2 Node5_13_15 Node5_14_15 7239999.999999993
R_5_13_15_3 Node5_13_15 Node6_13_15 18.534399999999987
C_5_13_15 Node5_13_15 GND 3.4160156250000033e-10
R_5_14_0_1 Node5_14_0 Node5_14_1 7239999.999999999
R_5_14_0_2 Node5_14_0 Node5_15_0 7239999.999999999
R_5_14_0_3 Node5_14_0 Node6_14_0 18.5344
C_5_14_0 Node5_14_0 GND 3.416015625e-10
R_5_14_1_1 Node5_14_1 Node5_14_2 7239999.999999999
R_5_14_1_2 Node5_14_1 Node5_15_1 7239999.999999999
R_5_14_1_3 Node5_14_1 Node6_14_1 18.5344
C_5_14_1 Node5_14_1 GND 3.416015625e-10
R_5_14_2_1 Node5_14_2 Node5_14_3 7239999.999999999
R_5_14_2_2 Node5_14_2 Node5_15_2 7239999.999999999
R_5_14_2_3 Node5_14_2 Node6_14_2 18.5344
C_5_14_2 Node5_14_2 GND 3.416015625e-10
R_5_14_3_1 Node5_14_3 Node5_14_4 7239999.999999999
R_5_14_3_2 Node5_14_3 Node5_15_3 7239999.999999999
R_5_14_3_3 Node5_14_3 Node6_14_3 18.5344
C_5_14_3 Node5_14_3 GND 3.416015625e-10
R_5_14_4_1 Node5_14_4 Node5_14_5 7239999.999999999
R_5_14_4_2 Node5_14_4 Node5_15_4 7239999.999999999
R_5_14_4_3 Node5_14_4 Node6_14_4 18.5344
C_5_14_4 Node5_14_4 GND 3.416015625e-10
R_5_14_5_1 Node5_14_5 Node5_14_6 7239999.999999999
R_5_14_5_2 Node5_14_5 Node5_15_5 7239999.999999999
R_5_14_5_3 Node5_14_5 Node6_14_5 18.5344
C_5_14_5 Node5_14_5 GND 3.416015625e-10
R_5_14_6_1 Node5_14_6 Node5_14_7 7239999.999999999
R_5_14_6_2 Node5_14_6 Node5_15_6 7239999.999999999
R_5_14_6_3 Node5_14_6 Node6_14_6 18.5344
C_5_14_6 Node5_14_6 GND 3.416015625e-10
R_5_14_7_1 Node5_14_7 Node5_14_8 7239999.999999999
R_5_14_7_2 Node5_14_7 Node5_15_7 7239999.999999999
R_5_14_7_3 Node5_14_7 Node6_14_7 18.5344
C_5_14_7 Node5_14_7 GND 3.416015625e-10
R_5_14_8_1 Node5_14_8 Node5_14_9 7239999.999999999
R_5_14_8_2 Node5_14_8 Node5_15_8 7239999.999999999
R_5_14_8_3 Node5_14_8 Node6_14_8 18.5344
C_5_14_8 Node5_14_8 GND 3.416015625e-10
R_5_14_9_1 Node5_14_9 Node5_14_10 7239999.999999999
R_5_14_9_2 Node5_14_9 Node5_15_9 7239999.999999999
R_5_14_9_3 Node5_14_9 Node6_14_9 18.5344
C_5_14_9 Node5_14_9 GND 3.416015625e-10
R_5_14_10_1 Node5_14_10 Node5_14_11 7239999.999999999
R_5_14_10_2 Node5_14_10 Node5_15_10 7239999.999999999
R_5_14_10_3 Node5_14_10 Node6_14_10 18.5344
C_5_14_10 Node5_14_10 GND 3.416015625e-10
R_5_14_11_1 Node5_14_11 Node5_14_12 7239999.999999999
R_5_14_11_2 Node5_14_11 Node5_15_11 7239999.999999999
R_5_14_11_3 Node5_14_11 Node6_14_11 18.5344
C_5_14_11 Node5_14_11 GND 3.416015625e-10
R_5_14_12_1 Node5_14_12 Node5_14_13 7239999.999999999
R_5_14_12_2 Node5_14_12 Node5_15_12 7239999.999999999
R_5_14_12_3 Node5_14_12 Node6_14_12 18.5344
C_5_14_12 Node5_14_12 GND 3.416015625e-10
R_5_14_13_1 Node5_14_13 Node5_14_14 7239999.999999999
R_5_14_13_2 Node5_14_13 Node5_15_13 7239999.999999999
R_5_14_13_3 Node5_14_13 Node6_14_13 18.5344
C_5_14_13 Node5_14_13 GND 3.416015625e-10
R_5_14_14_1 Node5_14_14 Node5_14_15 7239999.999999996
R_5_14_14_2 Node5_14_14 Node5_15_14 7239999.999999999
R_5_14_14_3 Node5_14_14 Node6_14_14 18.5344
C_5_14_14 Node5_14_14 GND 3.416015625e-10
R_5_14_15_2 Node5_14_15 Node5_15_15 7239999.999999992
R_5_14_15_3 Node5_14_15 Node6_14_15 18.534399999999987
C_5_14_15 Node5_14_15 GND 3.4160156250000033e-10
R_5_15_0_1 Node5_15_0 Node5_15_1 7239999.999999999
R_5_15_0_3 Node5_15_0 Node6_15_0 18.5344
C_5_15_0 Node5_15_0 GND 3.416015625e-10
R_5_15_1_1 Node5_15_1 Node5_15_2 7239999.999999999
R_5_15_1_3 Node5_15_1 Node6_15_1 18.5344
C_5_15_1 Node5_15_1 GND 3.416015625e-10
R_5_15_2_1 Node5_15_2 Node5_15_3 7239999.999999999
R_5_15_2_3 Node5_15_2 Node6_15_2 18.5344
C_5_15_2 Node5_15_2 GND 3.416015625e-10
R_5_15_3_1 Node5_15_3 Node5_15_4 7239999.999999999
R_5_15_3_3 Node5_15_3 Node6_15_3 18.5344
C_5_15_3 Node5_15_3 GND 3.416015625e-10
R_5_15_4_1 Node5_15_4 Node5_15_5 7239999.999999999
R_5_15_4_3 Node5_15_4 Node6_15_4 18.5344
C_5_15_4 Node5_15_4 GND 3.416015625e-10
R_5_15_5_1 Node5_15_5 Node5_15_6 7239999.999999999
R_5_15_5_3 Node5_15_5 Node6_15_5 18.5344
C_5_15_5 Node5_15_5 GND 3.416015625e-10
R_5_15_6_1 Node5_15_6 Node5_15_7 7239999.999999999
R_5_15_6_3 Node5_15_6 Node6_15_6 18.5344
C_5_15_6 Node5_15_6 GND 3.416015625e-10
R_5_15_7_1 Node5_15_7 Node5_15_8 7239999.999999999
R_5_15_7_3 Node5_15_7 Node6_15_7 18.5344
C_5_15_7 Node5_15_7 GND 3.416015625e-10
R_5_15_8_1 Node5_15_8 Node5_15_9 7239999.999999999
R_5_15_8_3 Node5_15_8 Node6_15_8 18.5344
C_5_15_8 Node5_15_8 GND 3.416015625e-10
R_5_15_9_1 Node5_15_9 Node5_15_10 7239999.999999999
R_5_15_9_3 Node5_15_9 Node6_15_9 18.5344
C_5_15_9 Node5_15_9 GND 3.416015625e-10
R_5_15_10_1 Node5_15_10 Node5_15_11 7239999.999999999
R_5_15_10_3 Node5_15_10 Node6_15_10 18.5344
C_5_15_10 Node5_15_10 GND 3.416015625e-10
R_5_15_11_1 Node5_15_11 Node5_15_12 7239999.999999999
R_5_15_11_3 Node5_15_11 Node6_15_11 18.5344
C_5_15_11 Node5_15_11 GND 3.416015625e-10
R_5_15_12_1 Node5_15_12 Node5_15_13 7239999.999999999
R_5_15_12_3 Node5_15_12 Node6_15_12 18.5344
C_5_15_12 Node5_15_12 GND 3.416015625e-10
R_5_15_13_1 Node5_15_13 Node5_15_14 7239999.999999999
R_5_15_13_3 Node5_15_13 Node6_15_13 18.5344
C_5_15_13 Node5_15_13 GND 3.416015625e-10
R_5_15_14_1 Node5_15_14 Node5_15_15 7239999.999999994
R_5_15_14_3 Node5_15_14 Node6_15_14 18.5344
C_5_15_14 Node5_15_14 GND 3.416015625e-10
R_5_15_15_3 Node5_15_15 Node6_15_15 18.53439999999998
C_5_15_15 Node5_15_15 GND 3.416015625000004e-10
R_6_0_0_1 Node6_0_0 Node6_0_1 1407692.307692309
R_6_0_0_2 Node6_0_0 Node6_1_0 1407692.3076923084
R_6_0_0_3 Node6_0_0 Node7_0_0 6.090240000000006
C_6_0_0 Node6_0_0 GND 5.657437499999995e-16
R_6_0_1_1 Node6_0_1 Node6_0_2 1407692.307692309
R_6_0_1_2 Node6_0_1 Node6_1_1 1407692.3076923084
R_6_0_1_3 Node6_0_1 Node7_0_1 6.090240000000006
C_6_0_1 Node6_0_1 GND 5.657437499999995e-16
R_6_0_2_1 Node6_0_2 Node6_0_3 1407692.307692309
R_6_0_2_2 Node6_0_2 Node6_1_2 1407692.3076923084
R_6_0_2_3 Node6_0_2 Node7_0_2 6.090240000000006
C_6_0_2 Node6_0_2 GND 5.657437499999995e-16
R_6_0_3_1 Node6_0_3 Node6_0_4 1407692.307692309
R_6_0_3_2 Node6_0_3 Node6_1_3 1407692.3076923084
R_6_0_3_3 Node6_0_3 Node7_0_3 6.090240000000006
C_6_0_3 Node6_0_3 GND 5.657437499999995e-16
R_6_0_4_1 Node6_0_4 Node6_0_5 1407692.307692309
R_6_0_4_2 Node6_0_4 Node6_1_4 1407692.3076923084
R_6_0_4_3 Node6_0_4 Node7_0_4 6.090240000000006
C_6_0_4 Node6_0_4 GND 5.657437499999995e-16
R_6_0_5_1 Node6_0_5 Node6_0_6 1407692.307692309
R_6_0_5_2 Node6_0_5 Node6_1_5 1407692.3076923084
R_6_0_5_3 Node6_0_5 Node7_0_5 6.090240000000006
C_6_0_5 Node6_0_5 GND 5.657437499999995e-16
R_6_0_6_1 Node6_0_6 Node6_0_7 1407692.307692309
R_6_0_6_2 Node6_0_6 Node6_1_6 1407692.3076923084
R_6_0_6_3 Node6_0_6 Node7_0_6 6.090240000000006
C_6_0_6 Node6_0_6 GND 5.657437499999995e-16
R_6_0_7_1 Node6_0_7 Node6_0_8 1407692.307692309
R_6_0_7_2 Node6_0_7 Node6_1_7 1407692.3076923084
R_6_0_7_3 Node6_0_7 Node7_0_7 6.090240000000006
C_6_0_7 Node6_0_7 GND 5.657437499999995e-16
R_6_0_8_1 Node6_0_8 Node6_0_9 1407692.307692309
R_6_0_8_2 Node6_0_8 Node6_1_8 1407692.3076923084
R_6_0_8_3 Node6_0_8 Node7_0_8 6.090240000000006
C_6_0_8 Node6_0_8 GND 5.657437499999995e-16
R_6_0_9_1 Node6_0_9 Node6_0_10 1407692.307692309
R_6_0_9_2 Node6_0_9 Node6_1_9 1407692.3076923084
R_6_0_9_3 Node6_0_9 Node7_0_9 6.090240000000006
C_6_0_9 Node6_0_9 GND 5.657437499999995e-16
R_6_0_10_1 Node6_0_10 Node6_0_11 1407692.307692309
R_6_0_10_2 Node6_0_10 Node6_1_10 1407692.3076923084
R_6_0_10_3 Node6_0_10 Node7_0_10 6.090240000000006
C_6_0_10 Node6_0_10 GND 5.657437499999995e-16
R_6_0_11_1 Node6_0_11 Node6_0_12 1407692.307692309
R_6_0_11_2 Node6_0_11 Node6_1_11 1407692.3076923084
R_6_0_11_3 Node6_0_11 Node7_0_11 6.090240000000006
C_6_0_11 Node6_0_11 GND 5.657437499999995e-16
R_6_0_12_1 Node6_0_12 Node6_0_13 1407692.307692309
R_6_0_12_2 Node6_0_12 Node6_1_12 1407692.3076923084
R_6_0_12_3 Node6_0_12 Node7_0_12 6.090240000000006
C_6_0_12 Node6_0_12 GND 5.657437499999995e-16
R_6_0_13_1 Node6_0_13 Node6_0_14 1407692.307692309
R_6_0_13_2 Node6_0_13 Node6_1_13 1407692.3076923084
R_6_0_13_3 Node6_0_13 Node7_0_13 6.090240000000006
C_6_0_13 Node6_0_13 GND 5.657437499999995e-16
R_6_0_14_1 Node6_0_14 Node6_0_15 1407692.3076923084
R_6_0_14_2 Node6_0_14 Node6_1_14 1407692.3076923084
R_6_0_14_3 Node6_0_14 Node7_0_14 6.090240000000006
C_6_0_14 Node6_0_14 GND 5.657437499999995e-16
R_6_0_15_2 Node6_0_15 Node6_1_15 1407692.307692307
R_6_0_15_3 Node6_0_15 Node7_0_15 6.0902400000000005
C_6_0_15 Node6_0_15 GND 5.6574375e-16
R_6_1_0_1 Node6_1_0 Node6_1_1 1407692.3076923077
R_6_1_0_2 Node6_1_0 Node6_2_0 1407692.3076923077
R_6_1_0_3 Node6_1_0 Node7_1_0 6.0902400000000005
C_6_1_0 Node6_1_0 GND 5.6574375e-16
R_6_1_1_1 Node6_1_1 Node6_1_2 1407692.3076923077
R_6_1_1_2 Node6_1_1 Node6_2_1 1407692.3076923077
R_6_1_1_3 Node6_1_1 Node7_1_1 6.0902400000000005
C_6_1_1 Node6_1_1 GND 5.6574375e-16
R_6_1_2_1 Node6_1_2 Node6_1_3 1407692.3076923077
R_6_1_2_2 Node6_1_2 Node6_2_2 1407692.3076923077
R_6_1_2_3 Node6_1_2 Node7_1_2 6.0902400000000005
C_6_1_2 Node6_1_2 GND 5.6574375e-16
R_6_1_3_1 Node6_1_3 Node6_1_4 1407692.3076923077
R_6_1_3_2 Node6_1_3 Node6_2_3 1407692.3076923077
R_6_1_3_3 Node6_1_3 Node7_1_3 6.0902400000000005
C_6_1_3 Node6_1_3 GND 5.6574375e-16
R_6_1_4_1 Node6_1_4 Node6_1_5 1407692.3076923077
R_6_1_4_2 Node6_1_4 Node6_2_4 1407692.3076923077
R_6_1_4_3 Node6_1_4 Node7_1_4 6.0902400000000005
C_6_1_4 Node6_1_4 GND 5.6574375e-16
R_6_1_5_1 Node6_1_5 Node6_1_6 1407692.3076923077
R_6_1_5_2 Node6_1_5 Node6_2_5 1407692.3076923077
R_6_1_5_3 Node6_1_5 Node7_1_5 6.0902400000000005
C_6_1_5 Node6_1_5 GND 5.6574375e-16
R_6_1_6_1 Node6_1_6 Node6_1_7 1407692.3076923077
R_6_1_6_2 Node6_1_6 Node6_2_6 1407692.3076923077
R_6_1_6_3 Node6_1_6 Node7_1_6 6.0902400000000005
C_6_1_6 Node6_1_6 GND 5.6574375e-16
R_6_1_7_1 Node6_1_7 Node6_1_8 1407692.3076923077
R_6_1_7_2 Node6_1_7 Node6_2_7 1407692.3076923077
R_6_1_7_3 Node6_1_7 Node7_1_7 6.0902400000000005
C_6_1_7 Node6_1_7 GND 5.6574375e-16
R_6_1_8_1 Node6_1_8 Node6_1_9 1407692.3076923077
R_6_1_8_2 Node6_1_8 Node6_2_8 1407692.3076923077
R_6_1_8_3 Node6_1_8 Node7_1_8 6.0902400000000005
C_6_1_8 Node6_1_8 GND 5.6574375e-16
R_6_1_9_1 Node6_1_9 Node6_1_10 1407692.3076923077
R_6_1_9_2 Node6_1_9 Node6_2_9 1407692.3076923077
R_6_1_9_3 Node6_1_9 Node7_1_9 6.0902400000000005
C_6_1_9 Node6_1_9 GND 5.6574375e-16
R_6_1_10_1 Node6_1_10 Node6_1_11 1407692.3076923077
R_6_1_10_2 Node6_1_10 Node6_2_10 1407692.3076923077
R_6_1_10_3 Node6_1_10 Node7_1_10 6.0902400000000005
C_6_1_10 Node6_1_10 GND 5.6574375e-16
R_6_1_11_1 Node6_1_11 Node6_1_12 1407692.3076923077
R_6_1_11_2 Node6_1_11 Node6_2_11 1407692.3076923077
R_6_1_11_3 Node6_1_11 Node7_1_11 6.0902400000000005
C_6_1_11 Node6_1_11 GND 5.6574375e-16
R_6_1_12_1 Node6_1_12 Node6_1_13 1407692.3076923077
R_6_1_12_2 Node6_1_12 Node6_2_12 1407692.3076923077
R_6_1_12_3 Node6_1_12 Node7_1_12 6.0902400000000005
C_6_1_12 Node6_1_12 GND 5.6574375e-16
R_6_1_13_1 Node6_1_13 Node6_1_14 1407692.3076923077
R_6_1_13_2 Node6_1_13 Node6_2_13 1407692.3076923077
R_6_1_13_3 Node6_1_13 Node7_1_13 6.0902400000000005
C_6_1_13 Node6_1_13 GND 5.6574375e-16
R_6_1_14_1 Node6_1_14 Node6_1_15 1407692.307692307
R_6_1_14_2 Node6_1_14 Node6_2_14 1407692.3076923077
R_6_1_14_3 Node6_1_14 Node7_1_14 6.0902400000000005
C_6_1_14 Node6_1_14 GND 5.6574375e-16
R_6_1_15_2 Node6_1_15 Node6_2_15 1407692.3076923063
R_6_1_15_3 Node6_1_15 Node7_1_15 6.090239999999995
C_6_1_15 Node6_1_15 GND 5.657437500000005e-16
R_6_2_0_1 Node6_2_0 Node6_2_1 1407692.3076923077
R_6_2_0_2 Node6_2_0 Node6_3_0 1407692.3076923077
R_6_2_0_3 Node6_2_0 Node7_2_0 6.0902400000000005
C_6_2_0 Node6_2_0 GND 5.6574375e-16
R_6_2_1_1 Node6_2_1 Node6_2_2 1407692.3076923077
R_6_2_1_2 Node6_2_1 Node6_3_1 1407692.3076923077
R_6_2_1_3 Node6_2_1 Node7_2_1 6.0902400000000005
C_6_2_1 Node6_2_1 GND 5.6574375e-16
R_6_2_2_1 Node6_2_2 Node6_2_3 1407692.3076923077
R_6_2_2_2 Node6_2_2 Node6_3_2 1407692.3076923077
R_6_2_2_3 Node6_2_2 Node7_2_2 6.0902400000000005
C_6_2_2 Node6_2_2 GND 5.6574375e-16
R_6_2_3_1 Node6_2_3 Node6_2_4 1407692.3076923077
R_6_2_3_2 Node6_2_3 Node6_3_3 1407692.3076923077
R_6_2_3_3 Node6_2_3 Node7_2_3 6.0902400000000005
C_6_2_3 Node6_2_3 GND 5.6574375e-16
R_6_2_4_1 Node6_2_4 Node6_2_5 1407692.3076923077
R_6_2_4_2 Node6_2_4 Node6_3_4 1407692.3076923077
R_6_2_4_3 Node6_2_4 Node7_2_4 6.0902400000000005
C_6_2_4 Node6_2_4 GND 5.6574375e-16
R_6_2_5_1 Node6_2_5 Node6_2_6 1407692.3076923077
R_6_2_5_2 Node6_2_5 Node6_3_5 1407692.3076923077
R_6_2_5_3 Node6_2_5 Node7_2_5 6.0902400000000005
C_6_2_5 Node6_2_5 GND 5.6574375e-16
R_6_2_6_1 Node6_2_6 Node6_2_7 1407692.3076923077
R_6_2_6_2 Node6_2_6 Node6_3_6 1407692.3076923077
R_6_2_6_3 Node6_2_6 Node7_2_6 6.0902400000000005
C_6_2_6 Node6_2_6 GND 5.6574375e-16
R_6_2_7_1 Node6_2_7 Node6_2_8 1407692.3076923077
R_6_2_7_2 Node6_2_7 Node6_3_7 1407692.3076923077
R_6_2_7_3 Node6_2_7 Node7_2_7 6.0902400000000005
C_6_2_7 Node6_2_7 GND 5.6574375e-16
R_6_2_8_1 Node6_2_8 Node6_2_9 1407692.3076923077
R_6_2_8_2 Node6_2_8 Node6_3_8 1407692.3076923077
R_6_2_8_3 Node6_2_8 Node7_2_8 6.0902400000000005
C_6_2_8 Node6_2_8 GND 5.6574375e-16
R_6_2_9_1 Node6_2_9 Node6_2_10 1407692.3076923077
R_6_2_9_2 Node6_2_9 Node6_3_9 1407692.3076923077
R_6_2_9_3 Node6_2_9 Node7_2_9 6.0902400000000005
C_6_2_9 Node6_2_9 GND 5.6574375e-16
R_6_2_10_1 Node6_2_10 Node6_2_11 1407692.3076923077
R_6_2_10_2 Node6_2_10 Node6_3_10 1407692.3076923077
R_6_2_10_3 Node6_2_10 Node7_2_10 6.0902400000000005
C_6_2_10 Node6_2_10 GND 5.6574375e-16
R_6_2_11_1 Node6_2_11 Node6_2_12 1407692.3076923077
R_6_2_11_2 Node6_2_11 Node6_3_11 1407692.3076923077
R_6_2_11_3 Node6_2_11 Node7_2_11 6.0902400000000005
C_6_2_11 Node6_2_11 GND 5.6574375e-16
R_6_2_12_1 Node6_2_12 Node6_2_13 1407692.3076923077
R_6_2_12_2 Node6_2_12 Node6_3_12 1407692.3076923077
R_6_2_12_3 Node6_2_12 Node7_2_12 6.0902400000000005
C_6_2_12 Node6_2_12 GND 5.6574375e-16
R_6_2_13_1 Node6_2_13 Node6_2_14 1407692.3076923077
R_6_2_13_2 Node6_2_13 Node6_3_13 1407692.3076923077
R_6_2_13_3 Node6_2_13 Node7_2_13 6.0902400000000005
C_6_2_13 Node6_2_13 GND 5.6574375e-16
R_6_2_14_1 Node6_2_14 Node6_2_15 1407692.307692307
R_6_2_14_2 Node6_2_14 Node6_3_14 1407692.3076923077
R_6_2_14_3 Node6_2_14 Node7_2_14 6.0902400000000005
C_6_2_14 Node6_2_14 GND 5.6574375e-16
R_6_2_15_2 Node6_2_15 Node6_3_15 1407692.3076923063
R_6_2_15_3 Node6_2_15 Node7_2_15 6.090239999999995
C_6_2_15 Node6_2_15 GND 5.657437500000005e-16
R_6_3_0_1 Node6_3_0 Node6_3_1 1407692.3076923077
R_6_3_0_2 Node6_3_0 Node6_4_0 1407692.3076923077
R_6_3_0_3 Node6_3_0 Node7_3_0 6.0902400000000005
C_6_3_0 Node6_3_0 GND 5.6574375e-16
R_6_3_1_1 Node6_3_1 Node6_3_2 1407692.3076923077
R_6_3_1_2 Node6_3_1 Node6_4_1 1407692.3076923077
R_6_3_1_3 Node6_3_1 Node7_3_1 6.0902400000000005
C_6_3_1 Node6_3_1 GND 5.6574375e-16
R_6_3_2_1 Node6_3_2 Node6_3_3 1407692.3076923077
R_6_3_2_2 Node6_3_2 Node6_4_2 1407692.3076923077
R_6_3_2_3 Node6_3_2 Node7_3_2 6.0902400000000005
C_6_3_2 Node6_3_2 GND 5.6574375e-16
R_6_3_3_1 Node6_3_3 Node6_3_4 1407692.3076923077
R_6_3_3_2 Node6_3_3 Node6_4_3 1407692.3076923077
R_6_3_3_3 Node6_3_3 Node7_3_3 6.0902400000000005
C_6_3_3 Node6_3_3 GND 5.6574375e-16
R_6_3_4_1 Node6_3_4 Node6_3_5 1407692.3076923077
R_6_3_4_2 Node6_3_4 Node6_4_4 1407692.3076923077
R_6_3_4_3 Node6_3_4 Node7_3_4 6.0902400000000005
C_6_3_4 Node6_3_4 GND 5.6574375e-16
R_6_3_5_1 Node6_3_5 Node6_3_6 1407692.3076923077
R_6_3_5_2 Node6_3_5 Node6_4_5 1407692.3076923077
R_6_3_5_3 Node6_3_5 Node7_3_5 6.0902400000000005
C_6_3_5 Node6_3_5 GND 5.6574375e-16
R_6_3_6_1 Node6_3_6 Node6_3_7 1407692.3076923077
R_6_3_6_2 Node6_3_6 Node6_4_6 1407692.3076923077
R_6_3_6_3 Node6_3_6 Node7_3_6 6.0902400000000005
C_6_3_6 Node6_3_6 GND 5.6574375e-16
R_6_3_7_1 Node6_3_7 Node6_3_8 1407692.3076923077
R_6_3_7_2 Node6_3_7 Node6_4_7 1407692.3076923077
R_6_3_7_3 Node6_3_7 Node7_3_7 6.0902400000000005
C_6_3_7 Node6_3_7 GND 5.6574375e-16
R_6_3_8_1 Node6_3_8 Node6_3_9 1407692.3076923077
R_6_3_8_2 Node6_3_8 Node6_4_8 1407692.3076923077
R_6_3_8_3 Node6_3_8 Node7_3_8 6.0902400000000005
C_6_3_8 Node6_3_8 GND 5.6574375e-16
R_6_3_9_1 Node6_3_9 Node6_3_10 1407692.3076923077
R_6_3_9_2 Node6_3_9 Node6_4_9 1407692.3076923077
R_6_3_9_3 Node6_3_9 Node7_3_9 6.0902400000000005
C_6_3_9 Node6_3_9 GND 5.6574375e-16
R_6_3_10_1 Node6_3_10 Node6_3_11 1407692.3076923077
R_6_3_10_2 Node6_3_10 Node6_4_10 1407692.3076923077
R_6_3_10_3 Node6_3_10 Node7_3_10 6.0902400000000005
C_6_3_10 Node6_3_10 GND 5.6574375e-16
R_6_3_11_1 Node6_3_11 Node6_3_12 1407692.3076923077
R_6_3_11_2 Node6_3_11 Node6_4_11 1407692.3076923077
R_6_3_11_3 Node6_3_11 Node7_3_11 6.0902400000000005
C_6_3_11 Node6_3_11 GND 5.6574375e-16
R_6_3_12_1 Node6_3_12 Node6_3_13 1407692.3076923077
R_6_3_12_2 Node6_3_12 Node6_4_12 1407692.3076923077
R_6_3_12_3 Node6_3_12 Node7_3_12 6.0902400000000005
C_6_3_12 Node6_3_12 GND 5.6574375e-16
R_6_3_13_1 Node6_3_13 Node6_3_14 1407692.3076923077
R_6_3_13_2 Node6_3_13 Node6_4_13 1407692.3076923077
R_6_3_13_3 Node6_3_13 Node7_3_13 6.0902400000000005
C_6_3_13 Node6_3_13 GND 5.6574375e-16
R_6_3_14_1 Node6_3_14 Node6_3_15 1407692.307692307
R_6_3_14_2 Node6_3_14 Node6_4_14 1407692.3076923077
R_6_3_14_3 Node6_3_14 Node7_3_14 6.0902400000000005
C_6_3_14 Node6_3_14 GND 5.6574375e-16
R_6_3_15_2 Node6_3_15 Node6_4_15 1407692.3076923063
R_6_3_15_3 Node6_3_15 Node7_3_15 6.090239999999995
C_6_3_15 Node6_3_15 GND 5.657437500000005e-16
R_6_4_0_1 Node6_4_0 Node6_4_1 1407692.3076923077
R_6_4_0_2 Node6_4_0 Node6_5_0 1407692.3076923077
R_6_4_0_3 Node6_4_0 Node7_4_0 6.0902400000000005
C_6_4_0 Node6_4_0 GND 5.6574375e-16
R_6_4_1_1 Node6_4_1 Node6_4_2 1407692.3076923077
R_6_4_1_2 Node6_4_1 Node6_5_1 1407692.3076923077
R_6_4_1_3 Node6_4_1 Node7_4_1 6.0902400000000005
C_6_4_1 Node6_4_1 GND 5.6574375e-16
R_6_4_2_1 Node6_4_2 Node6_4_3 1407692.3076923077
R_6_4_2_2 Node6_4_2 Node6_5_2 1407692.3076923077
R_6_4_2_3 Node6_4_2 Node7_4_2 6.0902400000000005
C_6_4_2 Node6_4_2 GND 5.6574375e-16
R_6_4_3_1 Node6_4_3 Node6_4_4 1407692.3076923077
R_6_4_3_2 Node6_4_3 Node6_5_3 1407692.3076923077
R_6_4_3_3 Node6_4_3 Node7_4_3 6.0902400000000005
C_6_4_3 Node6_4_3 GND 5.6574375e-16
R_6_4_4_1 Node6_4_4 Node6_4_5 1407692.3076923077
R_6_4_4_2 Node6_4_4 Node6_5_4 1407692.3076923077
R_6_4_4_3 Node6_4_4 Node7_4_4 6.0902400000000005
C_6_4_4 Node6_4_4 GND 5.6574375e-16
R_6_4_5_1 Node6_4_5 Node6_4_6 1407692.3076923077
R_6_4_5_2 Node6_4_5 Node6_5_5 1407692.3076923077
R_6_4_5_3 Node6_4_5 Node7_4_5 6.0902400000000005
C_6_4_5 Node6_4_5 GND 5.6574375e-16
R_6_4_6_1 Node6_4_6 Node6_4_7 1407692.3076923077
R_6_4_6_2 Node6_4_6 Node6_5_6 1407692.3076923077
R_6_4_6_3 Node6_4_6 Node7_4_6 6.0902400000000005
C_6_4_6 Node6_4_6 GND 5.6574375e-16
R_6_4_7_1 Node6_4_7 Node6_4_8 1407692.3076923077
R_6_4_7_2 Node6_4_7 Node6_5_7 1407692.3076923077
R_6_4_7_3 Node6_4_7 Node7_4_7 6.0902400000000005
C_6_4_7 Node6_4_7 GND 5.6574375e-16
R_6_4_8_1 Node6_4_8 Node6_4_9 1407692.3076923077
R_6_4_8_2 Node6_4_8 Node6_5_8 1407692.3076923077
R_6_4_8_3 Node6_4_8 Node7_4_8 6.0902400000000005
C_6_4_8 Node6_4_8 GND 5.6574375e-16
R_6_4_9_1 Node6_4_9 Node6_4_10 1407692.3076923077
R_6_4_9_2 Node6_4_9 Node6_5_9 1407692.3076923077
R_6_4_9_3 Node6_4_9 Node7_4_9 6.0902400000000005
C_6_4_9 Node6_4_9 GND 5.6574375e-16
R_6_4_10_1 Node6_4_10 Node6_4_11 1407692.3076923077
R_6_4_10_2 Node6_4_10 Node6_5_10 1407692.3076923077
R_6_4_10_3 Node6_4_10 Node7_4_10 6.0902400000000005
C_6_4_10 Node6_4_10 GND 5.6574375e-16
R_6_4_11_1 Node6_4_11 Node6_4_12 1407692.3076923077
R_6_4_11_2 Node6_4_11 Node6_5_11 1407692.3076923077
R_6_4_11_3 Node6_4_11 Node7_4_11 6.0902400000000005
C_6_4_11 Node6_4_11 GND 5.6574375e-16
R_6_4_12_1 Node6_4_12 Node6_4_13 1407692.3076923077
R_6_4_12_2 Node6_4_12 Node6_5_12 1407692.3076923077
R_6_4_12_3 Node6_4_12 Node7_4_12 6.0902400000000005
C_6_4_12 Node6_4_12 GND 5.6574375e-16
R_6_4_13_1 Node6_4_13 Node6_4_14 1407692.3076923077
R_6_4_13_2 Node6_4_13 Node6_5_13 1407692.3076923077
R_6_4_13_3 Node6_4_13 Node7_4_13 6.0902400000000005
C_6_4_13 Node6_4_13 GND 5.6574375e-16
R_6_4_14_1 Node6_4_14 Node6_4_15 1407692.307692307
R_6_4_14_2 Node6_4_14 Node6_5_14 1407692.3076923077
R_6_4_14_3 Node6_4_14 Node7_4_14 6.0902400000000005
C_6_4_14 Node6_4_14 GND 5.6574375e-16
R_6_4_15_2 Node6_4_15 Node6_5_15 1407692.3076923063
R_6_4_15_3 Node6_4_15 Node7_4_15 6.090239999999995
C_6_4_15 Node6_4_15 GND 5.657437500000005e-16
R_6_5_0_1 Node6_5_0 Node6_5_1 1407692.3076923077
R_6_5_0_2 Node6_5_0 Node6_6_0 1407692.3076923077
R_6_5_0_3 Node6_5_0 Node7_5_0 6.0902400000000005
C_6_5_0 Node6_5_0 GND 5.6574375e-16
R_6_5_1_1 Node6_5_1 Node6_5_2 1407692.3076923077
R_6_5_1_2 Node6_5_1 Node6_6_1 1407692.3076923077
R_6_5_1_3 Node6_5_1 Node7_5_1 6.0902400000000005
C_6_5_1 Node6_5_1 GND 5.6574375e-16
R_6_5_2_1 Node6_5_2 Node6_5_3 1407692.3076923077
R_6_5_2_2 Node6_5_2 Node6_6_2 1407692.3076923077
R_6_5_2_3 Node6_5_2 Node7_5_2 6.0902400000000005
C_6_5_2 Node6_5_2 GND 5.6574375e-16
R_6_5_3_1 Node6_5_3 Node6_5_4 1407692.3076923077
R_6_5_3_2 Node6_5_3 Node6_6_3 1407692.3076923077
R_6_5_3_3 Node6_5_3 Node7_5_3 6.0902400000000005
C_6_5_3 Node6_5_3 GND 5.6574375e-16
R_6_5_4_1 Node6_5_4 Node6_5_5 1407692.3076923077
R_6_5_4_2 Node6_5_4 Node6_6_4 1407692.3076923077
R_6_5_4_3 Node6_5_4 Node7_5_4 6.0902400000000005
C_6_5_4 Node6_5_4 GND 5.6574375e-16
R_6_5_5_1 Node6_5_5 Node6_5_6 1407692.3076923077
R_6_5_5_2 Node6_5_5 Node6_6_5 1407692.3076923077
R_6_5_5_3 Node6_5_5 Node7_5_5 6.0902400000000005
C_6_5_5 Node6_5_5 GND 5.6574375e-16
R_6_5_6_1 Node6_5_6 Node6_5_7 1407692.3076923077
R_6_5_6_2 Node6_5_6 Node6_6_6 1407692.3076923077
R_6_5_6_3 Node6_5_6 Node7_5_6 6.0902400000000005
C_6_5_6 Node6_5_6 GND 5.6574375e-16
R_6_5_7_1 Node6_5_7 Node6_5_8 1407692.3076923077
R_6_5_7_2 Node6_5_7 Node6_6_7 1407692.3076923077
R_6_5_7_3 Node6_5_7 Node7_5_7 6.0902400000000005
C_6_5_7 Node6_5_7 GND 5.6574375e-16
R_6_5_8_1 Node6_5_8 Node6_5_9 1407692.3076923077
R_6_5_8_2 Node6_5_8 Node6_6_8 1407692.3076923077
R_6_5_8_3 Node6_5_8 Node7_5_8 6.0902400000000005
C_6_5_8 Node6_5_8 GND 5.6574375e-16
R_6_5_9_1 Node6_5_9 Node6_5_10 1407692.3076923077
R_6_5_9_2 Node6_5_9 Node6_6_9 1407692.3076923073
R_6_5_9_3 Node6_5_9 Node7_5_9 6.0902400000000005
C_6_5_9 Node6_5_9 GND 5.6574375e-16
R_6_5_10_1 Node6_5_10 Node6_5_11 1407692.3076923077
R_6_5_10_2 Node6_5_10 Node6_6_10 1407692.3076923077
R_6_5_10_3 Node6_5_10 Node7_5_10 6.0902400000000005
C_6_5_10 Node6_5_10 GND 5.6574375e-16
R_6_5_11_1 Node6_5_11 Node6_5_12 1407692.3076923077
R_6_5_11_2 Node6_5_11 Node6_6_11 1407692.3076923077
R_6_5_11_3 Node6_5_11 Node7_5_11 6.0902400000000005
C_6_5_11 Node6_5_11 GND 5.6574375e-16
R_6_5_12_1 Node6_5_12 Node6_5_13 1407692.3076923077
R_6_5_12_2 Node6_5_12 Node6_6_12 1407692.3076923077
R_6_5_12_3 Node6_5_12 Node7_5_12 6.0902400000000005
C_6_5_12 Node6_5_12 GND 5.6574375e-16
R_6_5_13_1 Node6_5_13 Node6_5_14 1407692.3076923077
R_6_5_13_2 Node6_5_13 Node6_6_13 1407692.3076923077
R_6_5_13_3 Node6_5_13 Node7_5_13 6.0902400000000005
C_6_5_13 Node6_5_13 GND 5.6574375e-16
R_6_5_14_1 Node6_5_14 Node6_5_15 1407692.307692307
R_6_5_14_2 Node6_5_14 Node6_6_14 1407692.3076923077
R_6_5_14_3 Node6_5_14 Node7_5_14 6.0902400000000005
C_6_5_14 Node6_5_14 GND 5.6574375e-16
R_6_5_15_2 Node6_5_15 Node6_6_15 1407692.3076923063
R_6_5_15_3 Node6_5_15 Node7_5_15 6.090239999999995
C_6_5_15 Node6_5_15 GND 5.657437500000005e-16
R_6_6_0_1 Node6_6_0 Node6_6_1 1407692.3076923077
R_6_6_0_2 Node6_6_0 Node6_7_0 1407692.3076923077
R_6_6_0_3 Node6_6_0 Node7_6_0 6.09024
C_6_6_0 Node6_6_0 GND 5.6574375e-16
R_6_6_1_1 Node6_6_1 Node6_6_2 1407692.3076923077
R_6_6_1_2 Node6_6_1 Node6_7_1 1407692.3076923077
R_6_6_1_3 Node6_6_1 Node7_6_1 6.0902400000000005
C_6_6_1 Node6_6_1 GND 5.6574375e-16
R_6_6_2_1 Node6_6_2 Node6_6_3 1407692.3076923077
R_6_6_2_2 Node6_6_2 Node6_7_2 1407692.3076923077
R_6_6_2_3 Node6_6_2 Node7_6_2 6.0902400000000005
C_6_6_2 Node6_6_2 GND 5.6574375e-16
R_6_6_3_1 Node6_6_3 Node6_6_4 1407692.3076923077
R_6_6_3_2 Node6_6_3 Node6_7_3 1407692.3076923077
R_6_6_3_3 Node6_6_3 Node7_6_3 6.0902400000000005
C_6_6_3 Node6_6_3 GND 5.6574375e-16
R_6_6_4_1 Node6_6_4 Node6_6_5 1407692.3076923077
R_6_6_4_2 Node6_6_4 Node6_7_4 1407692.3076923077
R_6_6_4_3 Node6_6_4 Node7_6_4 6.0902400000000005
C_6_6_4 Node6_6_4 GND 5.6574375e-16
R_6_6_5_1 Node6_6_5 Node6_6_6 1407692.3076923077
R_6_6_5_2 Node6_6_5 Node6_7_5 1407692.3076923077
R_6_6_5_3 Node6_6_5 Node7_6_5 6.0902400000000005
C_6_6_5 Node6_6_5 GND 5.6574375e-16
R_6_6_6_1 Node6_6_6 Node6_6_7 1407692.3076923077
R_6_6_6_2 Node6_6_6 Node6_7_6 1407692.3076923077
R_6_6_6_3 Node6_6_6 Node7_6_6 6.09024
C_6_6_6 Node6_6_6 GND 5.657437500000001e-16
R_6_6_7_1 Node6_6_7 Node6_6_8 1407692.3076923077
R_6_6_7_2 Node6_6_7 Node6_7_7 1407692.3076923077
R_6_6_7_3 Node6_6_7 Node7_6_7 6.0902400000000005
C_6_6_7 Node6_6_7 GND 5.6574375e-16
R_6_6_8_1 Node6_6_8 Node6_6_9 1407692.3076923073
R_6_6_8_2 Node6_6_8 Node6_7_8 1407692.3076923077
R_6_6_8_3 Node6_6_8 Node7_6_8 6.0902400000000005
C_6_6_8 Node6_6_8 GND 5.6574375e-16
R_6_6_9_1 Node6_6_9 Node6_6_10 1407692.3076923073
R_6_6_9_2 Node6_6_9 Node6_7_9 1407692.3076923066
R_6_6_9_3 Node6_6_9 Node7_6_9 6.090239999999998
C_6_6_9 Node6_6_9 GND 5.657437500000003e-16
R_6_6_10_1 Node6_6_10 Node6_6_11 1407692.3076923077
R_6_6_10_2 Node6_6_10 Node6_7_10 1407692.3076923077
R_6_6_10_3 Node6_6_10 Node7_6_10 6.0902400000000005
C_6_6_10 Node6_6_10 GND 5.6574375e-16
R_6_6_11_1 Node6_6_11 Node6_6_12 1407692.3076923077
R_6_6_11_2 Node6_6_11 Node6_7_11 1407692.3076923077
R_6_6_11_3 Node6_6_11 Node7_6_11 6.0902400000000005
C_6_6_11 Node6_6_11 GND 5.6574375e-16
R_6_6_12_1 Node6_6_12 Node6_6_13 1407692.3076923077
R_6_6_12_2 Node6_6_12 Node6_7_12 1407692.3076923077
R_6_6_12_3 Node6_6_12 Node7_6_12 6.0902400000000005
C_6_6_12 Node6_6_12 GND 5.6574375e-16
R_6_6_13_1 Node6_6_13 Node6_6_14 1407692.3076923077
R_6_6_13_2 Node6_6_13 Node6_7_13 1407692.3076923077
R_6_6_13_3 Node6_6_13 Node7_6_13 6.0902400000000005
C_6_6_13 Node6_6_13 GND 5.6574375e-16
R_6_6_14_1 Node6_6_14 Node6_6_15 1407692.307692307
R_6_6_14_2 Node6_6_14 Node6_7_14 1407692.3076923077
R_6_6_14_3 Node6_6_14 Node7_6_14 6.0902400000000005
C_6_6_14 Node6_6_14 GND 5.6574375e-16
R_6_6_15_2 Node6_6_15 Node6_7_15 1407692.3076923063
R_6_6_15_3 Node6_6_15 Node7_6_15 6.090239999999995
C_6_6_15 Node6_6_15 GND 5.657437500000005e-16
R_6_7_0_1 Node6_7_0 Node6_7_1 1407692.3076923077
R_6_7_0_2 Node6_7_0 Node6_8_0 1407692.3076923077
R_6_7_0_3 Node6_7_0 Node7_7_0 6.0902400000000005
C_6_7_0 Node6_7_0 GND 5.6574375e-16
R_6_7_1_1 Node6_7_1 Node6_7_2 1407692.3076923077
R_6_7_1_2 Node6_7_1 Node6_8_1 1407692.3076923077
R_6_7_1_3 Node6_7_1 Node7_7_1 6.0902400000000005
C_6_7_1 Node6_7_1 GND 5.6574375e-16
R_6_7_2_1 Node6_7_2 Node6_7_3 1407692.3076923077
R_6_7_2_2 Node6_7_2 Node6_8_2 1407692.3076923077
R_6_7_2_3 Node6_7_2 Node7_7_2 6.0902400000000005
C_6_7_2 Node6_7_2 GND 5.6574375e-16
R_6_7_3_1 Node6_7_3 Node6_7_4 1407692.3076923077
R_6_7_3_2 Node6_7_3 Node6_8_3 1407692.3076923077
R_6_7_3_3 Node6_7_3 Node7_7_3 6.0902400000000005
C_6_7_3 Node6_7_3 GND 5.6574375e-16
R_6_7_4_1 Node6_7_4 Node6_7_5 1407692.3076923077
R_6_7_4_2 Node6_7_4 Node6_8_4 1407692.3076923077
R_6_7_4_3 Node6_7_4 Node7_7_4 6.0902400000000005
C_6_7_4 Node6_7_4 GND 5.6574375e-16
R_6_7_5_1 Node6_7_5 Node6_7_6 1407692.3076923077
R_6_7_5_2 Node6_7_5 Node6_8_5 1407692.3076923077
R_6_7_5_3 Node6_7_5 Node7_7_5 6.0902400000000005
C_6_7_5 Node6_7_5 GND 5.6574375e-16
R_6_7_6_1 Node6_7_6 Node6_7_7 1407692.3076923077
R_6_7_6_2 Node6_7_6 Node6_8_6 1407692.3076923077
R_6_7_6_3 Node6_7_6 Node7_7_6 6.09024
C_6_7_6 Node6_7_6 GND 5.6574375e-16
R_6_7_7_1 Node6_7_7 Node6_7_8 1407692.3076923077
R_6_7_7_2 Node6_7_7 Node6_8_7 1407692.3076923077
R_6_7_7_3 Node6_7_7 Node7_7_7 6.0902400000000005
C_6_7_7 Node6_7_7 GND 5.6574375e-16
R_6_7_8_1 Node6_7_8 Node6_7_9 1407692.307692307
R_6_7_8_2 Node6_7_8 Node6_8_8 1407692.3076923077
R_6_7_8_3 Node6_7_8 Node7_7_8 6.0902400000000005
C_6_7_8 Node6_7_8 GND 5.6574375e-16
R_6_7_9_1 Node6_7_9 Node6_7_10 1407692.307692307
R_6_7_9_2 Node6_7_9 Node6_8_9 1407692.3076923063
R_6_7_9_3 Node6_7_9 Node7_7_9 6.090239999999995
C_6_7_9 Node6_7_9 GND 5.657437500000005e-16
R_6_7_10_1 Node6_7_10 Node6_7_11 1407692.3076923077
R_6_7_10_2 Node6_7_10 Node6_8_10 1407692.3076923077
R_6_7_10_3 Node6_7_10 Node7_7_10 6.0902400000000005
C_6_7_10 Node6_7_10 GND 5.6574375e-16
R_6_7_11_1 Node6_7_11 Node6_7_12 1407692.3076923077
R_6_7_11_2 Node6_7_11 Node6_8_11 1407692.3076923077
R_6_7_11_3 Node6_7_11 Node7_7_11 6.0902400000000005
C_6_7_11 Node6_7_11 GND 5.6574375e-16
R_6_7_12_1 Node6_7_12 Node6_7_13 1407692.3076923077
R_6_7_12_2 Node6_7_12 Node6_8_12 1407692.3076923077
R_6_7_12_3 Node6_7_12 Node7_7_12 6.0902400000000005
C_6_7_12 Node6_7_12 GND 5.6574375e-16
R_6_7_13_1 Node6_7_13 Node6_7_14 1407692.3076923077
R_6_7_13_2 Node6_7_13 Node6_8_13 1407692.3076923077
R_6_7_13_3 Node6_7_13 Node7_7_13 6.0902400000000005
C_6_7_13 Node6_7_13 GND 5.6574375e-16
R_6_7_14_1 Node6_7_14 Node6_7_15 1407692.307692307
R_6_7_14_2 Node6_7_14 Node6_8_14 1407692.3076923077
R_6_7_14_3 Node6_7_14 Node7_7_14 6.0902400000000005
C_6_7_14 Node6_7_14 GND 5.6574375e-16
R_6_7_15_2 Node6_7_15 Node6_8_15 1407692.3076923063
R_6_7_15_3 Node6_7_15 Node7_7_15 6.090239999999995
C_6_7_15 Node6_7_15 GND 5.657437500000005e-16
R_6_8_0_1 Node6_8_0 Node6_8_1 1407692.3076923077
R_6_8_0_2 Node6_8_0 Node6_9_0 1407692.3076923082
R_6_8_0_3 Node6_8_0 Node7_8_0 6.0902400000000005
C_6_8_0 Node6_8_0 GND 5.6574375e-16
R_6_8_1_1 Node6_8_1 Node6_8_2 1407692.3076923077
R_6_8_1_2 Node6_8_1 Node6_9_1 1407692.3076923084
R_6_8_1_3 Node6_8_1 Node7_8_1 6.0902400000000005
C_6_8_1 Node6_8_1 GND 5.6574375e-16
R_6_8_2_1 Node6_8_2 Node6_8_3 1407692.3076923077
R_6_8_2_2 Node6_8_2 Node6_9_2 1407692.3076923084
R_6_8_2_3 Node6_8_2 Node7_8_2 6.0902400000000005
C_6_8_2 Node6_8_2 GND 5.6574375e-16
R_6_8_3_1 Node6_8_3 Node6_8_4 1407692.3076923077
R_6_8_3_2 Node6_8_3 Node6_9_3 1407692.3076923084
R_6_8_3_3 Node6_8_3 Node7_8_3 6.0902400000000005
C_6_8_3 Node6_8_3 GND 5.6574375e-16
R_6_8_4_1 Node6_8_4 Node6_8_5 1407692.3076923077
R_6_8_4_2 Node6_8_4 Node6_9_4 1407692.3076923084
R_6_8_4_3 Node6_8_4 Node7_8_4 6.0902400000000005
C_6_8_4 Node6_8_4 GND 5.6574375e-16
R_6_8_5_1 Node6_8_5 Node6_8_6 1407692.3076923077
R_6_8_5_2 Node6_8_5 Node6_9_5 1407692.3076923084
R_6_8_5_3 Node6_8_5 Node7_8_5 6.0902400000000005
C_6_8_5 Node6_8_5 GND 5.6574375e-16
R_6_8_6_1 Node6_8_6 Node6_8_7 1407692.3076923077
R_6_8_6_2 Node6_8_6 Node6_9_6 1407692.3076923084
R_6_8_6_3 Node6_8_6 Node7_8_6 6.09024
C_6_8_6 Node6_8_6 GND 5.6574375e-16
R_6_8_7_1 Node6_8_7 Node6_8_8 1407692.3076923077
R_6_8_7_2 Node6_8_7 Node6_9_7 1407692.3076923084
R_6_8_7_3 Node6_8_7 Node7_8_7 6.0902400000000005
C_6_8_7 Node6_8_7 GND 5.6574375e-16
R_6_8_8_1 Node6_8_8 Node6_8_9 1407692.307692307
R_6_8_8_2 Node6_8_8 Node6_9_8 1407692.3076923084
R_6_8_8_3 Node6_8_8 Node7_8_8 6.0902400000000005
C_6_8_8 Node6_8_8 GND 5.6574375e-16
R_6_8_9_1 Node6_8_9 Node6_8_10 1407692.307692307
R_6_8_9_2 Node6_8_9 Node6_9_9 1407692.3076923075
R_6_8_9_3 Node6_8_9 Node7_8_9 6.090239999999995
C_6_8_9 Node6_8_9 GND 5.657437500000005e-16
R_6_8_10_1 Node6_8_10 Node6_8_11 1407692.3076923077
R_6_8_10_2 Node6_8_10 Node6_9_10 1407692.3076923084
R_6_8_10_3 Node6_8_10 Node7_8_10 6.0902400000000005
C_6_8_10 Node6_8_10 GND 5.6574375e-16
R_6_8_11_1 Node6_8_11 Node6_8_12 1407692.3076923077
R_6_8_11_2 Node6_8_11 Node6_9_11 1407692.3076923084
R_6_8_11_3 Node6_8_11 Node7_8_11 6.0902400000000005
C_6_8_11 Node6_8_11 GND 5.6574375e-16
R_6_8_12_1 Node6_8_12 Node6_8_13 1407692.3076923077
R_6_8_12_2 Node6_8_12 Node6_9_12 1407692.3076923084
R_6_8_12_3 Node6_8_12 Node7_8_12 6.0902400000000005
C_6_8_12 Node6_8_12 GND 5.6574375e-16
R_6_8_13_1 Node6_8_13 Node6_8_14 1407692.3076923077
R_6_8_13_2 Node6_8_13 Node6_9_13 1407692.3076923084
R_6_8_13_3 Node6_8_13 Node7_8_13 6.0902400000000005
C_6_8_13 Node6_8_13 GND 5.6574375e-16
R_6_8_14_1 Node6_8_14 Node6_8_15 1407692.307692307
R_6_8_14_2 Node6_8_14 Node6_9_14 1407692.3076923084
R_6_8_14_3 Node6_8_14 Node7_8_14 6.0902400000000005
C_6_8_14 Node6_8_14 GND 5.6574375e-16
R_6_8_15_2 Node6_8_15 Node6_9_15 1407692.307692307
R_6_8_15_3 Node6_8_15 Node7_8_15 6.090239999999995
C_6_8_15 Node6_8_15 GND 5.657437500000005e-16
R_6_9_0_1 Node6_9_0 Node6_9_1 1407692.307692309
R_6_9_0_2 Node6_9_0 Node6_10_0 1407692.3076923082
R_6_9_0_3 Node6_9_0 Node7_9_0 6.090240000000006
C_6_9_0 Node6_9_0 GND 5.657437499999995e-16
R_6_9_1_1 Node6_9_1 Node6_9_2 1407692.307692309
R_6_9_1_2 Node6_9_1 Node6_10_1 1407692.3076923084
R_6_9_1_3 Node6_9_1 Node7_9_1 6.090240000000006
C_6_9_1 Node6_9_1 GND 5.657437499999995e-16
R_6_9_2_1 Node6_9_2 Node6_9_3 1407692.307692309
R_6_9_2_2 Node6_9_2 Node6_10_2 1407692.3076923084
R_6_9_2_3 Node6_9_2 Node7_9_2 6.090240000000006
C_6_9_2 Node6_9_2 GND 5.657437499999995e-16
R_6_9_3_1 Node6_9_3 Node6_9_4 1407692.307692309
R_6_9_3_2 Node6_9_3 Node6_10_3 1407692.3076923084
R_6_9_3_3 Node6_9_3 Node7_9_3 6.090240000000006
C_6_9_3 Node6_9_3 GND 5.657437499999995e-16
R_6_9_4_1 Node6_9_4 Node6_9_5 1407692.307692309
R_6_9_4_2 Node6_9_4 Node6_10_4 1407692.3076923084
R_6_9_4_3 Node6_9_4 Node7_9_4 6.090240000000006
C_6_9_4 Node6_9_4 GND 5.657437499999995e-16
R_6_9_5_1 Node6_9_5 Node6_9_6 1407692.307692309
R_6_9_5_2 Node6_9_5 Node6_10_5 1407692.3076923084
R_6_9_5_3 Node6_9_5 Node7_9_5 6.090240000000006
C_6_9_5 Node6_9_5 GND 5.657437499999995e-16
R_6_9_6_1 Node6_9_6 Node6_9_7 1407692.307692309
R_6_9_6_2 Node6_9_6 Node6_10_6 1407692.3076923084
R_6_9_6_3 Node6_9_6 Node7_9_6 6.090240000000006
C_6_9_6 Node6_9_6 GND 5.657437499999995e-16
R_6_9_7_1 Node6_9_7 Node6_9_8 1407692.307692309
R_6_9_7_2 Node6_9_7 Node6_10_7 1407692.3076923084
R_6_9_7_3 Node6_9_7 Node7_9_7 6.090240000000006
C_6_9_7 Node6_9_7 GND 5.657437499999995e-16
R_6_9_8_1 Node6_9_8 Node6_9_9 1407692.3076923087
R_6_9_8_2 Node6_9_8 Node6_10_8 1407692.3076923084
R_6_9_8_3 Node6_9_8 Node7_9_8 6.090240000000006
C_6_9_8 Node6_9_8 GND 5.657437499999995e-16
R_6_9_9_1 Node6_9_9 Node6_9_10 1407692.3076923087
R_6_9_9_2 Node6_9_9 Node6_10_9 1407692.307692308
R_6_9_9_3 Node6_9_9 Node7_9_9 6.090240000000002
C_6_9_9 Node6_9_9 GND 5.657437499999999e-16
R_6_9_10_1 Node6_9_10 Node6_9_11 1407692.307692309
R_6_9_10_2 Node6_9_10 Node6_10_10 1407692.3076923084
R_6_9_10_3 Node6_9_10 Node7_9_10 6.090240000000006
C_6_9_10 Node6_9_10 GND 5.657437499999995e-16
R_6_9_11_1 Node6_9_11 Node6_9_12 1407692.307692309
R_6_9_11_2 Node6_9_11 Node6_10_11 1407692.3076923084
R_6_9_11_3 Node6_9_11 Node7_9_11 6.090240000000006
C_6_9_11 Node6_9_11 GND 5.657437499999995e-16
R_6_9_12_1 Node6_9_12 Node6_9_13 1407692.307692309
R_6_9_12_2 Node6_9_12 Node6_10_12 1407692.3076923084
R_6_9_12_3 Node6_9_12 Node7_9_12 6.090240000000006
C_6_9_12 Node6_9_12 GND 5.657437499999995e-16
R_6_9_13_1 Node6_9_13 Node6_9_14 1407692.307692309
R_6_9_13_2 Node6_9_13 Node6_10_13 1407692.3076923084
R_6_9_13_3 Node6_9_13 Node7_9_13 6.090240000000006
C_6_9_13 Node6_9_13 GND 5.657437499999995e-16
R_6_9_14_1 Node6_9_14 Node6_9_15 1407692.3076923084
R_6_9_14_2 Node6_9_14 Node6_10_14 1407692.3076923084
R_6_9_14_3 Node6_9_14 Node7_9_14 6.090240000000006
C_6_9_14 Node6_9_14 GND 5.657437499999995e-16
R_6_9_15_2 Node6_9_15 Node6_10_15 1407692.307692307
R_6_9_15_3 Node6_9_15 Node7_9_15 6.0902400000000005
C_6_9_15 Node6_9_15 GND 5.6574375e-16
R_6_10_0_1 Node6_10_0 Node6_10_1 1407692.3076923077
R_6_10_0_2 Node6_10_0 Node6_11_0 1407692.3076923077
R_6_10_0_3 Node6_10_0 Node7_10_0 6.0902400000000005
C_6_10_0 Node6_10_0 GND 5.6574375e-16
R_6_10_1_1 Node6_10_1 Node6_10_2 1407692.3076923077
R_6_10_1_2 Node6_10_1 Node6_11_1 1407692.3076923077
R_6_10_1_3 Node6_10_1 Node7_10_1 6.0902400000000005
C_6_10_1 Node6_10_1 GND 5.6574375e-16
R_6_10_2_1 Node6_10_2 Node6_10_3 1407692.3076923077
R_6_10_2_2 Node6_10_2 Node6_11_2 1407692.3076923077
R_6_10_2_3 Node6_10_2 Node7_10_2 6.0902400000000005
C_6_10_2 Node6_10_2 GND 5.6574375e-16
R_6_10_3_1 Node6_10_3 Node6_10_4 1407692.3076923077
R_6_10_3_2 Node6_10_3 Node6_11_3 1407692.3076923077
R_6_10_3_3 Node6_10_3 Node7_10_3 6.0902400000000005
C_6_10_3 Node6_10_3 GND 5.6574375e-16
R_6_10_4_1 Node6_10_4 Node6_10_5 1407692.3076923077
R_6_10_4_2 Node6_10_4 Node6_11_4 1407692.3076923077
R_6_10_4_3 Node6_10_4 Node7_10_4 6.0902400000000005
C_6_10_4 Node6_10_4 GND 5.6574375e-16
R_6_10_5_1 Node6_10_5 Node6_10_6 1407692.3076923077
R_6_10_5_2 Node6_10_5 Node6_11_5 1407692.3076923077
R_6_10_5_3 Node6_10_5 Node7_10_5 6.0902400000000005
C_6_10_5 Node6_10_5 GND 5.6574375e-16
R_6_10_6_1 Node6_10_6 Node6_10_7 1407692.3076923077
R_6_10_6_2 Node6_10_6 Node6_11_6 1407692.3076923077
R_6_10_6_3 Node6_10_6 Node7_10_6 6.0902400000000005
C_6_10_6 Node6_10_6 GND 5.6574375e-16
R_6_10_7_1 Node6_10_7 Node6_10_8 1407692.3076923077
R_6_10_7_2 Node6_10_7 Node6_11_7 1407692.3076923077
R_6_10_7_3 Node6_10_7 Node7_10_7 6.0902400000000005
C_6_10_7 Node6_10_7 GND 5.6574375e-16
R_6_10_8_1 Node6_10_8 Node6_10_9 1407692.3076923077
R_6_10_8_2 Node6_10_8 Node6_11_8 1407692.3076923077
R_6_10_8_3 Node6_10_8 Node7_10_8 6.0902400000000005
C_6_10_8 Node6_10_8 GND 5.6574375e-16
R_6_10_9_1 Node6_10_9 Node6_10_10 1407692.3076923077
R_6_10_9_2 Node6_10_9 Node6_11_9 1407692.3076923077
R_6_10_9_3 Node6_10_9 Node7_10_9 6.0902400000000005
C_6_10_9 Node6_10_9 GND 5.6574375e-16
R_6_10_10_1 Node6_10_10 Node6_10_11 1407692.3076923077
R_6_10_10_2 Node6_10_10 Node6_11_10 1407692.3076923077
R_6_10_10_3 Node6_10_10 Node7_10_10 6.0902400000000005
C_6_10_10 Node6_10_10 GND 5.6574375e-16
R_6_10_11_1 Node6_10_11 Node6_10_12 1407692.3076923077
R_6_10_11_2 Node6_10_11 Node6_11_11 1407692.3076923077
R_6_10_11_3 Node6_10_11 Node7_10_11 6.0902400000000005
C_6_10_11 Node6_10_11 GND 5.6574375e-16
R_6_10_12_1 Node6_10_12 Node6_10_13 1407692.3076923077
R_6_10_12_2 Node6_10_12 Node6_11_12 1407692.3076923077
R_6_10_12_3 Node6_10_12 Node7_10_12 6.0902400000000005
C_6_10_12 Node6_10_12 GND 5.6574375e-16
R_6_10_13_1 Node6_10_13 Node6_10_14 1407692.3076923077
R_6_10_13_2 Node6_10_13 Node6_11_13 1407692.3076923077
R_6_10_13_3 Node6_10_13 Node7_10_13 6.0902400000000005
C_6_10_13 Node6_10_13 GND 5.6574375e-16
R_6_10_14_1 Node6_10_14 Node6_10_15 1407692.307692307
R_6_10_14_2 Node6_10_14 Node6_11_14 1407692.3076923077
R_6_10_14_3 Node6_10_14 Node7_10_14 6.0902400000000005
C_6_10_14 Node6_10_14 GND 5.6574375e-16
R_6_10_15_2 Node6_10_15 Node6_11_15 1407692.3076923063
R_6_10_15_3 Node6_10_15 Node7_10_15 6.090239999999995
C_6_10_15 Node6_10_15 GND 5.657437500000005e-16
R_6_11_0_1 Node6_11_0 Node6_11_1 1407692.3076923077
R_6_11_0_2 Node6_11_0 Node6_12_0 1407692.3076923077
R_6_11_0_3 Node6_11_0 Node7_11_0 6.0902400000000005
C_6_11_0 Node6_11_0 GND 5.6574375e-16
R_6_11_1_1 Node6_11_1 Node6_11_2 1407692.3076923077
R_6_11_1_2 Node6_11_1 Node6_12_1 1407692.3076923077
R_6_11_1_3 Node6_11_1 Node7_11_1 6.0902400000000005
C_6_11_1 Node6_11_1 GND 5.6574375e-16
R_6_11_2_1 Node6_11_2 Node6_11_3 1407692.3076923077
R_6_11_2_2 Node6_11_2 Node6_12_2 1407692.3076923077
R_6_11_2_3 Node6_11_2 Node7_11_2 6.0902400000000005
C_6_11_2 Node6_11_2 GND 5.6574375e-16
R_6_11_3_1 Node6_11_3 Node6_11_4 1407692.3076923077
R_6_11_3_2 Node6_11_3 Node6_12_3 1407692.3076923077
R_6_11_3_3 Node6_11_3 Node7_11_3 6.0902400000000005
C_6_11_3 Node6_11_3 GND 5.6574375e-16
R_6_11_4_1 Node6_11_4 Node6_11_5 1407692.3076923077
R_6_11_4_2 Node6_11_4 Node6_12_4 1407692.3076923077
R_6_11_4_3 Node6_11_4 Node7_11_4 6.0902400000000005
C_6_11_4 Node6_11_4 GND 5.6574375e-16
R_6_11_5_1 Node6_11_5 Node6_11_6 1407692.3076923077
R_6_11_5_2 Node6_11_5 Node6_12_5 1407692.3076923077
R_6_11_5_3 Node6_11_5 Node7_11_5 6.0902400000000005
C_6_11_5 Node6_11_5 GND 5.6574375e-16
R_6_11_6_1 Node6_11_6 Node6_11_7 1407692.3076923077
R_6_11_6_2 Node6_11_6 Node6_12_6 1407692.3076923077
R_6_11_6_3 Node6_11_6 Node7_11_6 6.0902400000000005
C_6_11_6 Node6_11_6 GND 5.6574375e-16
R_6_11_7_1 Node6_11_7 Node6_11_8 1407692.3076923077
R_6_11_7_2 Node6_11_7 Node6_12_7 1407692.3076923077
R_6_11_7_3 Node6_11_7 Node7_11_7 6.0902400000000005
C_6_11_7 Node6_11_7 GND 5.6574375e-16
R_6_11_8_1 Node6_11_8 Node6_11_9 1407692.3076923077
R_6_11_8_2 Node6_11_8 Node6_12_8 1407692.3076923077
R_6_11_8_3 Node6_11_8 Node7_11_8 6.0902400000000005
C_6_11_8 Node6_11_8 GND 5.6574375e-16
R_6_11_9_1 Node6_11_9 Node6_11_10 1407692.3076923077
R_6_11_9_2 Node6_11_9 Node6_12_9 1407692.3076923077
R_6_11_9_3 Node6_11_9 Node7_11_9 6.0902400000000005
C_6_11_9 Node6_11_9 GND 5.6574375e-16
R_6_11_10_1 Node6_11_10 Node6_11_11 1407692.3076923077
R_6_11_10_2 Node6_11_10 Node6_12_10 1407692.3076923077
R_6_11_10_3 Node6_11_10 Node7_11_10 6.0902400000000005
C_6_11_10 Node6_11_10 GND 5.6574375e-16
R_6_11_11_1 Node6_11_11 Node6_11_12 1407692.3076923077
R_6_11_11_2 Node6_11_11 Node6_12_11 1407692.3076923077
R_6_11_11_3 Node6_11_11 Node7_11_11 6.0902400000000005
C_6_11_11 Node6_11_11 GND 5.6574375e-16
R_6_11_12_1 Node6_11_12 Node6_11_13 1407692.3076923077
R_6_11_12_2 Node6_11_12 Node6_12_12 1407692.3076923077
R_6_11_12_3 Node6_11_12 Node7_11_12 6.0902400000000005
C_6_11_12 Node6_11_12 GND 5.6574375e-16
R_6_11_13_1 Node6_11_13 Node6_11_14 1407692.3076923077
R_6_11_13_2 Node6_11_13 Node6_12_13 1407692.3076923077
R_6_11_13_3 Node6_11_13 Node7_11_13 6.0902400000000005
C_6_11_13 Node6_11_13 GND 5.6574375e-16
R_6_11_14_1 Node6_11_14 Node6_11_15 1407692.307692307
R_6_11_14_2 Node6_11_14 Node6_12_14 1407692.3076923077
R_6_11_14_3 Node6_11_14 Node7_11_14 6.0902400000000005
C_6_11_14 Node6_11_14 GND 5.6574375e-16
R_6_11_15_2 Node6_11_15 Node6_12_15 1407692.3076923063
R_6_11_15_3 Node6_11_15 Node7_11_15 6.090239999999995
C_6_11_15 Node6_11_15 GND 5.657437500000005e-16
R_6_12_0_1 Node6_12_0 Node6_12_1 1407692.3076923077
R_6_12_0_2 Node6_12_0 Node6_13_0 1407692.3076923077
R_6_12_0_3 Node6_12_0 Node7_12_0 6.0902400000000005
C_6_12_0 Node6_12_0 GND 5.6574375e-16
R_6_12_1_1 Node6_12_1 Node6_12_2 1407692.3076923077
R_6_12_1_2 Node6_12_1 Node6_13_1 1407692.3076923077
R_6_12_1_3 Node6_12_1 Node7_12_1 6.0902400000000005
C_6_12_1 Node6_12_1 GND 5.6574375e-16
R_6_12_2_1 Node6_12_2 Node6_12_3 1407692.3076923077
R_6_12_2_2 Node6_12_2 Node6_13_2 1407692.3076923077
R_6_12_2_3 Node6_12_2 Node7_12_2 6.0902400000000005
C_6_12_2 Node6_12_2 GND 5.6574375e-16
R_6_12_3_1 Node6_12_3 Node6_12_4 1407692.3076923077
R_6_12_3_2 Node6_12_3 Node6_13_3 1407692.3076923077
R_6_12_3_3 Node6_12_3 Node7_12_3 6.0902400000000005
C_6_12_3 Node6_12_3 GND 5.6574375e-16
R_6_12_4_1 Node6_12_4 Node6_12_5 1407692.3076923077
R_6_12_4_2 Node6_12_4 Node6_13_4 1407692.3076923077
R_6_12_4_3 Node6_12_4 Node7_12_4 6.0902400000000005
C_6_12_4 Node6_12_4 GND 5.6574375e-16
R_6_12_5_1 Node6_12_5 Node6_12_6 1407692.3076923077
R_6_12_5_2 Node6_12_5 Node6_13_5 1407692.3076923077
R_6_12_5_3 Node6_12_5 Node7_12_5 6.0902400000000005
C_6_12_5 Node6_12_5 GND 5.6574375e-16
R_6_12_6_1 Node6_12_6 Node6_12_7 1407692.3076923077
R_6_12_6_2 Node6_12_6 Node6_13_6 1407692.3076923077
R_6_12_6_3 Node6_12_6 Node7_12_6 6.0902400000000005
C_6_12_6 Node6_12_6 GND 5.6574375e-16
R_6_12_7_1 Node6_12_7 Node6_12_8 1407692.3076923077
R_6_12_7_2 Node6_12_7 Node6_13_7 1407692.3076923077
R_6_12_7_3 Node6_12_7 Node7_12_7 6.0902400000000005
C_6_12_7 Node6_12_7 GND 5.6574375e-16
R_6_12_8_1 Node6_12_8 Node6_12_9 1407692.3076923077
R_6_12_8_2 Node6_12_8 Node6_13_8 1407692.3076923077
R_6_12_8_3 Node6_12_8 Node7_12_8 6.0902400000000005
C_6_12_8 Node6_12_8 GND 5.6574375e-16
R_6_12_9_1 Node6_12_9 Node6_12_10 1407692.3076923077
R_6_12_9_2 Node6_12_9 Node6_13_9 1407692.3076923077
R_6_12_9_3 Node6_12_9 Node7_12_9 6.0902400000000005
C_6_12_9 Node6_12_9 GND 5.6574375e-16
R_6_12_10_1 Node6_12_10 Node6_12_11 1407692.3076923077
R_6_12_10_2 Node6_12_10 Node6_13_10 1407692.3076923077
R_6_12_10_3 Node6_12_10 Node7_12_10 6.0902400000000005
C_6_12_10 Node6_12_10 GND 5.6574375e-16
R_6_12_11_1 Node6_12_11 Node6_12_12 1407692.3076923077
R_6_12_11_2 Node6_12_11 Node6_13_11 1407692.3076923077
R_6_12_11_3 Node6_12_11 Node7_12_11 6.0902400000000005
C_6_12_11 Node6_12_11 GND 5.6574375e-16
R_6_12_12_1 Node6_12_12 Node6_12_13 1407692.3076923077
R_6_12_12_2 Node6_12_12 Node6_13_12 1407692.3076923077
R_6_12_12_3 Node6_12_12 Node7_12_12 6.0902400000000005
C_6_12_12 Node6_12_12 GND 5.6574375e-16
R_6_12_13_1 Node6_12_13 Node6_12_14 1407692.3076923077
R_6_12_13_2 Node6_12_13 Node6_13_13 1407692.3076923077
R_6_12_13_3 Node6_12_13 Node7_12_13 6.0902400000000005
C_6_12_13 Node6_12_13 GND 5.6574375e-16
R_6_12_14_1 Node6_12_14 Node6_12_15 1407692.307692307
R_6_12_14_2 Node6_12_14 Node6_13_14 1407692.3076923077
R_6_12_14_3 Node6_12_14 Node7_12_14 6.0902400000000005
C_6_12_14 Node6_12_14 GND 5.6574375e-16
R_6_12_15_2 Node6_12_15 Node6_13_15 1407692.3076923063
R_6_12_15_3 Node6_12_15 Node7_12_15 6.090239999999995
C_6_12_15 Node6_12_15 GND 5.657437500000005e-16
R_6_13_0_1 Node6_13_0 Node6_13_1 1407692.3076923077
R_6_13_0_2 Node6_13_0 Node6_14_0 1407692.3076923077
R_6_13_0_3 Node6_13_0 Node7_13_0 6.0902400000000005
C_6_13_0 Node6_13_0 GND 5.6574375e-16
R_6_13_1_1 Node6_13_1 Node6_13_2 1407692.3076923077
R_6_13_1_2 Node6_13_1 Node6_14_1 1407692.3076923077
R_6_13_1_3 Node6_13_1 Node7_13_1 6.0902400000000005
C_6_13_1 Node6_13_1 GND 5.6574375e-16
R_6_13_2_1 Node6_13_2 Node6_13_3 1407692.3076923077
R_6_13_2_2 Node6_13_2 Node6_14_2 1407692.3076923077
R_6_13_2_3 Node6_13_2 Node7_13_2 6.0902400000000005
C_6_13_2 Node6_13_2 GND 5.6574375e-16
R_6_13_3_1 Node6_13_3 Node6_13_4 1407692.3076923077
R_6_13_3_2 Node6_13_3 Node6_14_3 1407692.3076923077
R_6_13_3_3 Node6_13_3 Node7_13_3 6.0902400000000005
C_6_13_3 Node6_13_3 GND 5.6574375e-16
R_6_13_4_1 Node6_13_4 Node6_13_5 1407692.3076923077
R_6_13_4_2 Node6_13_4 Node6_14_4 1407692.3076923077
R_6_13_4_3 Node6_13_4 Node7_13_4 6.0902400000000005
C_6_13_4 Node6_13_4 GND 5.6574375e-16
R_6_13_5_1 Node6_13_5 Node6_13_6 1407692.3076923077
R_6_13_5_2 Node6_13_5 Node6_14_5 1407692.3076923077
R_6_13_5_3 Node6_13_5 Node7_13_5 6.0902400000000005
C_6_13_5 Node6_13_5 GND 5.6574375e-16
R_6_13_6_1 Node6_13_6 Node6_13_7 1407692.3076923077
R_6_13_6_2 Node6_13_6 Node6_14_6 1407692.3076923077
R_6_13_6_3 Node6_13_6 Node7_13_6 6.0902400000000005
C_6_13_6 Node6_13_6 GND 5.6574375e-16
R_6_13_7_1 Node6_13_7 Node6_13_8 1407692.3076923077
R_6_13_7_2 Node6_13_7 Node6_14_7 1407692.3076923077
R_6_13_7_3 Node6_13_7 Node7_13_7 6.0902400000000005
C_6_13_7 Node6_13_7 GND 5.6574375e-16
R_6_13_8_1 Node6_13_8 Node6_13_9 1407692.3076923077
R_6_13_8_2 Node6_13_8 Node6_14_8 1407692.3076923077
R_6_13_8_3 Node6_13_8 Node7_13_8 6.0902400000000005
C_6_13_8 Node6_13_8 GND 5.6574375e-16
R_6_13_9_1 Node6_13_9 Node6_13_10 1407692.3076923077
R_6_13_9_2 Node6_13_9 Node6_14_9 1407692.3076923077
R_6_13_9_3 Node6_13_9 Node7_13_9 6.0902400000000005
C_6_13_9 Node6_13_9 GND 5.6574375e-16
R_6_13_10_1 Node6_13_10 Node6_13_11 1407692.3076923077
R_6_13_10_2 Node6_13_10 Node6_14_10 1407692.3076923077
R_6_13_10_3 Node6_13_10 Node7_13_10 6.0902400000000005
C_6_13_10 Node6_13_10 GND 5.6574375e-16
R_6_13_11_1 Node6_13_11 Node6_13_12 1407692.3076923077
R_6_13_11_2 Node6_13_11 Node6_14_11 1407692.3076923077
R_6_13_11_3 Node6_13_11 Node7_13_11 6.0902400000000005
C_6_13_11 Node6_13_11 GND 5.6574375e-16
R_6_13_12_1 Node6_13_12 Node6_13_13 1407692.3076923077
R_6_13_12_2 Node6_13_12 Node6_14_12 1407692.3076923077
R_6_13_12_3 Node6_13_12 Node7_13_12 6.0902400000000005
C_6_13_12 Node6_13_12 GND 5.6574375e-16
R_6_13_13_1 Node6_13_13 Node6_13_14 1407692.3076923077
R_6_13_13_2 Node6_13_13 Node6_14_13 1407692.3076923077
R_6_13_13_3 Node6_13_13 Node7_13_13 6.0902400000000005
C_6_13_13 Node6_13_13 GND 5.6574375e-16
R_6_13_14_1 Node6_13_14 Node6_13_15 1407692.307692307
R_6_13_14_2 Node6_13_14 Node6_14_14 1407692.3076923077
R_6_13_14_3 Node6_13_14 Node7_13_14 6.0902400000000005
C_6_13_14 Node6_13_14 GND 5.6574375e-16
R_6_13_15_2 Node6_13_15 Node6_14_15 1407692.3076923063
R_6_13_15_3 Node6_13_15 Node7_13_15 6.090239999999995
C_6_13_15 Node6_13_15 GND 5.657437500000005e-16
R_6_14_0_1 Node6_14_0 Node6_14_1 1407692.3076923077
R_6_14_0_2 Node6_14_0 Node6_15_0 1407692.3076923077
R_6_14_0_3 Node6_14_0 Node7_14_0 6.0902400000000005
C_6_14_0 Node6_14_0 GND 5.6574375e-16
R_6_14_1_1 Node6_14_1 Node6_14_2 1407692.3076923077
R_6_14_1_2 Node6_14_1 Node6_15_1 1407692.3076923077
R_6_14_1_3 Node6_14_1 Node7_14_1 6.0902400000000005
C_6_14_1 Node6_14_1 GND 5.6574375e-16
R_6_14_2_1 Node6_14_2 Node6_14_3 1407692.3076923077
R_6_14_2_2 Node6_14_2 Node6_15_2 1407692.3076923077
R_6_14_2_3 Node6_14_2 Node7_14_2 6.0902400000000005
C_6_14_2 Node6_14_2 GND 5.6574375e-16
R_6_14_3_1 Node6_14_3 Node6_14_4 1407692.3076923077
R_6_14_3_2 Node6_14_3 Node6_15_3 1407692.3076923077
R_6_14_3_3 Node6_14_3 Node7_14_3 6.0902400000000005
C_6_14_3 Node6_14_3 GND 5.6574375e-16
R_6_14_4_1 Node6_14_4 Node6_14_5 1407692.3076923077
R_6_14_4_2 Node6_14_4 Node6_15_4 1407692.3076923077
R_6_14_4_3 Node6_14_4 Node7_14_4 6.0902400000000005
C_6_14_4 Node6_14_4 GND 5.6574375e-16
R_6_14_5_1 Node6_14_5 Node6_14_6 1407692.3076923077
R_6_14_5_2 Node6_14_5 Node6_15_5 1407692.3076923077
R_6_14_5_3 Node6_14_5 Node7_14_5 6.0902400000000005
C_6_14_5 Node6_14_5 GND 5.6574375e-16
R_6_14_6_1 Node6_14_6 Node6_14_7 1407692.3076923077
R_6_14_6_2 Node6_14_6 Node6_15_6 1407692.3076923077
R_6_14_6_3 Node6_14_6 Node7_14_6 6.0902400000000005
C_6_14_6 Node6_14_6 GND 5.6574375e-16
R_6_14_7_1 Node6_14_7 Node6_14_8 1407692.3076923077
R_6_14_7_2 Node6_14_7 Node6_15_7 1407692.3076923077
R_6_14_7_3 Node6_14_7 Node7_14_7 6.0902400000000005
C_6_14_7 Node6_14_7 GND 5.6574375e-16
R_6_14_8_1 Node6_14_8 Node6_14_9 1407692.3076923077
R_6_14_8_2 Node6_14_8 Node6_15_8 1407692.3076923077
R_6_14_8_3 Node6_14_8 Node7_14_8 6.0902400000000005
C_6_14_8 Node6_14_8 GND 5.6574375e-16
R_6_14_9_1 Node6_14_9 Node6_14_10 1407692.3076923077
R_6_14_9_2 Node6_14_9 Node6_15_9 1407692.3076923077
R_6_14_9_3 Node6_14_9 Node7_14_9 6.0902400000000005
C_6_14_9 Node6_14_9 GND 5.6574375e-16
R_6_14_10_1 Node6_14_10 Node6_14_11 1407692.3076923077
R_6_14_10_2 Node6_14_10 Node6_15_10 1407692.3076923077
R_6_14_10_3 Node6_14_10 Node7_14_10 6.0902400000000005
C_6_14_10 Node6_14_10 GND 5.6574375e-16
R_6_14_11_1 Node6_14_11 Node6_14_12 1407692.3076923077
R_6_14_11_2 Node6_14_11 Node6_15_11 1407692.3076923077
R_6_14_11_3 Node6_14_11 Node7_14_11 6.0902400000000005
C_6_14_11 Node6_14_11 GND 5.6574375e-16
R_6_14_12_1 Node6_14_12 Node6_14_13 1407692.3076923077
R_6_14_12_2 Node6_14_12 Node6_15_12 1407692.3076923077
R_6_14_12_3 Node6_14_12 Node7_14_12 6.0902400000000005
C_6_14_12 Node6_14_12 GND 5.6574375e-16
R_6_14_13_1 Node6_14_13 Node6_14_14 1407692.3076923077
R_6_14_13_2 Node6_14_13 Node6_15_13 1407692.3076923077
R_6_14_13_3 Node6_14_13 Node7_14_13 6.0902400000000005
C_6_14_13 Node6_14_13 GND 5.6574375e-16
R_6_14_14_1 Node6_14_14 Node6_14_15 1407692.307692307
R_6_14_14_2 Node6_14_14 Node6_15_14 1407692.3076923077
R_6_14_14_3 Node6_14_14 Node7_14_14 6.0902400000000005
C_6_14_14 Node6_14_14 GND 5.6574375e-16
R_6_14_15_2 Node6_14_15 Node6_15_15 1407692.3076923063
R_6_14_15_3 Node6_14_15 Node7_14_15 6.090239999999995
C_6_14_15 Node6_14_15 GND 5.657437500000005e-16
R_6_15_0_1 Node6_15_0 Node6_15_1 1407692.3076923077
R_6_15_0_3 Node6_15_0 Node7_15_0 6.0902400000000005
C_6_15_0 Node6_15_0 GND 5.6574375e-16
R_6_15_1_1 Node6_15_1 Node6_15_2 1407692.3076923077
R_6_15_1_3 Node6_15_1 Node7_15_1 6.0902400000000005
C_6_15_1 Node6_15_1 GND 5.6574375e-16
R_6_15_2_1 Node6_15_2 Node6_15_3 1407692.3076923077
R_6_15_2_3 Node6_15_2 Node7_15_2 6.0902400000000005
C_6_15_2 Node6_15_2 GND 5.6574375e-16
R_6_15_3_1 Node6_15_3 Node6_15_4 1407692.3076923077
R_6_15_3_3 Node6_15_3 Node7_15_3 6.0902400000000005
C_6_15_3 Node6_15_3 GND 5.6574375e-16
R_6_15_4_1 Node6_15_4 Node6_15_5 1407692.3076923077
R_6_15_4_3 Node6_15_4 Node7_15_4 6.0902400000000005
C_6_15_4 Node6_15_4 GND 5.6574375e-16
R_6_15_5_1 Node6_15_5 Node6_15_6 1407692.3076923077
R_6_15_5_3 Node6_15_5 Node7_15_5 6.0902400000000005
C_6_15_5 Node6_15_5 GND 5.6574375e-16
R_6_15_6_1 Node6_15_6 Node6_15_7 1407692.3076923077
R_6_15_6_3 Node6_15_6 Node7_15_6 6.0902400000000005
C_6_15_6 Node6_15_6 GND 5.6574375e-16
R_6_15_7_1 Node6_15_7 Node6_15_8 1407692.3076923077
R_6_15_7_3 Node6_15_7 Node7_15_7 6.0902400000000005
C_6_15_7 Node6_15_7 GND 5.6574375e-16
R_6_15_8_1 Node6_15_8 Node6_15_9 1407692.3076923077
R_6_15_8_3 Node6_15_8 Node7_15_8 6.0902400000000005
C_6_15_8 Node6_15_8 GND 5.6574375e-16
R_6_15_9_1 Node6_15_9 Node6_15_10 1407692.3076923077
R_6_15_9_3 Node6_15_9 Node7_15_9 6.0902400000000005
C_6_15_9 Node6_15_9 GND 5.6574375e-16
R_6_15_10_1 Node6_15_10 Node6_15_11 1407692.3076923077
R_6_15_10_3 Node6_15_10 Node7_15_10 6.0902400000000005
C_6_15_10 Node6_15_10 GND 5.6574375e-16
R_6_15_11_1 Node6_15_11 Node6_15_12 1407692.3076923077
R_6_15_11_3 Node6_15_11 Node7_15_11 6.0902400000000005
C_6_15_11 Node6_15_11 GND 5.6574375e-16
R_6_15_12_1 Node6_15_12 Node6_15_13 1407692.3076923077
R_6_15_12_3 Node6_15_12 Node7_15_12 6.0902400000000005
C_6_15_12 Node6_15_12 GND 5.6574375e-16
R_6_15_13_1 Node6_15_13 Node6_15_14 1407692.3076923077
R_6_15_13_3 Node6_15_13 Node7_15_13 6.0902400000000005
C_6_15_13 Node6_15_13 GND 5.6574375e-16
R_6_15_14_1 Node6_15_14 Node6_15_15 1407692.307692307
R_6_15_14_3 Node6_15_14 Node7_15_14 6.0902400000000005
C_6_15_14 Node6_15_14 GND 5.6574375e-16
R_6_15_15_3 Node6_15_15 Node7_15_15 6.090239999999993
C_6_15_15 Node6_15_15 GND 5.657437500000006e-16
R_7_0_0_1 Node7_0_0 Node7_0_1 8517647.058823539
R_7_0_0_2 Node7_0_0 Node7_1_0 8517647.058823535
R_7_0_0_3 Node7_0_0 Node8_0_0 15.754240000000014
C_7_0_0 Node7_0_0 GND 2.9036132812499977e-10
R_7_0_1_1 Node7_0_1 Node7_0_2 8517647.058823539
R_7_0_1_2 Node7_0_1 Node7_1_1 8517647.058823535
R_7_0_1_3 Node7_0_1 Node8_0_1 15.754240000000014
C_7_0_1 Node7_0_1 GND 2.9036132812499977e-10
R_7_0_2_1 Node7_0_2 Node7_0_3 8517647.058823539
R_7_0_2_2 Node7_0_2 Node7_1_2 8517647.058823535
R_7_0_2_3 Node7_0_2 Node8_0_2 15.754240000000014
C_7_0_2 Node7_0_2 GND 2.9036132812499977e-10
R_7_0_3_1 Node7_0_3 Node7_0_4 8517647.058823539
R_7_0_3_2 Node7_0_3 Node7_1_3 8517647.058823535
R_7_0_3_3 Node7_0_3 Node8_0_3 15.754240000000014
C_7_0_3 Node7_0_3 GND 2.9036132812499977e-10
R_7_0_4_1 Node7_0_4 Node7_0_5 8517647.058823539
R_7_0_4_2 Node7_0_4 Node7_1_4 8517647.058823535
R_7_0_4_3 Node7_0_4 Node8_0_4 15.754240000000014
C_7_0_4 Node7_0_4 GND 2.9036132812499977e-10
R_7_0_5_1 Node7_0_5 Node7_0_6 8517647.058823539
R_7_0_5_2 Node7_0_5 Node7_1_5 8517647.058823535
R_7_0_5_3 Node7_0_5 Node8_0_5 15.754240000000014
C_7_0_5 Node7_0_5 GND 2.9036132812499977e-10
R_7_0_6_1 Node7_0_6 Node7_0_7 8517647.058823539
R_7_0_6_2 Node7_0_6 Node7_1_6 8517647.058823535
R_7_0_6_3 Node7_0_6 Node8_0_6 15.754240000000014
C_7_0_6 Node7_0_6 GND 2.9036132812499977e-10
R_7_0_7_1 Node7_0_7 Node7_0_8 8517647.058823539
R_7_0_7_2 Node7_0_7 Node7_1_7 8517647.058823535
R_7_0_7_3 Node7_0_7 Node8_0_7 15.754240000000014
C_7_0_7 Node7_0_7 GND 2.9036132812499977e-10
R_7_0_8_1 Node7_0_8 Node7_0_9 8517647.058823539
R_7_0_8_2 Node7_0_8 Node7_1_8 8517647.058823535
R_7_0_8_3 Node7_0_8 Node8_0_8 15.754240000000014
C_7_0_8 Node7_0_8 GND 2.9036132812499977e-10
R_7_0_9_1 Node7_0_9 Node7_0_10 8517647.058823539
R_7_0_9_2 Node7_0_9 Node7_1_9 8517647.058823535
R_7_0_9_3 Node7_0_9 Node8_0_9 15.754240000000014
C_7_0_9 Node7_0_9 GND 2.9036132812499977e-10
R_7_0_10_1 Node7_0_10 Node7_0_11 8517647.058823539
R_7_0_10_2 Node7_0_10 Node7_1_10 8517647.058823535
R_7_0_10_3 Node7_0_10 Node8_0_10 15.754240000000014
C_7_0_10 Node7_0_10 GND 2.9036132812499977e-10
R_7_0_11_1 Node7_0_11 Node7_0_12 8517647.058823539
R_7_0_11_2 Node7_0_11 Node7_1_11 8517647.058823535
R_7_0_11_3 Node7_0_11 Node8_0_11 15.754240000000014
C_7_0_11 Node7_0_11 GND 2.9036132812499977e-10
R_7_0_12_1 Node7_0_12 Node7_0_13 8517647.058823539
R_7_0_12_2 Node7_0_12 Node7_1_12 8517647.058823535
R_7_0_12_3 Node7_0_12 Node8_0_12 15.754240000000014
C_7_0_12 Node7_0_12 GND 2.9036132812499977e-10
R_7_0_13_1 Node7_0_13 Node7_0_14 8517647.058823539
R_7_0_13_2 Node7_0_13 Node7_1_13 8517647.058823535
R_7_0_13_3 Node7_0_13 Node8_0_13 15.754240000000014
C_7_0_13 Node7_0_13 GND 2.9036132812499977e-10
R_7_0_14_1 Node7_0_14 Node7_0_15 8517647.058823535
R_7_0_14_2 Node7_0_14 Node7_1_14 8517647.058823535
R_7_0_14_3 Node7_0_14 Node8_0_14 15.754240000000014
C_7_0_14 Node7_0_14 GND 2.9036132812499977e-10
R_7_0_15_2 Node7_0_15 Node7_1_15 8517647.058823528
R_7_0_15_3 Node7_0_15 Node8_0_15 15.75424
C_7_0_15 Node7_0_15 GND 2.9036132812500003e-10
R_7_1_0_1 Node7_1_0 Node7_1_1 8517647.058823531
R_7_1_0_2 Node7_1_0 Node7_2_0 8517647.058823531
R_7_1_0_3 Node7_1_0 Node8_1_0 15.75424
C_7_1_0 Node7_1_0 GND 2.9036132812500003e-10
R_7_1_1_1 Node7_1_1 Node7_1_2 8517647.058823531
R_7_1_1_2 Node7_1_1 Node7_2_1 8517647.058823531
R_7_1_1_3 Node7_1_1 Node8_1_1 15.75424
C_7_1_1 Node7_1_1 GND 2.9036132812500003e-10
R_7_1_2_1 Node7_1_2 Node7_1_3 8517647.058823531
R_7_1_2_2 Node7_1_2 Node7_2_2 8517647.058823531
R_7_1_2_3 Node7_1_2 Node8_1_2 15.75424
C_7_1_2 Node7_1_2 GND 2.9036132812500003e-10
R_7_1_3_1 Node7_1_3 Node7_1_4 8517647.058823531
R_7_1_3_2 Node7_1_3 Node7_2_3 8517647.058823531
R_7_1_3_3 Node7_1_3 Node8_1_3 15.75424
C_7_1_3 Node7_1_3 GND 2.9036132812500003e-10
R_7_1_4_1 Node7_1_4 Node7_1_5 8517647.058823531
R_7_1_4_2 Node7_1_4 Node7_2_4 8517647.058823531
R_7_1_4_3 Node7_1_4 Node8_1_4 15.75424
C_7_1_4 Node7_1_4 GND 2.9036132812500003e-10
R_7_1_5_1 Node7_1_5 Node7_1_6 8517647.058823531
R_7_1_5_2 Node7_1_5 Node7_2_5 8517647.058823531
R_7_1_5_3 Node7_1_5 Node8_1_5 15.75424
C_7_1_5 Node7_1_5 GND 2.9036132812500003e-10
R_7_1_6_1 Node7_1_6 Node7_1_7 8517647.058823531
R_7_1_6_2 Node7_1_6 Node7_2_6 8517647.058823531
R_7_1_6_3 Node7_1_6 Node8_1_6 15.75424
C_7_1_6 Node7_1_6 GND 2.9036132812500003e-10
R_7_1_7_1 Node7_1_7 Node7_1_8 8517647.058823531
R_7_1_7_2 Node7_1_7 Node7_2_7 8517647.058823531
R_7_1_7_3 Node7_1_7 Node8_1_7 15.75424
C_7_1_7 Node7_1_7 GND 2.9036132812500003e-10
R_7_1_8_1 Node7_1_8 Node7_1_9 8517647.058823531
R_7_1_8_2 Node7_1_8 Node7_2_8 8517647.058823531
R_7_1_8_3 Node7_1_8 Node8_1_8 15.75424
C_7_1_8 Node7_1_8 GND 2.9036132812500003e-10
R_7_1_9_1 Node7_1_9 Node7_1_10 8517647.058823531
R_7_1_9_2 Node7_1_9 Node7_2_9 8517647.058823531
R_7_1_9_3 Node7_1_9 Node8_1_9 15.75424
C_7_1_9 Node7_1_9 GND 2.9036132812500003e-10
R_7_1_10_1 Node7_1_10 Node7_1_11 8517647.058823531
R_7_1_10_2 Node7_1_10 Node7_2_10 8517647.058823531
R_7_1_10_3 Node7_1_10 Node8_1_10 15.75424
C_7_1_10 Node7_1_10 GND 2.9036132812500003e-10
R_7_1_11_1 Node7_1_11 Node7_1_12 8517647.058823531
R_7_1_11_2 Node7_1_11 Node7_2_11 8517647.058823531
R_7_1_11_3 Node7_1_11 Node8_1_11 15.75424
C_7_1_11 Node7_1_11 GND 2.9036132812500003e-10
R_7_1_12_1 Node7_1_12 Node7_1_13 8517647.058823531
R_7_1_12_2 Node7_1_12 Node7_2_12 8517647.058823531
R_7_1_12_3 Node7_1_12 Node8_1_12 15.75424
C_7_1_12 Node7_1_12 GND 2.9036132812500003e-10
R_7_1_13_1 Node7_1_13 Node7_1_14 8517647.058823531
R_7_1_13_2 Node7_1_13 Node7_2_13 8517647.058823531
R_7_1_13_3 Node7_1_13 Node8_1_13 15.75424
C_7_1_13 Node7_1_13 GND 2.9036132812500003e-10
R_7_1_14_1 Node7_1_14 Node7_1_15 8517647.058823528
R_7_1_14_2 Node7_1_14 Node7_2_14 8517647.058823531
R_7_1_14_3 Node7_1_14 Node8_1_14 15.75424
C_7_1_14 Node7_1_14 GND 2.9036132812500003e-10
R_7_1_15_2 Node7_1_15 Node7_2_15 8517647.058823524
R_7_1_15_3 Node7_1_15 Node8_1_15 15.754239999999987
C_7_1_15 Node7_1_15 GND 2.903613281250003e-10
R_7_2_0_1 Node7_2_0 Node7_2_1 8517647.058823531
R_7_2_0_2 Node7_2_0 Node7_3_0 8517647.058823531
R_7_2_0_3 Node7_2_0 Node8_2_0 15.75424
C_7_2_0 Node7_2_0 GND 2.9036132812500003e-10
R_7_2_1_1 Node7_2_1 Node7_2_2 8517647.058823531
R_7_2_1_2 Node7_2_1 Node7_3_1 8517647.058823531
R_7_2_1_3 Node7_2_1 Node8_2_1 15.75424
C_7_2_1 Node7_2_1 GND 2.9036132812500003e-10
R_7_2_2_1 Node7_2_2 Node7_2_3 8517647.058823531
R_7_2_2_2 Node7_2_2 Node7_3_2 8517647.058823531
R_7_2_2_3 Node7_2_2 Node8_2_2 15.75424
C_7_2_2 Node7_2_2 GND 2.9036132812500003e-10
R_7_2_3_1 Node7_2_3 Node7_2_4 8517647.058823531
R_7_2_3_2 Node7_2_3 Node7_3_3 8517647.058823531
R_7_2_3_3 Node7_2_3 Node8_2_3 15.75424
C_7_2_3 Node7_2_3 GND 2.9036132812500003e-10
R_7_2_4_1 Node7_2_4 Node7_2_5 8517647.058823531
R_7_2_4_2 Node7_2_4 Node7_3_4 8517647.058823531
R_7_2_4_3 Node7_2_4 Node8_2_4 15.75424
C_7_2_4 Node7_2_4 GND 2.9036132812500003e-10
R_7_2_5_1 Node7_2_5 Node7_2_6 8517647.058823531
R_7_2_5_2 Node7_2_5 Node7_3_5 8517647.058823531
R_7_2_5_3 Node7_2_5 Node8_2_5 15.75424
C_7_2_5 Node7_2_5 GND 2.9036132812500003e-10
R_7_2_6_1 Node7_2_6 Node7_2_7 8517647.058823531
R_7_2_6_2 Node7_2_6 Node7_3_6 8517647.058823531
R_7_2_6_3 Node7_2_6 Node8_2_6 15.75424
C_7_2_6 Node7_2_6 GND 2.9036132812500003e-10
R_7_2_7_1 Node7_2_7 Node7_2_8 8517647.058823531
R_7_2_7_2 Node7_2_7 Node7_3_7 8517647.058823531
R_7_2_7_3 Node7_2_7 Node8_2_7 15.75424
C_7_2_7 Node7_2_7 GND 2.9036132812500003e-10
R_7_2_8_1 Node7_2_8 Node7_2_9 8517647.058823531
R_7_2_8_2 Node7_2_8 Node7_3_8 8517647.058823531
R_7_2_8_3 Node7_2_8 Node8_2_8 15.75424
C_7_2_8 Node7_2_8 GND 2.9036132812500003e-10
R_7_2_9_1 Node7_2_9 Node7_2_10 8517647.058823531
R_7_2_9_2 Node7_2_9 Node7_3_9 8517647.058823531
R_7_2_9_3 Node7_2_9 Node8_2_9 15.75424
C_7_2_9 Node7_2_9 GND 2.9036132812500003e-10
R_7_2_10_1 Node7_2_10 Node7_2_11 8517647.058823531
R_7_2_10_2 Node7_2_10 Node7_3_10 8517647.058823531
R_7_2_10_3 Node7_2_10 Node8_2_10 15.75424
C_7_2_10 Node7_2_10 GND 2.9036132812500003e-10
R_7_2_11_1 Node7_2_11 Node7_2_12 8517647.058823531
R_7_2_11_2 Node7_2_11 Node7_3_11 8517647.058823531
R_7_2_11_3 Node7_2_11 Node8_2_11 15.75424
C_7_2_11 Node7_2_11 GND 2.9036132812500003e-10
R_7_2_12_1 Node7_2_12 Node7_2_13 8517647.058823531
R_7_2_12_2 Node7_2_12 Node7_3_12 8517647.058823531
R_7_2_12_3 Node7_2_12 Node8_2_12 15.75424
C_7_2_12 Node7_2_12 GND 2.9036132812500003e-10
R_7_2_13_1 Node7_2_13 Node7_2_14 8517647.058823531
R_7_2_13_2 Node7_2_13 Node7_3_13 8517647.058823531
R_7_2_13_3 Node7_2_13 Node8_2_13 15.75424
C_7_2_13 Node7_2_13 GND 2.9036132812500003e-10
R_7_2_14_1 Node7_2_14 Node7_2_15 8517647.058823528
R_7_2_14_2 Node7_2_14 Node7_3_14 8517647.058823531
R_7_2_14_3 Node7_2_14 Node8_2_14 15.75424
C_7_2_14 Node7_2_14 GND 2.9036132812500003e-10
R_7_2_15_2 Node7_2_15 Node7_3_15 8517647.058823524
R_7_2_15_3 Node7_2_15 Node8_2_15 15.754239999999987
C_7_2_15 Node7_2_15 GND 2.903613281250003e-10
R_7_3_0_1 Node7_3_0 Node7_3_1 8517647.058823531
R_7_3_0_2 Node7_3_0 Node7_4_0 8517647.058823531
R_7_3_0_3 Node7_3_0 Node8_3_0 15.75424
C_7_3_0 Node7_3_0 GND 2.9036132812500003e-10
R_7_3_1_1 Node7_3_1 Node7_3_2 8517647.058823531
R_7_3_1_2 Node7_3_1 Node7_4_1 8517647.058823531
R_7_3_1_3 Node7_3_1 Node8_3_1 15.75424
C_7_3_1 Node7_3_1 GND 2.9036132812500003e-10
R_7_3_2_1 Node7_3_2 Node7_3_3 8517647.058823531
R_7_3_2_2 Node7_3_2 Node7_4_2 8517647.058823531
R_7_3_2_3 Node7_3_2 Node8_3_2 15.75424
C_7_3_2 Node7_3_2 GND 2.9036132812500003e-10
R_7_3_3_1 Node7_3_3 Node7_3_4 8517647.058823531
R_7_3_3_2 Node7_3_3 Node7_4_3 8517647.058823531
R_7_3_3_3 Node7_3_3 Node8_3_3 15.75424
C_7_3_3 Node7_3_3 GND 2.9036132812500003e-10
R_7_3_4_1 Node7_3_4 Node7_3_5 8517647.058823531
R_7_3_4_2 Node7_3_4 Node7_4_4 8517647.058823531
R_7_3_4_3 Node7_3_4 Node8_3_4 15.75424
C_7_3_4 Node7_3_4 GND 2.9036132812500003e-10
R_7_3_5_1 Node7_3_5 Node7_3_6 8517647.058823531
R_7_3_5_2 Node7_3_5 Node7_4_5 8517647.058823531
R_7_3_5_3 Node7_3_5 Node8_3_5 15.75424
C_7_3_5 Node7_3_5 GND 2.9036132812500003e-10
R_7_3_6_1 Node7_3_6 Node7_3_7 8517647.058823531
R_7_3_6_2 Node7_3_6 Node7_4_6 8517647.058823531
R_7_3_6_3 Node7_3_6 Node8_3_6 15.75424
C_7_3_6 Node7_3_6 GND 2.9036132812500003e-10
R_7_3_7_1 Node7_3_7 Node7_3_8 8517647.058823531
R_7_3_7_2 Node7_3_7 Node7_4_7 8517647.058823531
R_7_3_7_3 Node7_3_7 Node8_3_7 15.75424
C_7_3_7 Node7_3_7 GND 2.9036132812500003e-10
R_7_3_8_1 Node7_3_8 Node7_3_9 8517647.058823531
R_7_3_8_2 Node7_3_8 Node7_4_8 8517647.058823531
R_7_3_8_3 Node7_3_8 Node8_3_8 15.75424
C_7_3_8 Node7_3_8 GND 2.9036132812500003e-10
R_7_3_9_1 Node7_3_9 Node7_3_10 8517647.058823531
R_7_3_9_2 Node7_3_9 Node7_4_9 8517647.058823531
R_7_3_9_3 Node7_3_9 Node8_3_9 15.75424
C_7_3_9 Node7_3_9 GND 2.9036132812500003e-10
R_7_3_10_1 Node7_3_10 Node7_3_11 8517647.058823531
R_7_3_10_2 Node7_3_10 Node7_4_10 8517647.058823531
R_7_3_10_3 Node7_3_10 Node8_3_10 15.75424
C_7_3_10 Node7_3_10 GND 2.9036132812500003e-10
R_7_3_11_1 Node7_3_11 Node7_3_12 8517647.058823531
R_7_3_11_2 Node7_3_11 Node7_4_11 8517647.058823531
R_7_3_11_3 Node7_3_11 Node8_3_11 15.75424
C_7_3_11 Node7_3_11 GND 2.9036132812500003e-10
R_7_3_12_1 Node7_3_12 Node7_3_13 8517647.058823531
R_7_3_12_2 Node7_3_12 Node7_4_12 8517647.058823531
R_7_3_12_3 Node7_3_12 Node8_3_12 15.75424
C_7_3_12 Node7_3_12 GND 2.9036132812500003e-10
R_7_3_13_1 Node7_3_13 Node7_3_14 8517647.058823531
R_7_3_13_2 Node7_3_13 Node7_4_13 8517647.058823531
R_7_3_13_3 Node7_3_13 Node8_3_13 15.75424
C_7_3_13 Node7_3_13 GND 2.9036132812500003e-10
R_7_3_14_1 Node7_3_14 Node7_3_15 8517647.058823528
R_7_3_14_2 Node7_3_14 Node7_4_14 8517647.058823531
R_7_3_14_3 Node7_3_14 Node8_3_14 15.75424
C_7_3_14 Node7_3_14 GND 2.9036132812500003e-10
R_7_3_15_2 Node7_3_15 Node7_4_15 8517647.058823524
R_7_3_15_3 Node7_3_15 Node8_3_15 15.754239999999987
C_7_3_15 Node7_3_15 GND 2.903613281250003e-10
R_7_4_0_1 Node7_4_0 Node7_4_1 8517647.058823531
R_7_4_0_2 Node7_4_0 Node7_5_0 8517647.058823531
R_7_4_0_3 Node7_4_0 Node8_4_0 15.75424
C_7_4_0 Node7_4_0 GND 2.9036132812500003e-10
R_7_4_1_1 Node7_4_1 Node7_4_2 8517647.058823531
R_7_4_1_2 Node7_4_1 Node7_5_1 8517647.058823531
R_7_4_1_3 Node7_4_1 Node8_4_1 15.75424
C_7_4_1 Node7_4_1 GND 2.9036132812500003e-10
R_7_4_2_1 Node7_4_2 Node7_4_3 8517647.058823531
R_7_4_2_2 Node7_4_2 Node7_5_2 8517647.058823531
R_7_4_2_3 Node7_4_2 Node8_4_2 15.75424
C_7_4_2 Node7_4_2 GND 2.9036132812500003e-10
R_7_4_3_1 Node7_4_3 Node7_4_4 8517647.058823531
R_7_4_3_2 Node7_4_3 Node7_5_3 8517647.058823531
R_7_4_3_3 Node7_4_3 Node8_4_3 15.75424
C_7_4_3 Node7_4_3 GND 2.9036132812500003e-10
R_7_4_4_1 Node7_4_4 Node7_4_5 8517647.058823531
R_7_4_4_2 Node7_4_4 Node7_5_4 8517647.058823531
R_7_4_4_3 Node7_4_4 Node8_4_4 15.75424
C_7_4_4 Node7_4_4 GND 2.9036132812500003e-10
R_7_4_5_1 Node7_4_5 Node7_4_6 8517647.058823531
R_7_4_5_2 Node7_4_5 Node7_5_5 8517647.058823531
R_7_4_5_3 Node7_4_5 Node8_4_5 15.75424
C_7_4_5 Node7_4_5 GND 2.9036132812500003e-10
R_7_4_6_1 Node7_4_6 Node7_4_7 8517647.058823531
R_7_4_6_2 Node7_4_6 Node7_5_6 8517647.058823531
R_7_4_6_3 Node7_4_6 Node8_4_6 15.75424
C_7_4_6 Node7_4_6 GND 2.9036132812500003e-10
R_7_4_7_1 Node7_4_7 Node7_4_8 8517647.058823531
R_7_4_7_2 Node7_4_7 Node7_5_7 8517647.058823531
R_7_4_7_3 Node7_4_7 Node8_4_7 15.75424
C_7_4_7 Node7_4_7 GND 2.9036132812500003e-10
R_7_4_8_1 Node7_4_8 Node7_4_9 8517647.058823531
R_7_4_8_2 Node7_4_8 Node7_5_8 8517647.058823531
R_7_4_8_3 Node7_4_8 Node8_4_8 15.75424
C_7_4_8 Node7_4_8 GND 2.9036132812500003e-10
R_7_4_9_1 Node7_4_9 Node7_4_10 8517647.058823531
R_7_4_9_2 Node7_4_9 Node7_5_9 8517647.058823531
R_7_4_9_3 Node7_4_9 Node8_4_9 15.75424
C_7_4_9 Node7_4_9 GND 2.9036132812500003e-10
R_7_4_10_1 Node7_4_10 Node7_4_11 8517647.058823531
R_7_4_10_2 Node7_4_10 Node7_5_10 8517647.058823531
R_7_4_10_3 Node7_4_10 Node8_4_10 15.75424
C_7_4_10 Node7_4_10 GND 2.9036132812500003e-10
R_7_4_11_1 Node7_4_11 Node7_4_12 8517647.058823531
R_7_4_11_2 Node7_4_11 Node7_5_11 8517647.058823531
R_7_4_11_3 Node7_4_11 Node8_4_11 15.75424
C_7_4_11 Node7_4_11 GND 2.9036132812500003e-10
R_7_4_12_1 Node7_4_12 Node7_4_13 8517647.058823531
R_7_4_12_2 Node7_4_12 Node7_5_12 8517647.058823531
R_7_4_12_3 Node7_4_12 Node8_4_12 15.75424
C_7_4_12 Node7_4_12 GND 2.9036132812500003e-10
R_7_4_13_1 Node7_4_13 Node7_4_14 8517647.058823531
R_7_4_13_2 Node7_4_13 Node7_5_13 8517647.058823531
R_7_4_13_3 Node7_4_13 Node8_4_13 15.75424
C_7_4_13 Node7_4_13 GND 2.9036132812500003e-10
R_7_4_14_1 Node7_4_14 Node7_4_15 8517647.058823528
R_7_4_14_2 Node7_4_14 Node7_5_14 8517647.058823531
R_7_4_14_3 Node7_4_14 Node8_4_14 15.75424
C_7_4_14 Node7_4_14 GND 2.9036132812500003e-10
R_7_4_15_2 Node7_4_15 Node7_5_15 8517647.058823524
R_7_4_15_3 Node7_4_15 Node8_4_15 15.754239999999987
C_7_4_15 Node7_4_15 GND 2.903613281250003e-10
R_7_5_0_1 Node7_5_0 Node7_5_1 8517647.058823531
R_7_5_0_2 Node7_5_0 Node7_6_0 8517647.058823531
R_7_5_0_3 Node7_5_0 Node8_5_0 15.75424
C_7_5_0 Node7_5_0 GND 2.9036132812500003e-10
R_7_5_1_1 Node7_5_1 Node7_5_2 8517647.058823531
R_7_5_1_2 Node7_5_1 Node7_6_1 8517647.058823533
R_7_5_1_3 Node7_5_1 Node8_5_1 15.75424
C_7_5_1 Node7_5_1 GND 2.9036132812500003e-10
R_7_5_2_1 Node7_5_2 Node7_5_3 8517647.058823531
R_7_5_2_2 Node7_5_2 Node7_6_2 8517647.058823533
R_7_5_2_3 Node7_5_2 Node8_5_2 15.75424
C_7_5_2 Node7_5_2 GND 2.9036132812500003e-10
R_7_5_3_1 Node7_5_3 Node7_5_4 8517647.058823531
R_7_5_3_2 Node7_5_3 Node7_6_3 8517647.058823533
R_7_5_3_3 Node7_5_3 Node8_5_3 15.75424
C_7_5_3 Node7_5_3 GND 2.9036132812500003e-10
R_7_5_4_1 Node7_5_4 Node7_5_5 8517647.058823531
R_7_5_4_2 Node7_5_4 Node7_6_4 8517647.058823533
R_7_5_4_3 Node7_5_4 Node8_5_4 15.75424
C_7_5_4 Node7_5_4 GND 2.9036132812500003e-10
R_7_5_5_1 Node7_5_5 Node7_5_6 8517647.058823531
R_7_5_5_2 Node7_5_5 Node7_6_5 8517647.058823533
R_7_5_5_3 Node7_5_5 Node8_5_5 15.75424
C_7_5_5 Node7_5_5 GND 2.9036132812500003e-10
R_7_5_6_1 Node7_5_6 Node7_5_7 8517647.058823531
R_7_5_6_2 Node7_5_6 Node7_6_6 8517647.058823531
R_7_5_6_3 Node7_5_6 Node8_5_6 15.75424
C_7_5_6 Node7_5_6 GND 2.9036132812500003e-10
R_7_5_7_1 Node7_5_7 Node7_5_8 8517647.058823531
R_7_5_7_2 Node7_5_7 Node7_6_7 8517647.058823533
R_7_5_7_3 Node7_5_7 Node8_5_7 15.75424
C_7_5_7 Node7_5_7 GND 2.9036132812500003e-10
R_7_5_8_1 Node7_5_8 Node7_5_9 8517647.058823531
R_7_5_8_2 Node7_5_8 Node7_6_8 8517647.058823533
R_7_5_8_3 Node7_5_8 Node8_5_8 15.75424
C_7_5_8 Node7_5_8 GND 2.9036132812500003e-10
R_7_5_9_1 Node7_5_9 Node7_5_10 8517647.058823531
R_7_5_9_2 Node7_5_9 Node7_6_9 8517647.05882353
R_7_5_9_3 Node7_5_9 Node8_5_9 15.75424
C_7_5_9 Node7_5_9 GND 2.9036132812500003e-10
R_7_5_10_1 Node7_5_10 Node7_5_11 8517647.058823531
R_7_5_10_2 Node7_5_10 Node7_6_10 8517647.058823533
R_7_5_10_3 Node7_5_10 Node8_5_10 15.75424
C_7_5_10 Node7_5_10 GND 2.9036132812500003e-10
R_7_5_11_1 Node7_5_11 Node7_5_12 8517647.058823531
R_7_5_11_2 Node7_5_11 Node7_6_11 8517647.058823533
R_7_5_11_3 Node7_5_11 Node8_5_11 15.75424
C_7_5_11 Node7_5_11 GND 2.9036132812500003e-10
R_7_5_12_1 Node7_5_12 Node7_5_13 8517647.058823531
R_7_5_12_2 Node7_5_12 Node7_6_12 8517647.058823533
R_7_5_12_3 Node7_5_12 Node8_5_12 15.75424
C_7_5_12 Node7_5_12 GND 2.9036132812500003e-10
R_7_5_13_1 Node7_5_13 Node7_5_14 8517647.058823531
R_7_5_13_2 Node7_5_13 Node7_6_13 8517647.058823533
R_7_5_13_3 Node7_5_13 Node8_5_13 15.75424
C_7_5_13 Node7_5_13 GND 2.9036132812500003e-10
R_7_5_14_1 Node7_5_14 Node7_5_15 8517647.058823528
R_7_5_14_2 Node7_5_14 Node7_6_14 8517647.058823533
R_7_5_14_3 Node7_5_14 Node8_5_14 15.75424
C_7_5_14 Node7_5_14 GND 2.9036132812500003e-10
R_7_5_15_2 Node7_5_15 Node7_6_15 8517647.058823524
R_7_5_15_3 Node7_5_15 Node8_5_15 15.754239999999987
C_7_5_15 Node7_5_15 GND 2.903613281250003e-10
R_7_6_0_1 Node7_6_0 Node7_6_1 8517647.058823533
R_7_6_0_2 Node7_6_0 Node7_7_0 8517647.058823531
R_7_6_0_3 Node7_6_0 Node8_6_0 15.75424
C_7_6_0 Node7_6_0 GND 2.9036132812500003e-10
R_7_6_1_1 Node7_6_1 Node7_6_2 8517647.058823533
R_7_6_1_2 Node7_6_1 Node7_7_1 8517647.058823533
R_7_6_1_3 Node7_6_1 Node8_6_1 15.75424
C_7_6_1 Node7_6_1 GND 2.9036132812500003e-10
R_7_6_2_1 Node7_6_2 Node7_6_3 8517647.058823533
R_7_6_2_2 Node7_6_2 Node7_7_2 8517647.058823533
R_7_6_2_3 Node7_6_2 Node8_6_2 15.75424
C_7_6_2 Node7_6_2 GND 2.9036132812500003e-10
R_7_6_3_1 Node7_6_3 Node7_6_4 8517647.058823533
R_7_6_3_2 Node7_6_3 Node7_7_3 8517647.058823533
R_7_6_3_3 Node7_6_3 Node8_6_3 15.75424
C_7_6_3 Node7_6_3 GND 2.9036132812500003e-10
R_7_6_4_1 Node7_6_4 Node7_6_5 8517647.058823533
R_7_6_4_2 Node7_6_4 Node7_7_4 8517647.058823533
R_7_6_4_3 Node7_6_4 Node8_6_4 15.75424
C_7_6_4 Node7_6_4 GND 2.9036132812500003e-10
R_7_6_5_1 Node7_6_5 Node7_6_6 8517647.058823533
R_7_6_5_2 Node7_6_5 Node7_7_5 8517647.058823533
R_7_6_5_3 Node7_6_5 Node8_6_5 15.75424
C_7_6_5 Node7_6_5 GND 2.9036132812500003e-10
R_7_6_6_1 Node7_6_6 Node7_6_7 8517647.058823533
R_7_6_6_2 Node7_6_6 Node7_7_6 8517647.058823531
R_7_6_6_3 Node7_6_6 Node8_6_6 15.754239999999998
C_7_6_6 Node7_6_6 GND 2.903613281250001e-10
R_7_6_7_1 Node7_6_7 Node7_6_8 8517647.058823533
R_7_6_7_2 Node7_6_7 Node7_7_7 8517647.058823533
R_7_6_7_3 Node7_6_7 Node8_6_7 15.75424
C_7_6_7 Node7_6_7 GND 2.9036132812500003e-10
R_7_6_8_1 Node7_6_8 Node7_6_9 8517647.05882353
R_7_6_8_2 Node7_6_8 Node7_7_8 8517647.058823533
R_7_6_8_3 Node7_6_8 Node8_6_8 15.75424
C_7_6_8 Node7_6_8 GND 2.9036132812500003e-10
R_7_6_9_1 Node7_6_9 Node7_6_10 8517647.05882353
R_7_6_9_2 Node7_6_9 Node7_7_9 8517647.058823526
R_7_6_9_3 Node7_6_9 Node8_6_9 15.75423999999999
C_7_6_9 Node7_6_9 GND 2.903613281250002e-10
R_7_6_10_1 Node7_6_10 Node7_6_11 8517647.058823533
R_7_6_10_2 Node7_6_10 Node7_7_10 8517647.058823533
R_7_6_10_3 Node7_6_10 Node8_6_10 15.75424
C_7_6_10 Node7_6_10 GND 2.9036132812500003e-10
R_7_6_11_1 Node7_6_11 Node7_6_12 8517647.058823533
R_7_6_11_2 Node7_6_11 Node7_7_11 8517647.058823533
R_7_6_11_3 Node7_6_11 Node8_6_11 15.75424
C_7_6_11 Node7_6_11 GND 2.9036132812500003e-10
R_7_6_12_1 Node7_6_12 Node7_6_13 8517647.058823533
R_7_6_12_2 Node7_6_12 Node7_7_12 8517647.058823533
R_7_6_12_3 Node7_6_12 Node8_6_12 15.75424
C_7_6_12 Node7_6_12 GND 2.9036132812500003e-10
R_7_6_13_1 Node7_6_13 Node7_6_14 8517647.058823533
R_7_6_13_2 Node7_6_13 Node7_7_13 8517647.058823533
R_7_6_13_3 Node7_6_13 Node8_6_13 15.75424
C_7_6_13 Node7_6_13 GND 2.9036132812500003e-10
R_7_6_14_1 Node7_6_14 Node7_6_15 8517647.05882353
R_7_6_14_2 Node7_6_14 Node7_7_14 8517647.058823533
R_7_6_14_3 Node7_6_14 Node8_6_14 15.75424
C_7_6_14 Node7_6_14 GND 2.9036132812500003e-10
R_7_6_15_2 Node7_6_15 Node7_7_15 8517647.058823524
R_7_6_15_3 Node7_6_15 Node8_6_15 15.754239999999987
C_7_6_15 Node7_6_15 GND 2.903613281250003e-10
R_7_7_0_1 Node7_7_0 Node7_7_1 8517647.058823531
R_7_7_0_2 Node7_7_0 Node7_8_0 8517647.058823531
R_7_7_0_3 Node7_7_0 Node8_7_0 15.75424
C_7_7_0 Node7_7_0 GND 2.9036132812500003e-10
R_7_7_1_1 Node7_7_1 Node7_7_2 8517647.058823531
R_7_7_1_2 Node7_7_1 Node7_8_1 8517647.058823531
R_7_7_1_3 Node7_7_1 Node8_7_1 15.75424
C_7_7_1 Node7_7_1 GND 2.9036132812500003e-10
R_7_7_2_1 Node7_7_2 Node7_7_3 8517647.058823531
R_7_7_2_2 Node7_7_2 Node7_8_2 8517647.058823531
R_7_7_2_3 Node7_7_2 Node8_7_2 15.75424
C_7_7_2 Node7_7_2 GND 2.9036132812500003e-10
R_7_7_3_1 Node7_7_3 Node7_7_4 8517647.058823531
R_7_7_3_2 Node7_7_3 Node7_8_3 8517647.058823531
R_7_7_3_3 Node7_7_3 Node8_7_3 15.75424
C_7_7_3 Node7_7_3 GND 2.9036132812500003e-10
R_7_7_4_1 Node7_7_4 Node7_7_5 8517647.058823531
R_7_7_4_2 Node7_7_4 Node7_8_4 8517647.058823531
R_7_7_4_3 Node7_7_4 Node8_7_4 15.75424
C_7_7_4 Node7_7_4 GND 2.9036132812500003e-10
R_7_7_5_1 Node7_7_5 Node7_7_6 8517647.058823531
R_7_7_5_2 Node7_7_5 Node7_8_5 8517647.058823531
R_7_7_5_3 Node7_7_5 Node8_7_5 15.75424
C_7_7_5 Node7_7_5 GND 2.9036132812500003e-10
R_7_7_6_1 Node7_7_6 Node7_7_7 8517647.058823531
R_7_7_6_2 Node7_7_6 Node7_8_6 8517647.058823531
R_7_7_6_3 Node7_7_6 Node8_7_6 15.75424
C_7_7_6 Node7_7_6 GND 2.9036132812500003e-10
R_7_7_7_1 Node7_7_7 Node7_7_8 8517647.058823531
R_7_7_7_2 Node7_7_7 Node7_8_7 8517647.058823531
R_7_7_7_3 Node7_7_7 Node8_7_7 15.75424
C_7_7_7 Node7_7_7 GND 2.9036132812500003e-10
R_7_7_8_1 Node7_7_8 Node7_7_9 8517647.05882353
R_7_7_8_2 Node7_7_8 Node7_8_8 8517647.058823531
R_7_7_8_3 Node7_7_8 Node8_7_8 15.75424
C_7_7_8 Node7_7_8 GND 2.9036132812500003e-10
R_7_7_9_1 Node7_7_9 Node7_7_10 8517647.05882353
R_7_7_9_2 Node7_7_9 Node7_8_9 8517647.058823526
R_7_7_9_3 Node7_7_9 Node8_7_9 15.754239999999987
C_7_7_9 Node7_7_9 GND 2.903613281250003e-10
R_7_7_10_1 Node7_7_10 Node7_7_11 8517647.058823531
R_7_7_10_2 Node7_7_10 Node7_8_10 8517647.058823531
R_7_7_10_3 Node7_7_10 Node8_7_10 15.75424
C_7_7_10 Node7_7_10 GND 2.9036132812500003e-10
R_7_7_11_1 Node7_7_11 Node7_7_12 8517647.058823531
R_7_7_11_2 Node7_7_11 Node7_8_11 8517647.058823531
R_7_7_11_3 Node7_7_11 Node8_7_11 15.75424
C_7_7_11 Node7_7_11 GND 2.9036132812500003e-10
R_7_7_12_1 Node7_7_12 Node7_7_13 8517647.058823531
R_7_7_12_2 Node7_7_12 Node7_8_12 8517647.058823531
R_7_7_12_3 Node7_7_12 Node8_7_12 15.75424
C_7_7_12 Node7_7_12 GND 2.9036132812500003e-10
R_7_7_13_1 Node7_7_13 Node7_7_14 8517647.058823531
R_7_7_13_2 Node7_7_13 Node7_8_13 8517647.058823531
R_7_7_13_3 Node7_7_13 Node8_7_13 15.75424
C_7_7_13 Node7_7_13 GND 2.9036132812500003e-10
R_7_7_14_1 Node7_7_14 Node7_7_15 8517647.058823528
R_7_7_14_2 Node7_7_14 Node7_8_14 8517647.058823531
R_7_7_14_3 Node7_7_14 Node8_7_14 15.75424
C_7_7_14 Node7_7_14 GND 2.9036132812500003e-10
R_7_7_15_2 Node7_7_15 Node7_8_15 8517647.058823524
R_7_7_15_3 Node7_7_15 Node8_7_15 15.754239999999987
C_7_7_15 Node7_7_15 GND 2.903613281250003e-10
R_7_8_0_1 Node7_8_0 Node7_8_1 8517647.058823531
R_7_8_0_2 Node7_8_0 Node7_9_0 8517647.058823535
R_7_8_0_3 Node7_8_0 Node8_8_0 15.75424
C_7_8_0 Node7_8_0 GND 2.9036132812500003e-10
R_7_8_1_1 Node7_8_1 Node7_8_2 8517647.058823531
R_7_8_1_2 Node7_8_1 Node7_9_1 8517647.058823535
R_7_8_1_3 Node7_8_1 Node8_8_1 15.75424
C_7_8_1 Node7_8_1 GND 2.9036132812500003e-10
R_7_8_2_1 Node7_8_2 Node7_8_3 8517647.058823531
R_7_8_2_2 Node7_8_2 Node7_9_2 8517647.058823535
R_7_8_2_3 Node7_8_2 Node8_8_2 15.75424
C_7_8_2 Node7_8_2 GND 2.9036132812500003e-10
R_7_8_3_1 Node7_8_3 Node7_8_4 8517647.058823531
R_7_8_3_2 Node7_8_3 Node7_9_3 8517647.058823535
R_7_8_3_3 Node7_8_3 Node8_8_3 15.75424
C_7_8_3 Node7_8_3 GND 2.9036132812500003e-10
R_7_8_4_1 Node7_8_4 Node7_8_5 8517647.058823531
R_7_8_4_2 Node7_8_4 Node7_9_4 8517647.058823535
R_7_8_4_3 Node7_8_4 Node8_8_4 15.75424
C_7_8_4 Node7_8_4 GND 2.9036132812500003e-10
R_7_8_5_1 Node7_8_5 Node7_8_6 8517647.058823531
R_7_8_5_2 Node7_8_5 Node7_9_5 8517647.058823535
R_7_8_5_3 Node7_8_5 Node8_8_5 15.75424
C_7_8_5 Node7_8_5 GND 2.9036132812500003e-10
R_7_8_6_1 Node7_8_6 Node7_8_7 8517647.058823531
R_7_8_6_2 Node7_8_6 Node7_9_6 8517647.058823535
R_7_8_6_3 Node7_8_6 Node8_8_6 15.75424
C_7_8_6 Node7_8_6 GND 2.9036132812500003e-10
R_7_8_7_1 Node7_8_7 Node7_8_8 8517647.058823531
R_7_8_7_2 Node7_8_7 Node7_9_7 8517647.058823535
R_7_8_7_3 Node7_8_7 Node8_8_7 15.75424
C_7_8_7 Node7_8_7 GND 2.9036132812500003e-10
R_7_8_8_1 Node7_8_8 Node7_8_9 8517647.05882353
R_7_8_8_2 Node7_8_8 Node7_9_8 8517647.058823535
R_7_8_8_3 Node7_8_8 Node8_8_8 15.75424
C_7_8_8 Node7_8_8 GND 2.9036132812500003e-10
R_7_8_9_1 Node7_8_9 Node7_8_10 8517647.05882353
R_7_8_9_2 Node7_8_9 Node7_9_9 8517647.05882353
R_7_8_9_3 Node7_8_9 Node8_8_9 15.754239999999987
C_7_8_9 Node7_8_9 GND 2.903613281250003e-10
R_7_8_10_1 Node7_8_10 Node7_8_11 8517647.058823531
R_7_8_10_2 Node7_8_10 Node7_9_10 8517647.058823535
R_7_8_10_3 Node7_8_10 Node8_8_10 15.75424
C_7_8_10 Node7_8_10 GND 2.9036132812500003e-10
R_7_8_11_1 Node7_8_11 Node7_8_12 8517647.058823531
R_7_8_11_2 Node7_8_11 Node7_9_11 8517647.058823535
R_7_8_11_3 Node7_8_11 Node8_8_11 15.75424
C_7_8_11 Node7_8_11 GND 2.9036132812500003e-10
R_7_8_12_1 Node7_8_12 Node7_8_13 8517647.058823531
R_7_8_12_2 Node7_8_12 Node7_9_12 8517647.058823535
R_7_8_12_3 Node7_8_12 Node8_8_12 15.75424
C_7_8_12 Node7_8_12 GND 2.9036132812500003e-10
R_7_8_13_1 Node7_8_13 Node7_8_14 8517647.058823531
R_7_8_13_2 Node7_8_13 Node7_9_13 8517647.058823535
R_7_8_13_3 Node7_8_13 Node8_8_13 15.75424
C_7_8_13 Node7_8_13 GND 2.9036132812500003e-10
R_7_8_14_1 Node7_8_14 Node7_8_15 8517647.058823528
R_7_8_14_2 Node7_8_14 Node7_9_14 8517647.058823535
R_7_8_14_3 Node7_8_14 Node8_8_14 15.75424
C_7_8_14 Node7_8_14 GND 2.9036132812500003e-10
R_7_8_15_2 Node7_8_15 Node7_9_15 8517647.058823528
R_7_8_15_3 Node7_8_15 Node8_8_15 15.754239999999987
C_7_8_15 Node7_8_15 GND 2.903613281250003e-10
R_7_9_0_1 Node7_9_0 Node7_9_1 8517647.058823539
R_7_9_0_2 Node7_9_0 Node7_10_0 8517647.058823535
R_7_9_0_3 Node7_9_0 Node8_9_0 15.754240000000014
C_7_9_0 Node7_9_0 GND 2.903613281249998e-10
R_7_9_1_1 Node7_9_1 Node7_9_2 8517647.058823539
R_7_9_1_2 Node7_9_1 Node7_10_1 8517647.058823535
R_7_9_1_3 Node7_9_1 Node8_9_1 15.754240000000014
C_7_9_1 Node7_9_1 GND 2.9036132812499977e-10
R_7_9_2_1 Node7_9_2 Node7_9_3 8517647.058823539
R_7_9_2_2 Node7_9_2 Node7_10_2 8517647.058823535
R_7_9_2_3 Node7_9_2 Node8_9_2 15.754240000000014
C_7_9_2 Node7_9_2 GND 2.9036132812499977e-10
R_7_9_3_1 Node7_9_3 Node7_9_4 8517647.058823539
R_7_9_3_2 Node7_9_3 Node7_10_3 8517647.058823535
R_7_9_3_3 Node7_9_3 Node8_9_3 15.754240000000014
C_7_9_3 Node7_9_3 GND 2.9036132812499977e-10
R_7_9_4_1 Node7_9_4 Node7_9_5 8517647.058823539
R_7_9_4_2 Node7_9_4 Node7_10_4 8517647.058823535
R_7_9_4_3 Node7_9_4 Node8_9_4 15.754240000000014
C_7_9_4 Node7_9_4 GND 2.9036132812499977e-10
R_7_9_5_1 Node7_9_5 Node7_9_6 8517647.058823539
R_7_9_5_2 Node7_9_5 Node7_10_5 8517647.058823535
R_7_9_5_3 Node7_9_5 Node8_9_5 15.754240000000014
C_7_9_5 Node7_9_5 GND 2.9036132812499977e-10
R_7_9_6_1 Node7_9_6 Node7_9_7 8517647.058823539
R_7_9_6_2 Node7_9_6 Node7_10_6 8517647.058823535
R_7_9_6_3 Node7_9_6 Node8_9_6 15.754240000000014
C_7_9_6 Node7_9_6 GND 2.9036132812499977e-10
R_7_9_7_1 Node7_9_7 Node7_9_8 8517647.058823539
R_7_9_7_2 Node7_9_7 Node7_10_7 8517647.058823535
R_7_9_7_3 Node7_9_7 Node8_9_7 15.754240000000014
C_7_9_7 Node7_9_7 GND 2.9036132812499977e-10
R_7_9_8_1 Node7_9_8 Node7_9_9 8517647.058823537
R_7_9_8_2 Node7_9_8 Node7_10_8 8517647.058823535
R_7_9_8_3 Node7_9_8 Node8_9_8 15.754240000000014
C_7_9_8 Node7_9_8 GND 2.9036132812499977e-10
R_7_9_9_1 Node7_9_9 Node7_9_10 8517647.058823537
R_7_9_9_2 Node7_9_9 Node7_10_9 8517647.058823533
R_7_9_9_3 Node7_9_9 Node8_9_9 15.754240000000003
C_7_9_9 Node7_9_9 GND 2.903613281249999e-10
R_7_9_10_1 Node7_9_10 Node7_9_11 8517647.058823539
R_7_9_10_2 Node7_9_10 Node7_10_10 8517647.058823535
R_7_9_10_3 Node7_9_10 Node8_9_10 15.754240000000014
C_7_9_10 Node7_9_10 GND 2.9036132812499977e-10
R_7_9_11_1 Node7_9_11 Node7_9_12 8517647.058823539
R_7_9_11_2 Node7_9_11 Node7_10_11 8517647.058823535
R_7_9_11_3 Node7_9_11 Node8_9_11 15.754240000000014
C_7_9_11 Node7_9_11 GND 2.9036132812499977e-10
R_7_9_12_1 Node7_9_12 Node7_9_13 8517647.058823539
R_7_9_12_2 Node7_9_12 Node7_10_12 8517647.058823535
R_7_9_12_3 Node7_9_12 Node8_9_12 15.754240000000014
C_7_9_12 Node7_9_12 GND 2.9036132812499977e-10
R_7_9_13_1 Node7_9_13 Node7_9_14 8517647.058823539
R_7_9_13_2 Node7_9_13 Node7_10_13 8517647.058823535
R_7_9_13_3 Node7_9_13 Node8_9_13 15.754240000000014
C_7_9_13 Node7_9_13 GND 2.9036132812499977e-10
R_7_9_14_1 Node7_9_14 Node7_9_15 8517647.058823535
R_7_9_14_2 Node7_9_14 Node7_10_14 8517647.058823535
R_7_9_14_3 Node7_9_14 Node8_9_14 15.754240000000014
C_7_9_14 Node7_9_14 GND 2.9036132812499977e-10
R_7_9_15_2 Node7_9_15 Node7_10_15 8517647.058823528
R_7_9_15_3 Node7_9_15 Node8_9_15 15.75424
C_7_9_15 Node7_9_15 GND 2.9036132812500003e-10
R_7_10_0_1 Node7_10_0 Node7_10_1 8517647.058823531
R_7_10_0_2 Node7_10_0 Node7_11_0 8517647.058823531
R_7_10_0_3 Node7_10_0 Node8_10_0 15.75424
C_7_10_0 Node7_10_0 GND 2.9036132812500003e-10
R_7_10_1_1 Node7_10_1 Node7_10_2 8517647.058823531
R_7_10_1_2 Node7_10_1 Node7_11_1 8517647.058823531
R_7_10_1_3 Node7_10_1 Node8_10_1 15.75424
C_7_10_1 Node7_10_1 GND 2.9036132812500003e-10
R_7_10_2_1 Node7_10_2 Node7_10_3 8517647.058823531
R_7_10_2_2 Node7_10_2 Node7_11_2 8517647.058823531
R_7_10_2_3 Node7_10_2 Node8_10_2 15.75424
C_7_10_2 Node7_10_2 GND 2.9036132812500003e-10
R_7_10_3_1 Node7_10_3 Node7_10_4 8517647.058823531
R_7_10_3_2 Node7_10_3 Node7_11_3 8517647.058823531
R_7_10_3_3 Node7_10_3 Node8_10_3 15.75424
C_7_10_3 Node7_10_3 GND 2.9036132812500003e-10
R_7_10_4_1 Node7_10_4 Node7_10_5 8517647.058823531
R_7_10_4_2 Node7_10_4 Node7_11_4 8517647.058823531
R_7_10_4_3 Node7_10_4 Node8_10_4 15.75424
C_7_10_4 Node7_10_4 GND 2.9036132812500003e-10
R_7_10_5_1 Node7_10_5 Node7_10_6 8517647.058823531
R_7_10_5_2 Node7_10_5 Node7_11_5 8517647.058823531
R_7_10_5_3 Node7_10_5 Node8_10_5 15.75424
C_7_10_5 Node7_10_5 GND 2.9036132812500003e-10
R_7_10_6_1 Node7_10_6 Node7_10_7 8517647.058823531
R_7_10_6_2 Node7_10_6 Node7_11_6 8517647.058823531
R_7_10_6_3 Node7_10_6 Node8_10_6 15.75424
C_7_10_6 Node7_10_6 GND 2.9036132812500003e-10
R_7_10_7_1 Node7_10_7 Node7_10_8 8517647.058823531
R_7_10_7_2 Node7_10_7 Node7_11_7 8517647.058823531
R_7_10_7_3 Node7_10_7 Node8_10_7 15.75424
C_7_10_7 Node7_10_7 GND 2.9036132812500003e-10
R_7_10_8_1 Node7_10_8 Node7_10_9 8517647.058823531
R_7_10_8_2 Node7_10_8 Node7_11_8 8517647.058823531
R_7_10_8_3 Node7_10_8 Node8_10_8 15.75424
C_7_10_8 Node7_10_8 GND 2.9036132812500003e-10
R_7_10_9_1 Node7_10_9 Node7_10_10 8517647.058823531
R_7_10_9_2 Node7_10_9 Node7_11_9 8517647.058823531
R_7_10_9_3 Node7_10_9 Node8_10_9 15.75424
C_7_10_9 Node7_10_9 GND 2.9036132812500003e-10
R_7_10_10_1 Node7_10_10 Node7_10_11 8517647.058823531
R_7_10_10_2 Node7_10_10 Node7_11_10 8517647.058823531
R_7_10_10_3 Node7_10_10 Node8_10_10 15.75424
C_7_10_10 Node7_10_10 GND 2.9036132812500003e-10
R_7_10_11_1 Node7_10_11 Node7_10_12 8517647.058823531
R_7_10_11_2 Node7_10_11 Node7_11_11 8517647.058823531
R_7_10_11_3 Node7_10_11 Node8_10_11 15.75424
C_7_10_11 Node7_10_11 GND 2.9036132812500003e-10
R_7_10_12_1 Node7_10_12 Node7_10_13 8517647.058823531
R_7_10_12_2 Node7_10_12 Node7_11_12 8517647.058823531
R_7_10_12_3 Node7_10_12 Node8_10_12 15.75424
C_7_10_12 Node7_10_12 GND 2.9036132812500003e-10
R_7_10_13_1 Node7_10_13 Node7_10_14 8517647.058823531
R_7_10_13_2 Node7_10_13 Node7_11_13 8517647.058823531
R_7_10_13_3 Node7_10_13 Node8_10_13 15.75424
C_7_10_13 Node7_10_13 GND 2.9036132812500003e-10
R_7_10_14_1 Node7_10_14 Node7_10_15 8517647.058823528
R_7_10_14_2 Node7_10_14 Node7_11_14 8517647.058823531
R_7_10_14_3 Node7_10_14 Node8_10_14 15.75424
C_7_10_14 Node7_10_14 GND 2.9036132812500003e-10
R_7_10_15_2 Node7_10_15 Node7_11_15 8517647.058823524
R_7_10_15_3 Node7_10_15 Node8_10_15 15.754239999999987
C_7_10_15 Node7_10_15 GND 2.903613281250003e-10
R_7_11_0_1 Node7_11_0 Node7_11_1 8517647.058823531
R_7_11_0_2 Node7_11_0 Node7_12_0 8517647.058823531
R_7_11_0_3 Node7_11_0 Node8_11_0 15.75424
C_7_11_0 Node7_11_0 GND 2.9036132812500003e-10
R_7_11_1_1 Node7_11_1 Node7_11_2 8517647.058823531
R_7_11_1_2 Node7_11_1 Node7_12_1 8517647.058823531
R_7_11_1_3 Node7_11_1 Node8_11_1 15.75424
C_7_11_1 Node7_11_1 GND 2.9036132812500003e-10
R_7_11_2_1 Node7_11_2 Node7_11_3 8517647.058823531
R_7_11_2_2 Node7_11_2 Node7_12_2 8517647.058823531
R_7_11_2_3 Node7_11_2 Node8_11_2 15.75424
C_7_11_2 Node7_11_2 GND 2.9036132812500003e-10
R_7_11_3_1 Node7_11_3 Node7_11_4 8517647.058823531
R_7_11_3_2 Node7_11_3 Node7_12_3 8517647.058823531
R_7_11_3_3 Node7_11_3 Node8_11_3 15.75424
C_7_11_3 Node7_11_3 GND 2.9036132812500003e-10
R_7_11_4_1 Node7_11_4 Node7_11_5 8517647.058823531
R_7_11_4_2 Node7_11_4 Node7_12_4 8517647.058823531
R_7_11_4_3 Node7_11_4 Node8_11_4 15.75424
C_7_11_4 Node7_11_4 GND 2.9036132812500003e-10
R_7_11_5_1 Node7_11_5 Node7_11_6 8517647.058823531
R_7_11_5_2 Node7_11_5 Node7_12_5 8517647.058823531
R_7_11_5_3 Node7_11_5 Node8_11_5 15.75424
C_7_11_5 Node7_11_5 GND 2.9036132812500003e-10
R_7_11_6_1 Node7_11_6 Node7_11_7 8517647.058823531
R_7_11_6_2 Node7_11_6 Node7_12_6 8517647.058823531
R_7_11_6_3 Node7_11_6 Node8_11_6 15.75424
C_7_11_6 Node7_11_6 GND 2.9036132812500003e-10
R_7_11_7_1 Node7_11_7 Node7_11_8 8517647.058823531
R_7_11_7_2 Node7_11_7 Node7_12_7 8517647.058823531
R_7_11_7_3 Node7_11_7 Node8_11_7 15.75424
C_7_11_7 Node7_11_7 GND 2.9036132812500003e-10
R_7_11_8_1 Node7_11_8 Node7_11_9 8517647.058823531
R_7_11_8_2 Node7_11_8 Node7_12_8 8517647.058823531
R_7_11_8_3 Node7_11_8 Node8_11_8 15.75424
C_7_11_8 Node7_11_8 GND 2.9036132812500003e-10
R_7_11_9_1 Node7_11_9 Node7_11_10 8517647.058823531
R_7_11_9_2 Node7_11_9 Node7_12_9 8517647.058823531
R_7_11_9_3 Node7_11_9 Node8_11_9 15.75424
C_7_11_9 Node7_11_9 GND 2.9036132812500003e-10
R_7_11_10_1 Node7_11_10 Node7_11_11 8517647.058823531
R_7_11_10_2 Node7_11_10 Node7_12_10 8517647.058823531
R_7_11_10_3 Node7_11_10 Node8_11_10 15.75424
C_7_11_10 Node7_11_10 GND 2.9036132812500003e-10
R_7_11_11_1 Node7_11_11 Node7_11_12 8517647.058823531
R_7_11_11_2 Node7_11_11 Node7_12_11 8517647.058823531
R_7_11_11_3 Node7_11_11 Node8_11_11 15.75424
C_7_11_11 Node7_11_11 GND 2.9036132812500003e-10
R_7_11_12_1 Node7_11_12 Node7_11_13 8517647.058823531
R_7_11_12_2 Node7_11_12 Node7_12_12 8517647.058823531
R_7_11_12_3 Node7_11_12 Node8_11_12 15.75424
C_7_11_12 Node7_11_12 GND 2.9036132812500003e-10
R_7_11_13_1 Node7_11_13 Node7_11_14 8517647.058823531
R_7_11_13_2 Node7_11_13 Node7_12_13 8517647.058823531
R_7_11_13_3 Node7_11_13 Node8_11_13 15.75424
C_7_11_13 Node7_11_13 GND 2.9036132812500003e-10
R_7_11_14_1 Node7_11_14 Node7_11_15 8517647.058823528
R_7_11_14_2 Node7_11_14 Node7_12_14 8517647.058823531
R_7_11_14_3 Node7_11_14 Node8_11_14 15.75424
C_7_11_14 Node7_11_14 GND 2.9036132812500003e-10
R_7_11_15_2 Node7_11_15 Node7_12_15 8517647.058823524
R_7_11_15_3 Node7_11_15 Node8_11_15 15.754239999999987
C_7_11_15 Node7_11_15 GND 2.903613281250003e-10
R_7_12_0_1 Node7_12_0 Node7_12_1 8517647.058823531
R_7_12_0_2 Node7_12_0 Node7_13_0 8517647.058823531
R_7_12_0_3 Node7_12_0 Node8_12_0 15.75424
C_7_12_0 Node7_12_0 GND 2.9036132812500003e-10
R_7_12_1_1 Node7_12_1 Node7_12_2 8517647.058823531
R_7_12_1_2 Node7_12_1 Node7_13_1 8517647.058823531
R_7_12_1_3 Node7_12_1 Node8_12_1 15.75424
C_7_12_1 Node7_12_1 GND 2.9036132812500003e-10
R_7_12_2_1 Node7_12_2 Node7_12_3 8517647.058823531
R_7_12_2_2 Node7_12_2 Node7_13_2 8517647.058823531
R_7_12_2_3 Node7_12_2 Node8_12_2 15.75424
C_7_12_2 Node7_12_2 GND 2.9036132812500003e-10
R_7_12_3_1 Node7_12_3 Node7_12_4 8517647.058823531
R_7_12_3_2 Node7_12_3 Node7_13_3 8517647.058823531
R_7_12_3_3 Node7_12_3 Node8_12_3 15.75424
C_7_12_3 Node7_12_3 GND 2.9036132812500003e-10
R_7_12_4_1 Node7_12_4 Node7_12_5 8517647.058823531
R_7_12_4_2 Node7_12_4 Node7_13_4 8517647.058823531
R_7_12_4_3 Node7_12_4 Node8_12_4 15.75424
C_7_12_4 Node7_12_4 GND 2.9036132812500003e-10
R_7_12_5_1 Node7_12_5 Node7_12_6 8517647.058823531
R_7_12_5_2 Node7_12_5 Node7_13_5 8517647.058823531
R_7_12_5_3 Node7_12_5 Node8_12_5 15.75424
C_7_12_5 Node7_12_5 GND 2.9036132812500003e-10
R_7_12_6_1 Node7_12_6 Node7_12_7 8517647.058823531
R_7_12_6_2 Node7_12_6 Node7_13_6 8517647.058823531
R_7_12_6_3 Node7_12_6 Node8_12_6 15.75424
C_7_12_6 Node7_12_6 GND 2.9036132812500003e-10
R_7_12_7_1 Node7_12_7 Node7_12_8 8517647.058823531
R_7_12_7_2 Node7_12_7 Node7_13_7 8517647.058823531
R_7_12_7_3 Node7_12_7 Node8_12_7 15.75424
C_7_12_7 Node7_12_7 GND 2.9036132812500003e-10
R_7_12_8_1 Node7_12_8 Node7_12_9 8517647.058823531
R_7_12_8_2 Node7_12_8 Node7_13_8 8517647.058823531
R_7_12_8_3 Node7_12_8 Node8_12_8 15.75424
C_7_12_8 Node7_12_8 GND 2.9036132812500003e-10
R_7_12_9_1 Node7_12_9 Node7_12_10 8517647.058823531
R_7_12_9_2 Node7_12_9 Node7_13_9 8517647.058823531
R_7_12_9_3 Node7_12_9 Node8_12_9 15.75424
C_7_12_9 Node7_12_9 GND 2.9036132812500003e-10
R_7_12_10_1 Node7_12_10 Node7_12_11 8517647.058823531
R_7_12_10_2 Node7_12_10 Node7_13_10 8517647.058823531
R_7_12_10_3 Node7_12_10 Node8_12_10 15.75424
C_7_12_10 Node7_12_10 GND 2.9036132812500003e-10
R_7_12_11_1 Node7_12_11 Node7_12_12 8517647.058823531
R_7_12_11_2 Node7_12_11 Node7_13_11 8517647.058823531
R_7_12_11_3 Node7_12_11 Node8_12_11 15.75424
C_7_12_11 Node7_12_11 GND 2.9036132812500003e-10
R_7_12_12_1 Node7_12_12 Node7_12_13 8517647.058823531
R_7_12_12_2 Node7_12_12 Node7_13_12 8517647.058823531
R_7_12_12_3 Node7_12_12 Node8_12_12 15.75424
C_7_12_12 Node7_12_12 GND 2.9036132812500003e-10
R_7_12_13_1 Node7_12_13 Node7_12_14 8517647.058823531
R_7_12_13_2 Node7_12_13 Node7_13_13 8517647.058823531
R_7_12_13_3 Node7_12_13 Node8_12_13 15.75424
C_7_12_13 Node7_12_13 GND 2.9036132812500003e-10
R_7_12_14_1 Node7_12_14 Node7_12_15 8517647.058823528
R_7_12_14_2 Node7_12_14 Node7_13_14 8517647.058823531
R_7_12_14_3 Node7_12_14 Node8_12_14 15.75424
C_7_12_14 Node7_12_14 GND 2.9036132812500003e-10
R_7_12_15_2 Node7_12_15 Node7_13_15 8517647.058823524
R_7_12_15_3 Node7_12_15 Node8_12_15 15.754239999999987
C_7_12_15 Node7_12_15 GND 2.903613281250003e-10
R_7_13_0_1 Node7_13_0 Node7_13_1 8517647.058823531
R_7_13_0_2 Node7_13_0 Node7_14_0 8517647.058823531
R_7_13_0_3 Node7_13_0 Node8_13_0 15.75424
C_7_13_0 Node7_13_0 GND 2.9036132812500003e-10
R_7_13_1_1 Node7_13_1 Node7_13_2 8517647.058823531
R_7_13_1_2 Node7_13_1 Node7_14_1 8517647.058823531
R_7_13_1_3 Node7_13_1 Node8_13_1 15.75424
C_7_13_1 Node7_13_1 GND 2.9036132812500003e-10
R_7_13_2_1 Node7_13_2 Node7_13_3 8517647.058823531
R_7_13_2_2 Node7_13_2 Node7_14_2 8517647.058823531
R_7_13_2_3 Node7_13_2 Node8_13_2 15.75424
C_7_13_2 Node7_13_2 GND 2.9036132812500003e-10
R_7_13_3_1 Node7_13_3 Node7_13_4 8517647.058823531
R_7_13_3_2 Node7_13_3 Node7_14_3 8517647.058823531
R_7_13_3_3 Node7_13_3 Node8_13_3 15.75424
C_7_13_3 Node7_13_3 GND 2.9036132812500003e-10
R_7_13_4_1 Node7_13_4 Node7_13_5 8517647.058823531
R_7_13_4_2 Node7_13_4 Node7_14_4 8517647.058823531
R_7_13_4_3 Node7_13_4 Node8_13_4 15.75424
C_7_13_4 Node7_13_4 GND 2.9036132812500003e-10
R_7_13_5_1 Node7_13_5 Node7_13_6 8517647.058823531
R_7_13_5_2 Node7_13_5 Node7_14_5 8517647.058823531
R_7_13_5_3 Node7_13_5 Node8_13_5 15.75424
C_7_13_5 Node7_13_5 GND 2.9036132812500003e-10
R_7_13_6_1 Node7_13_6 Node7_13_7 8517647.058823531
R_7_13_6_2 Node7_13_6 Node7_14_6 8517647.058823531
R_7_13_6_3 Node7_13_6 Node8_13_6 15.75424
C_7_13_6 Node7_13_6 GND 2.9036132812500003e-10
R_7_13_7_1 Node7_13_7 Node7_13_8 8517647.058823531
R_7_13_7_2 Node7_13_7 Node7_14_7 8517647.058823531
R_7_13_7_3 Node7_13_7 Node8_13_7 15.75424
C_7_13_7 Node7_13_7 GND 2.9036132812500003e-10
R_7_13_8_1 Node7_13_8 Node7_13_9 8517647.058823531
R_7_13_8_2 Node7_13_8 Node7_14_8 8517647.058823531
R_7_13_8_3 Node7_13_8 Node8_13_8 15.75424
C_7_13_8 Node7_13_8 GND 2.9036132812500003e-10
R_7_13_9_1 Node7_13_9 Node7_13_10 8517647.058823531
R_7_13_9_2 Node7_13_9 Node7_14_9 8517647.058823531
R_7_13_9_3 Node7_13_9 Node8_13_9 15.75424
C_7_13_9 Node7_13_9 GND 2.9036132812500003e-10
R_7_13_10_1 Node7_13_10 Node7_13_11 8517647.058823531
R_7_13_10_2 Node7_13_10 Node7_14_10 8517647.058823531
R_7_13_10_3 Node7_13_10 Node8_13_10 15.75424
C_7_13_10 Node7_13_10 GND 2.9036132812500003e-10
R_7_13_11_1 Node7_13_11 Node7_13_12 8517647.058823531
R_7_13_11_2 Node7_13_11 Node7_14_11 8517647.058823531
R_7_13_11_3 Node7_13_11 Node8_13_11 15.75424
C_7_13_11 Node7_13_11 GND 2.9036132812500003e-10
R_7_13_12_1 Node7_13_12 Node7_13_13 8517647.058823531
R_7_13_12_2 Node7_13_12 Node7_14_12 8517647.058823531
R_7_13_12_3 Node7_13_12 Node8_13_12 15.75424
C_7_13_12 Node7_13_12 GND 2.9036132812500003e-10
R_7_13_13_1 Node7_13_13 Node7_13_14 8517647.058823531
R_7_13_13_2 Node7_13_13 Node7_14_13 8517647.058823531
R_7_13_13_3 Node7_13_13 Node8_13_13 15.75424
C_7_13_13 Node7_13_13 GND 2.9036132812500003e-10
R_7_13_14_1 Node7_13_14 Node7_13_15 8517647.058823528
R_7_13_14_2 Node7_13_14 Node7_14_14 8517647.058823531
R_7_13_14_3 Node7_13_14 Node8_13_14 15.75424
C_7_13_14 Node7_13_14 GND 2.9036132812500003e-10
R_7_13_15_2 Node7_13_15 Node7_14_15 8517647.058823524
R_7_13_15_3 Node7_13_15 Node8_13_15 15.754239999999987
C_7_13_15 Node7_13_15 GND 2.903613281250003e-10
R_7_14_0_1 Node7_14_0 Node7_14_1 8517647.058823531
R_7_14_0_2 Node7_14_0 Node7_15_0 8517647.058823531
R_7_14_0_3 Node7_14_0 Node8_14_0 15.75424
C_7_14_0 Node7_14_0 GND 2.9036132812500003e-10
R_7_14_1_1 Node7_14_1 Node7_14_2 8517647.058823531
R_7_14_1_2 Node7_14_1 Node7_15_1 8517647.058823531
R_7_14_1_3 Node7_14_1 Node8_14_1 15.75424
C_7_14_1 Node7_14_1 GND 2.9036132812500003e-10
R_7_14_2_1 Node7_14_2 Node7_14_3 8517647.058823531
R_7_14_2_2 Node7_14_2 Node7_15_2 8517647.058823531
R_7_14_2_3 Node7_14_2 Node8_14_2 15.75424
C_7_14_2 Node7_14_2 GND 2.9036132812500003e-10
R_7_14_3_1 Node7_14_3 Node7_14_4 8517647.058823531
R_7_14_3_2 Node7_14_3 Node7_15_3 8517647.058823531
R_7_14_3_3 Node7_14_3 Node8_14_3 15.75424
C_7_14_3 Node7_14_3 GND 2.9036132812500003e-10
R_7_14_4_1 Node7_14_4 Node7_14_5 8517647.058823531
R_7_14_4_2 Node7_14_4 Node7_15_4 8517647.058823531
R_7_14_4_3 Node7_14_4 Node8_14_4 15.75424
C_7_14_4 Node7_14_4 GND 2.9036132812500003e-10
R_7_14_5_1 Node7_14_5 Node7_14_6 8517647.058823531
R_7_14_5_2 Node7_14_5 Node7_15_5 8517647.058823531
R_7_14_5_3 Node7_14_5 Node8_14_5 15.75424
C_7_14_5 Node7_14_5 GND 2.9036132812500003e-10
R_7_14_6_1 Node7_14_6 Node7_14_7 8517647.058823531
R_7_14_6_2 Node7_14_6 Node7_15_6 8517647.058823531
R_7_14_6_3 Node7_14_6 Node8_14_6 15.75424
C_7_14_6 Node7_14_6 GND 2.9036132812500003e-10
R_7_14_7_1 Node7_14_7 Node7_14_8 8517647.058823531
R_7_14_7_2 Node7_14_7 Node7_15_7 8517647.058823531
R_7_14_7_3 Node7_14_7 Node8_14_7 15.75424
C_7_14_7 Node7_14_7 GND 2.9036132812500003e-10
R_7_14_8_1 Node7_14_8 Node7_14_9 8517647.058823531
R_7_14_8_2 Node7_14_8 Node7_15_8 8517647.058823531
R_7_14_8_3 Node7_14_8 Node8_14_8 15.75424
C_7_14_8 Node7_14_8 GND 2.9036132812500003e-10
R_7_14_9_1 Node7_14_9 Node7_14_10 8517647.058823531
R_7_14_9_2 Node7_14_9 Node7_15_9 8517647.058823531
R_7_14_9_3 Node7_14_9 Node8_14_9 15.75424
C_7_14_9 Node7_14_9 GND 2.9036132812500003e-10
R_7_14_10_1 Node7_14_10 Node7_14_11 8517647.058823531
R_7_14_10_2 Node7_14_10 Node7_15_10 8517647.058823531
R_7_14_10_3 Node7_14_10 Node8_14_10 15.75424
C_7_14_10 Node7_14_10 GND 2.9036132812500003e-10
R_7_14_11_1 Node7_14_11 Node7_14_12 8517647.058823531
R_7_14_11_2 Node7_14_11 Node7_15_11 8517647.058823531
R_7_14_11_3 Node7_14_11 Node8_14_11 15.75424
C_7_14_11 Node7_14_11 GND 2.9036132812500003e-10
R_7_14_12_1 Node7_14_12 Node7_14_13 8517647.058823531
R_7_14_12_2 Node7_14_12 Node7_15_12 8517647.058823531
R_7_14_12_3 Node7_14_12 Node8_14_12 15.75424
C_7_14_12 Node7_14_12 GND 2.9036132812500003e-10
R_7_14_13_1 Node7_14_13 Node7_14_14 8517647.058823531
R_7_14_13_2 Node7_14_13 Node7_15_13 8517647.058823531
R_7_14_13_3 Node7_14_13 Node8_14_13 15.75424
C_7_14_13 Node7_14_13 GND 2.9036132812500003e-10
R_7_14_14_1 Node7_14_14 Node7_14_15 8517647.058823528
R_7_14_14_2 Node7_14_14 Node7_15_14 8517647.058823531
R_7_14_14_3 Node7_14_14 Node8_14_14 15.75424
C_7_14_14 Node7_14_14 GND 2.9036132812500003e-10
R_7_14_15_2 Node7_14_15 Node7_15_15 8517647.058823522
R_7_14_15_3 Node7_14_15 Node8_14_15 15.754239999999987
C_7_14_15 Node7_14_15 GND 2.903613281250003e-10
R_7_15_0_1 Node7_15_0 Node7_15_1 8517647.058823531
R_7_15_0_3 Node7_15_0 Node8_15_0 15.75424
C_7_15_0 Node7_15_0 GND 2.9036132812500003e-10
R_7_15_1_1 Node7_15_1 Node7_15_2 8517647.058823531
R_7_15_1_3 Node7_15_1 Node8_15_1 15.75424
C_7_15_1 Node7_15_1 GND 2.9036132812500003e-10
R_7_15_2_1 Node7_15_2 Node7_15_3 8517647.058823531
R_7_15_2_3 Node7_15_2 Node8_15_2 15.75424
C_7_15_2 Node7_15_2 GND 2.9036132812500003e-10
R_7_15_3_1 Node7_15_3 Node7_15_4 8517647.058823531
R_7_15_3_3 Node7_15_3 Node8_15_3 15.75424
C_7_15_3 Node7_15_3 GND 2.9036132812500003e-10
R_7_15_4_1 Node7_15_4 Node7_15_5 8517647.058823531
R_7_15_4_3 Node7_15_4 Node8_15_4 15.75424
C_7_15_4 Node7_15_4 GND 2.9036132812500003e-10
R_7_15_5_1 Node7_15_5 Node7_15_6 8517647.058823531
R_7_15_5_3 Node7_15_5 Node8_15_5 15.75424
C_7_15_5 Node7_15_5 GND 2.9036132812500003e-10
R_7_15_6_1 Node7_15_6 Node7_15_7 8517647.058823531
R_7_15_6_3 Node7_15_6 Node8_15_6 15.75424
C_7_15_6 Node7_15_6 GND 2.9036132812500003e-10
R_7_15_7_1 Node7_15_7 Node7_15_8 8517647.058823531
R_7_15_7_3 Node7_15_7 Node8_15_7 15.75424
C_7_15_7 Node7_15_7 GND 2.9036132812500003e-10
R_7_15_8_1 Node7_15_8 Node7_15_9 8517647.058823531
R_7_15_8_3 Node7_15_8 Node8_15_8 15.75424
C_7_15_8 Node7_15_8 GND 2.9036132812500003e-10
R_7_15_9_1 Node7_15_9 Node7_15_10 8517647.058823531
R_7_15_9_3 Node7_15_9 Node8_15_9 15.75424
C_7_15_9 Node7_15_9 GND 2.9036132812500003e-10
R_7_15_10_1 Node7_15_10 Node7_15_11 8517647.058823531
R_7_15_10_3 Node7_15_10 Node8_15_10 15.75424
C_7_15_10 Node7_15_10 GND 2.9036132812500003e-10
R_7_15_11_1 Node7_15_11 Node7_15_12 8517647.058823531
R_7_15_11_3 Node7_15_11 Node8_15_11 15.75424
C_7_15_11 Node7_15_11 GND 2.9036132812500003e-10
R_7_15_12_1 Node7_15_12 Node7_15_13 8517647.058823531
R_7_15_12_3 Node7_15_12 Node8_15_12 15.75424
C_7_15_12 Node7_15_12 GND 2.9036132812500003e-10
R_7_15_13_1 Node7_15_13 Node7_15_14 8517647.058823531
R_7_15_13_3 Node7_15_13 Node8_15_13 15.75424
C_7_15_13 Node7_15_13 GND 2.9036132812500003e-10
R_7_15_14_1 Node7_15_14 Node7_15_15 8517647.058823526
R_7_15_14_3 Node7_15_14 Node8_15_14 15.75424
C_7_15_14 Node7_15_14 GND 2.9036132812500003e-10
R_7_15_15_3 Node7_15_15 Node8_15_15 15.754239999999983
C_7_15_15 Node7_15_15 GND 2.9036132812500034e-10
R_8_0_0_1 Node8_0_0 Node8_0_1 90588.23529411775
R_8_0_0_2 Node8_0_0 Node8_1_0 90588.23529411771
R_8_0_0_3 Node8_0_0 Node9_0_0 0.16755200000000015
C_8_0_0 Node8_0_0 GND 1.9174804687499983e-10
R_8_0_1_1 Node8_0_1 Node8_0_2 90588.23529411775
R_8_0_1_2 Node8_0_1 Node8_1_1 90588.23529411771
R_8_0_1_3 Node8_0_1 Node9_0_1 0.16755200000000015
C_8_0_1 Node8_0_1 GND 1.9174804687499983e-10
R_8_0_2_1 Node8_0_2 Node8_0_3 90588.23529411775
R_8_0_2_2 Node8_0_2 Node8_1_2 90588.23529411771
R_8_0_2_3 Node8_0_2 Node9_0_2 0.16755200000000015
C_8_0_2 Node8_0_2 GND 1.9174804687499983e-10
R_8_0_3_1 Node8_0_3 Node8_0_4 90588.23529411775
R_8_0_3_2 Node8_0_3 Node8_1_3 90588.23529411771
R_8_0_3_3 Node8_0_3 Node9_0_3 0.16755200000000015
C_8_0_3 Node8_0_3 GND 1.9174804687499983e-10
R_8_0_4_1 Node8_0_4 Node8_0_5 90588.23529411775
R_8_0_4_2 Node8_0_4 Node8_1_4 90588.23529411771
R_8_0_4_3 Node8_0_4 Node9_0_4 0.16755200000000015
C_8_0_4 Node8_0_4 GND 1.9174804687499983e-10
R_8_0_5_1 Node8_0_5 Node8_0_6 90588.23529411775
R_8_0_5_2 Node8_0_5 Node8_1_5 90588.23529411771
R_8_0_5_3 Node8_0_5 Node9_0_5 0.16755200000000015
C_8_0_5 Node8_0_5 GND 1.9174804687499983e-10
R_8_0_6_1 Node8_0_6 Node8_0_7 90588.23529411775
R_8_0_6_2 Node8_0_6 Node8_1_6 90588.23529411771
R_8_0_6_3 Node8_0_6 Node9_0_6 0.16755200000000015
C_8_0_6 Node8_0_6 GND 1.9174804687499983e-10
R_8_0_7_1 Node8_0_7 Node8_0_8 90588.23529411775
R_8_0_7_2 Node8_0_7 Node8_1_7 90588.23529411771
R_8_0_7_3 Node8_0_7 Node9_0_7 0.16755200000000015
C_8_0_7 Node8_0_7 GND 1.9174804687499983e-10
R_8_0_8_1 Node8_0_8 Node8_0_9 90588.23529411775
R_8_0_8_2 Node8_0_8 Node8_1_8 90588.23529411771
R_8_0_8_3 Node8_0_8 Node9_0_8 0.16755200000000015
C_8_0_8 Node8_0_8 GND 1.9174804687499983e-10
R_8_0_9_1 Node8_0_9 Node8_0_10 90588.23529411775
R_8_0_9_2 Node8_0_9 Node8_1_9 90588.23529411771
R_8_0_9_3 Node8_0_9 Node9_0_9 0.16755200000000015
C_8_0_9 Node8_0_9 GND 1.9174804687499983e-10
R_8_0_10_1 Node8_0_10 Node8_0_11 90588.23529411775
R_8_0_10_2 Node8_0_10 Node8_1_10 90588.23529411771
R_8_0_10_3 Node8_0_10 Node9_0_10 0.16755200000000015
C_8_0_10 Node8_0_10 GND 1.9174804687499983e-10
R_8_0_11_1 Node8_0_11 Node8_0_12 90588.23529411775
R_8_0_11_2 Node8_0_11 Node8_1_11 90588.23529411771
R_8_0_11_3 Node8_0_11 Node9_0_11 0.16755200000000015
C_8_0_11 Node8_0_11 GND 1.9174804687499983e-10
R_8_0_12_1 Node8_0_12 Node8_0_13 90588.23529411775
R_8_0_12_2 Node8_0_12 Node8_1_12 90588.23529411771
R_8_0_12_3 Node8_0_12 Node9_0_12 0.16755200000000015
C_8_0_12 Node8_0_12 GND 1.9174804687499983e-10
R_8_0_13_1 Node8_0_13 Node8_0_14 90588.23529411775
R_8_0_13_2 Node8_0_13 Node8_1_13 90588.23529411771
R_8_0_13_3 Node8_0_13 Node9_0_13 0.16755200000000015
C_8_0_13 Node8_0_13 GND 1.9174804687499983e-10
R_8_0_14_1 Node8_0_14 Node8_0_15 90588.23529411771
R_8_0_14_2 Node8_0_14 Node8_1_14 90588.23529411771
R_8_0_14_3 Node8_0_14 Node9_0_14 0.16755200000000015
C_8_0_14 Node8_0_14 GND 1.9174804687499983e-10
R_8_0_15_2 Node8_0_15 Node8_1_15 90588.23529411762
R_8_0_15_3 Node8_0_15 Node9_0_15 0.167552
C_8_0_15 Node8_0_15 GND 1.91748046875e-10
R_8_1_0_1 Node8_1_0 Node8_1_1 90588.23529411767
R_8_1_0_2 Node8_1_0 Node8_2_0 90588.23529411767
R_8_1_0_3 Node8_1_0 Node9_1_0 0.167552
C_8_1_0 Node8_1_0 GND 1.91748046875e-10
R_8_1_1_1 Node8_1_1 Node8_1_2 90588.23529411767
R_8_1_1_2 Node8_1_1 Node8_2_1 90588.23529411767
R_8_1_1_3 Node8_1_1 Node9_1_1 0.167552
C_8_1_1 Node8_1_1 GND 1.91748046875e-10
R_8_1_2_1 Node8_1_2 Node8_1_3 90588.23529411767
R_8_1_2_2 Node8_1_2 Node8_2_2 90588.23529411767
R_8_1_2_3 Node8_1_2 Node9_1_2 0.167552
C_8_1_2 Node8_1_2 GND 1.91748046875e-10
R_8_1_3_1 Node8_1_3 Node8_1_4 90588.23529411767
R_8_1_3_2 Node8_1_3 Node8_2_3 90588.23529411767
R_8_1_3_3 Node8_1_3 Node9_1_3 0.167552
C_8_1_3 Node8_1_3 GND 1.91748046875e-10
R_8_1_4_1 Node8_1_4 Node8_1_5 90588.23529411767
R_8_1_4_2 Node8_1_4 Node8_2_4 90588.23529411767
R_8_1_4_3 Node8_1_4 Node9_1_4 0.167552
C_8_1_4 Node8_1_4 GND 1.91748046875e-10
R_8_1_5_1 Node8_1_5 Node8_1_6 90588.23529411767
R_8_1_5_2 Node8_1_5 Node8_2_5 90588.23529411767
R_8_1_5_3 Node8_1_5 Node9_1_5 0.167552
C_8_1_5 Node8_1_5 GND 1.91748046875e-10
R_8_1_6_1 Node8_1_6 Node8_1_7 90588.23529411767
R_8_1_6_2 Node8_1_6 Node8_2_6 90588.23529411767
R_8_1_6_3 Node8_1_6 Node9_1_6 0.167552
C_8_1_6 Node8_1_6 GND 1.91748046875e-10
R_8_1_7_1 Node8_1_7 Node8_1_8 90588.23529411767
R_8_1_7_2 Node8_1_7 Node8_2_7 90588.23529411767
R_8_1_7_3 Node8_1_7 Node9_1_7 0.167552
C_8_1_7 Node8_1_7 GND 1.91748046875e-10
R_8_1_8_1 Node8_1_8 Node8_1_9 90588.23529411767
R_8_1_8_2 Node8_1_8 Node8_2_8 90588.23529411767
R_8_1_8_3 Node8_1_8 Node9_1_8 0.167552
C_8_1_8 Node8_1_8 GND 1.91748046875e-10
R_8_1_9_1 Node8_1_9 Node8_1_10 90588.23529411767
R_8_1_9_2 Node8_1_9 Node8_2_9 90588.23529411767
R_8_1_9_3 Node8_1_9 Node9_1_9 0.167552
C_8_1_9 Node8_1_9 GND 1.91748046875e-10
R_8_1_10_1 Node8_1_10 Node8_1_11 90588.23529411767
R_8_1_10_2 Node8_1_10 Node8_2_10 90588.23529411767
R_8_1_10_3 Node8_1_10 Node9_1_10 0.167552
C_8_1_10 Node8_1_10 GND 1.91748046875e-10
R_8_1_11_1 Node8_1_11 Node8_1_12 90588.23529411767
R_8_1_11_2 Node8_1_11 Node8_2_11 90588.23529411767
R_8_1_11_3 Node8_1_11 Node9_1_11 0.167552
C_8_1_11 Node8_1_11 GND 1.91748046875e-10
R_8_1_12_1 Node8_1_12 Node8_1_13 90588.23529411767
R_8_1_12_2 Node8_1_12 Node8_2_12 90588.23529411767
R_8_1_12_3 Node8_1_12 Node9_1_12 0.167552
C_8_1_12 Node8_1_12 GND 1.91748046875e-10
R_8_1_13_1 Node8_1_13 Node8_1_14 90588.23529411767
R_8_1_13_2 Node8_1_13 Node8_2_13 90588.23529411767
R_8_1_13_3 Node8_1_13 Node9_1_13 0.167552
C_8_1_13 Node8_1_13 GND 1.91748046875e-10
R_8_1_14_1 Node8_1_14 Node8_1_15 90588.23529411762
R_8_1_14_2 Node8_1_14 Node8_2_14 90588.23529411767
R_8_1_14_3 Node8_1_14 Node9_1_14 0.167552
C_8_1_14 Node8_1_14 GND 1.91748046875e-10
R_8_1_15_2 Node8_1_15 Node8_2_15 90588.23529411759
R_8_1_15_3 Node8_1_15 Node9_1_15 0.16755199999999984
C_8_1_15 Node8_1_15 GND 1.917480468750002e-10
R_8_2_0_1 Node8_2_0 Node8_2_1 90588.23529411767
R_8_2_0_2 Node8_2_0 Node8_3_0 90588.23529411767
R_8_2_0_3 Node8_2_0 Node9_2_0 0.167552
C_8_2_0 Node8_2_0 GND 1.91748046875e-10
R_8_2_1_1 Node8_2_1 Node8_2_2 90588.23529411767
R_8_2_1_2 Node8_2_1 Node8_3_1 90588.23529411767
R_8_2_1_3 Node8_2_1 Node9_2_1 0.167552
C_8_2_1 Node8_2_1 GND 1.91748046875e-10
R_8_2_2_1 Node8_2_2 Node8_2_3 90588.23529411767
R_8_2_2_2 Node8_2_2 Node8_3_2 90588.23529411767
R_8_2_2_3 Node8_2_2 Node9_2_2 0.167552
C_8_2_2 Node8_2_2 GND 1.91748046875e-10
R_8_2_3_1 Node8_2_3 Node8_2_4 90588.23529411767
R_8_2_3_2 Node8_2_3 Node8_3_3 90588.23529411767
R_8_2_3_3 Node8_2_3 Node9_2_3 0.167552
C_8_2_3 Node8_2_3 GND 1.91748046875e-10
R_8_2_4_1 Node8_2_4 Node8_2_5 90588.23529411767
R_8_2_4_2 Node8_2_4 Node8_3_4 90588.23529411767
R_8_2_4_3 Node8_2_4 Node9_2_4 0.167552
C_8_2_4 Node8_2_4 GND 1.91748046875e-10
R_8_2_5_1 Node8_2_5 Node8_2_6 90588.23529411767
R_8_2_5_2 Node8_2_5 Node8_3_5 90588.23529411767
R_8_2_5_3 Node8_2_5 Node9_2_5 0.167552
C_8_2_5 Node8_2_5 GND 1.91748046875e-10
R_8_2_6_1 Node8_2_6 Node8_2_7 90588.23529411767
R_8_2_6_2 Node8_2_6 Node8_3_6 90588.23529411767
R_8_2_6_3 Node8_2_6 Node9_2_6 0.167552
C_8_2_6 Node8_2_6 GND 1.91748046875e-10
R_8_2_7_1 Node8_2_7 Node8_2_8 90588.23529411767
R_8_2_7_2 Node8_2_7 Node8_3_7 90588.23529411767
R_8_2_7_3 Node8_2_7 Node9_2_7 0.167552
C_8_2_7 Node8_2_7 GND 1.91748046875e-10
R_8_2_8_1 Node8_2_8 Node8_2_9 90588.23529411767
R_8_2_8_2 Node8_2_8 Node8_3_8 90588.23529411767
R_8_2_8_3 Node8_2_8 Node9_2_8 0.167552
C_8_2_8 Node8_2_8 GND 1.91748046875e-10
R_8_2_9_1 Node8_2_9 Node8_2_10 90588.23529411767
R_8_2_9_2 Node8_2_9 Node8_3_9 90588.23529411767
R_8_2_9_3 Node8_2_9 Node9_2_9 0.167552
C_8_2_9 Node8_2_9 GND 1.91748046875e-10
R_8_2_10_1 Node8_2_10 Node8_2_11 90588.23529411767
R_8_2_10_2 Node8_2_10 Node8_3_10 90588.23529411767
R_8_2_10_3 Node8_2_10 Node9_2_10 0.167552
C_8_2_10 Node8_2_10 GND 1.91748046875e-10
R_8_2_11_1 Node8_2_11 Node8_2_12 90588.23529411767
R_8_2_11_2 Node8_2_11 Node8_3_11 90588.23529411767
R_8_2_11_3 Node8_2_11 Node9_2_11 0.167552
C_8_2_11 Node8_2_11 GND 1.91748046875e-10
R_8_2_12_1 Node8_2_12 Node8_2_13 90588.23529411767
R_8_2_12_2 Node8_2_12 Node8_3_12 90588.23529411767
R_8_2_12_3 Node8_2_12 Node9_2_12 0.167552
C_8_2_12 Node8_2_12 GND 1.91748046875e-10
R_8_2_13_1 Node8_2_13 Node8_2_14 90588.23529411767
R_8_2_13_2 Node8_2_13 Node8_3_13 90588.23529411767
R_8_2_13_3 Node8_2_13 Node9_2_13 0.167552
C_8_2_13 Node8_2_13 GND 1.91748046875e-10
R_8_2_14_1 Node8_2_14 Node8_2_15 90588.23529411762
R_8_2_14_2 Node8_2_14 Node8_3_14 90588.23529411767
R_8_2_14_3 Node8_2_14 Node9_2_14 0.167552
C_8_2_14 Node8_2_14 GND 1.91748046875e-10
R_8_2_15_2 Node8_2_15 Node8_3_15 90588.23529411759
R_8_2_15_3 Node8_2_15 Node9_2_15 0.16755199999999984
C_8_2_15 Node8_2_15 GND 1.917480468750002e-10
R_8_3_0_1 Node8_3_0 Node8_3_1 90588.23529411767
R_8_3_0_2 Node8_3_0 Node8_4_0 90588.23529411767
R_8_3_0_3 Node8_3_0 Node9_3_0 0.167552
C_8_3_0 Node8_3_0 GND 1.91748046875e-10
R_8_3_1_1 Node8_3_1 Node8_3_2 90588.23529411767
R_8_3_1_2 Node8_3_1 Node8_4_1 90588.23529411767
R_8_3_1_3 Node8_3_1 Node9_3_1 0.167552
C_8_3_1 Node8_3_1 GND 1.91748046875e-10
R_8_3_2_1 Node8_3_2 Node8_3_3 90588.23529411767
R_8_3_2_2 Node8_3_2 Node8_4_2 90588.23529411767
R_8_3_2_3 Node8_3_2 Node9_3_2 0.167552
C_8_3_2 Node8_3_2 GND 1.91748046875e-10
R_8_3_3_1 Node8_3_3 Node8_3_4 90588.23529411767
R_8_3_3_2 Node8_3_3 Node8_4_3 90588.23529411767
R_8_3_3_3 Node8_3_3 Node9_3_3 0.167552
C_8_3_3 Node8_3_3 GND 1.91748046875e-10
R_8_3_4_1 Node8_3_4 Node8_3_5 90588.23529411767
R_8_3_4_2 Node8_3_4 Node8_4_4 90588.23529411767
R_8_3_4_3 Node8_3_4 Node9_3_4 0.167552
C_8_3_4 Node8_3_4 GND 1.91748046875e-10
R_8_3_5_1 Node8_3_5 Node8_3_6 90588.23529411767
R_8_3_5_2 Node8_3_5 Node8_4_5 90588.23529411767
R_8_3_5_3 Node8_3_5 Node9_3_5 0.167552
C_8_3_5 Node8_3_5 GND 1.91748046875e-10
R_8_3_6_1 Node8_3_6 Node8_3_7 90588.23529411767
R_8_3_6_2 Node8_3_6 Node8_4_6 90588.23529411767
R_8_3_6_3 Node8_3_6 Node9_3_6 0.167552
C_8_3_6 Node8_3_6 GND 1.91748046875e-10
R_8_3_7_1 Node8_3_7 Node8_3_8 90588.23529411767
R_8_3_7_2 Node8_3_7 Node8_4_7 90588.23529411767
R_8_3_7_3 Node8_3_7 Node9_3_7 0.167552
C_8_3_7 Node8_3_7 GND 1.91748046875e-10
R_8_3_8_1 Node8_3_8 Node8_3_9 90588.23529411767
R_8_3_8_2 Node8_3_8 Node8_4_8 90588.23529411767
R_8_3_8_3 Node8_3_8 Node9_3_8 0.167552
C_8_3_8 Node8_3_8 GND 1.91748046875e-10
R_8_3_9_1 Node8_3_9 Node8_3_10 90588.23529411767
R_8_3_9_2 Node8_3_9 Node8_4_9 90588.23529411767
R_8_3_9_3 Node8_3_9 Node9_3_9 0.167552
C_8_3_9 Node8_3_9 GND 1.91748046875e-10
R_8_3_10_1 Node8_3_10 Node8_3_11 90588.23529411767
R_8_3_10_2 Node8_3_10 Node8_4_10 90588.23529411767
R_8_3_10_3 Node8_3_10 Node9_3_10 0.167552
C_8_3_10 Node8_3_10 GND 1.91748046875e-10
R_8_3_11_1 Node8_3_11 Node8_3_12 90588.23529411767
R_8_3_11_2 Node8_3_11 Node8_4_11 90588.23529411767
R_8_3_11_3 Node8_3_11 Node9_3_11 0.167552
C_8_3_11 Node8_3_11 GND 1.91748046875e-10
R_8_3_12_1 Node8_3_12 Node8_3_13 90588.23529411767
R_8_3_12_2 Node8_3_12 Node8_4_12 90588.23529411767
R_8_3_12_3 Node8_3_12 Node9_3_12 0.167552
C_8_3_12 Node8_3_12 GND 1.91748046875e-10
R_8_3_13_1 Node8_3_13 Node8_3_14 90588.23529411767
R_8_3_13_2 Node8_3_13 Node8_4_13 90588.23529411767
R_8_3_13_3 Node8_3_13 Node9_3_13 0.167552
C_8_3_13 Node8_3_13 GND 1.91748046875e-10
R_8_3_14_1 Node8_3_14 Node8_3_15 90588.23529411762
R_8_3_14_2 Node8_3_14 Node8_4_14 90588.23529411767
R_8_3_14_3 Node8_3_14 Node9_3_14 0.167552
C_8_3_14 Node8_3_14 GND 1.91748046875e-10
R_8_3_15_2 Node8_3_15 Node8_4_15 90588.23529411759
R_8_3_15_3 Node8_3_15 Node9_3_15 0.16755199999999984
C_8_3_15 Node8_3_15 GND 1.917480468750002e-10
R_8_4_0_1 Node8_4_0 Node8_4_1 90588.23529411767
R_8_4_0_2 Node8_4_0 Node8_5_0 90588.23529411767
R_8_4_0_3 Node8_4_0 Node9_4_0 0.167552
C_8_4_0 Node8_4_0 GND 1.91748046875e-10
R_8_4_1_1 Node8_4_1 Node8_4_2 90588.23529411767
R_8_4_1_2 Node8_4_1 Node8_5_1 90588.23529411767
R_8_4_1_3 Node8_4_1 Node9_4_1 0.167552
C_8_4_1 Node8_4_1 GND 1.91748046875e-10
R_8_4_2_1 Node8_4_2 Node8_4_3 90588.23529411767
R_8_4_2_2 Node8_4_2 Node8_5_2 90588.23529411767
R_8_4_2_3 Node8_4_2 Node9_4_2 0.167552
C_8_4_2 Node8_4_2 GND 1.91748046875e-10
R_8_4_3_1 Node8_4_3 Node8_4_4 90588.23529411767
R_8_4_3_2 Node8_4_3 Node8_5_3 90588.23529411767
R_8_4_3_3 Node8_4_3 Node9_4_3 0.167552
C_8_4_3 Node8_4_3 GND 1.91748046875e-10
R_8_4_4_1 Node8_4_4 Node8_4_5 90588.23529411767
R_8_4_4_2 Node8_4_4 Node8_5_4 90588.23529411767
R_8_4_4_3 Node8_4_4 Node9_4_4 0.167552
C_8_4_4 Node8_4_4 GND 1.91748046875e-10
R_8_4_5_1 Node8_4_5 Node8_4_6 90588.23529411767
R_8_4_5_2 Node8_4_5 Node8_5_5 90588.23529411767
R_8_4_5_3 Node8_4_5 Node9_4_5 0.167552
C_8_4_5 Node8_4_5 GND 1.91748046875e-10
R_8_4_6_1 Node8_4_6 Node8_4_7 90588.23529411767
R_8_4_6_2 Node8_4_6 Node8_5_6 90588.23529411767
R_8_4_6_3 Node8_4_6 Node9_4_6 0.167552
C_8_4_6 Node8_4_6 GND 1.91748046875e-10
R_8_4_7_1 Node8_4_7 Node8_4_8 90588.23529411767
R_8_4_7_2 Node8_4_7 Node8_5_7 90588.23529411767
R_8_4_7_3 Node8_4_7 Node9_4_7 0.167552
C_8_4_7 Node8_4_7 GND 1.91748046875e-10
R_8_4_8_1 Node8_4_8 Node8_4_9 90588.23529411767
R_8_4_8_2 Node8_4_8 Node8_5_8 90588.23529411767
R_8_4_8_3 Node8_4_8 Node9_4_8 0.167552
C_8_4_8 Node8_4_8 GND 1.91748046875e-10
R_8_4_9_1 Node8_4_9 Node8_4_10 90588.23529411767
R_8_4_9_2 Node8_4_9 Node8_5_9 90588.23529411767
R_8_4_9_3 Node8_4_9 Node9_4_9 0.167552
C_8_4_9 Node8_4_9 GND 1.91748046875e-10
R_8_4_10_1 Node8_4_10 Node8_4_11 90588.23529411767
R_8_4_10_2 Node8_4_10 Node8_5_10 90588.23529411767
R_8_4_10_3 Node8_4_10 Node9_4_10 0.167552
C_8_4_10 Node8_4_10 GND 1.91748046875e-10
R_8_4_11_1 Node8_4_11 Node8_4_12 90588.23529411767
R_8_4_11_2 Node8_4_11 Node8_5_11 90588.23529411767
R_8_4_11_3 Node8_4_11 Node9_4_11 0.167552
C_8_4_11 Node8_4_11 GND 1.91748046875e-10
R_8_4_12_1 Node8_4_12 Node8_4_13 90588.23529411767
R_8_4_12_2 Node8_4_12 Node8_5_12 90588.23529411767
R_8_4_12_3 Node8_4_12 Node9_4_12 0.167552
C_8_4_12 Node8_4_12 GND 1.91748046875e-10
R_8_4_13_1 Node8_4_13 Node8_4_14 90588.23529411767
R_8_4_13_2 Node8_4_13 Node8_5_13 90588.23529411767
R_8_4_13_3 Node8_4_13 Node9_4_13 0.167552
C_8_4_13 Node8_4_13 GND 1.91748046875e-10
R_8_4_14_1 Node8_4_14 Node8_4_15 90588.23529411762
R_8_4_14_2 Node8_4_14 Node8_5_14 90588.23529411767
R_8_4_14_3 Node8_4_14 Node9_4_14 0.167552
C_8_4_14 Node8_4_14 GND 1.91748046875e-10
R_8_4_15_2 Node8_4_15 Node8_5_15 90588.23529411759
R_8_4_15_3 Node8_4_15 Node9_4_15 0.16755199999999984
C_8_4_15 Node8_4_15 GND 1.917480468750002e-10
R_8_5_0_1 Node8_5_0 Node8_5_1 90588.23529411767
R_8_5_0_2 Node8_5_0 Node8_6_0 90588.23529411767
R_8_5_0_3 Node8_5_0 Node9_5_0 0.167552
C_8_5_0 Node8_5_0 GND 1.91748046875e-10
R_8_5_1_1 Node8_5_1 Node8_5_2 90588.23529411767
R_8_5_1_2 Node8_5_1 Node8_6_1 90588.23529411767
R_8_5_1_3 Node8_5_1 Node9_5_1 0.167552
C_8_5_1 Node8_5_1 GND 1.91748046875e-10
R_8_5_2_1 Node8_5_2 Node8_5_3 90588.23529411767
R_8_5_2_2 Node8_5_2 Node8_6_2 90588.23529411767
R_8_5_2_3 Node8_5_2 Node9_5_2 0.167552
C_8_5_2 Node8_5_2 GND 1.91748046875e-10
R_8_5_3_1 Node8_5_3 Node8_5_4 90588.23529411767
R_8_5_3_2 Node8_5_3 Node8_6_3 90588.23529411767
R_8_5_3_3 Node8_5_3 Node9_5_3 0.167552
C_8_5_3 Node8_5_3 GND 1.91748046875e-10
R_8_5_4_1 Node8_5_4 Node8_5_5 90588.23529411767
R_8_5_4_2 Node8_5_4 Node8_6_4 90588.23529411767
R_8_5_4_3 Node8_5_4 Node9_5_4 0.167552
C_8_5_4 Node8_5_4 GND 1.91748046875e-10
R_8_5_5_1 Node8_5_5 Node8_5_6 90588.23529411767
R_8_5_5_2 Node8_5_5 Node8_6_5 90588.23529411767
R_8_5_5_3 Node8_5_5 Node9_5_5 0.167552
C_8_5_5 Node8_5_5 GND 1.91748046875e-10
R_8_5_6_1 Node8_5_6 Node8_5_7 90588.23529411767
R_8_5_6_2 Node8_5_6 Node8_6_6 90588.23529411765
R_8_5_6_3 Node8_5_6 Node9_5_6 0.167552
C_8_5_6 Node8_5_6 GND 1.91748046875e-10
R_8_5_7_1 Node8_5_7 Node8_5_8 90588.23529411767
R_8_5_7_2 Node8_5_7 Node8_6_7 90588.23529411767
R_8_5_7_3 Node8_5_7 Node9_5_7 0.167552
C_8_5_7 Node8_5_7 GND 1.91748046875e-10
R_8_5_8_1 Node8_5_8 Node8_5_9 90588.23529411767
R_8_5_8_2 Node8_5_8 Node8_6_8 90588.23529411767
R_8_5_8_3 Node8_5_8 Node9_5_8 0.167552
C_8_5_8 Node8_5_8 GND 1.91748046875e-10
R_8_5_9_1 Node8_5_9 Node8_5_10 90588.23529411767
R_8_5_9_2 Node8_5_9 Node8_6_9 90588.23529411765
R_8_5_9_3 Node8_5_9 Node9_5_9 0.167552
C_8_5_9 Node8_5_9 GND 1.91748046875e-10
R_8_5_10_1 Node8_5_10 Node8_5_11 90588.23529411767
R_8_5_10_2 Node8_5_10 Node8_6_10 90588.23529411767
R_8_5_10_3 Node8_5_10 Node9_5_10 0.167552
C_8_5_10 Node8_5_10 GND 1.91748046875e-10
R_8_5_11_1 Node8_5_11 Node8_5_12 90588.23529411767
R_8_5_11_2 Node8_5_11 Node8_6_11 90588.23529411767
R_8_5_11_3 Node8_5_11 Node9_5_11 0.167552
C_8_5_11 Node8_5_11 GND 1.91748046875e-10
R_8_5_12_1 Node8_5_12 Node8_5_13 90588.23529411767
R_8_5_12_2 Node8_5_12 Node8_6_12 90588.23529411767
R_8_5_12_3 Node8_5_12 Node9_5_12 0.167552
C_8_5_12 Node8_5_12 GND 1.91748046875e-10
R_8_5_13_1 Node8_5_13 Node8_5_14 90588.23529411767
R_8_5_13_2 Node8_5_13 Node8_6_13 90588.23529411767
R_8_5_13_3 Node8_5_13 Node9_5_13 0.167552
C_8_5_13 Node8_5_13 GND 1.91748046875e-10
R_8_5_14_1 Node8_5_14 Node8_5_15 90588.23529411762
R_8_5_14_2 Node8_5_14 Node8_6_14 90588.23529411767
R_8_5_14_3 Node8_5_14 Node9_5_14 0.167552
C_8_5_14 Node8_5_14 GND 1.91748046875e-10
R_8_5_15_2 Node8_5_15 Node8_6_15 90588.23529411759
R_8_5_15_3 Node8_5_15 Node9_5_15 0.16755199999999984
C_8_5_15 Node8_5_15 GND 1.917480468750002e-10
R_8_6_0_1 Node8_6_0 Node8_6_1 90588.23529411767
R_8_6_0_2 Node8_6_0 Node8_7_0 90588.23529411767
R_8_6_0_3 Node8_6_0 Node9_6_0 0.16755199999999998
C_8_6_0 Node8_6_0 GND 1.9174804687500003e-10
R_8_6_1_1 Node8_6_1 Node8_6_2 90588.23529411767
R_8_6_1_2 Node8_6_1 Node8_7_1 90588.23529411767
R_8_6_1_3 Node8_6_1 Node9_6_1 0.167552
C_8_6_1 Node8_6_1 GND 1.91748046875e-10
R_8_6_2_1 Node8_6_2 Node8_6_3 90588.23529411767
R_8_6_2_2 Node8_6_2 Node8_7_2 90588.23529411767
R_8_6_2_3 Node8_6_2 Node9_6_2 0.167552
C_8_6_2 Node8_6_2 GND 1.91748046875e-10
R_8_6_3_1 Node8_6_3 Node8_6_4 90588.23529411767
R_8_6_3_2 Node8_6_3 Node8_7_3 90588.23529411767
R_8_6_3_3 Node8_6_3 Node9_6_3 0.167552
C_8_6_3 Node8_6_3 GND 1.91748046875e-10
R_8_6_4_1 Node8_6_4 Node8_6_5 90588.23529411767
R_8_6_4_2 Node8_6_4 Node8_7_4 90588.23529411767
R_8_6_4_3 Node8_6_4 Node9_6_4 0.167552
C_8_6_4 Node8_6_4 GND 1.91748046875e-10
R_8_6_5_1 Node8_6_5 Node8_6_6 90588.23529411765
R_8_6_5_2 Node8_6_5 Node8_7_5 90588.23529411767
R_8_6_5_3 Node8_6_5 Node9_6_5 0.167552
C_8_6_5 Node8_6_5 GND 1.91748046875e-10
R_8_6_6_1 Node8_6_6 Node8_6_7 90588.23529411765
R_8_6_6_2 Node8_6_6 Node8_7_6 90588.23529411765
R_8_6_6_3 Node8_6_6 Node9_6_6 0.16755199999999998
C_8_6_6 Node8_6_6 GND 1.9174804687500003e-10
R_8_6_7_1 Node8_6_7 Node8_6_8 90588.23529411767
R_8_6_7_2 Node8_6_7 Node8_7_7 90588.23529411767
R_8_6_7_3 Node8_6_7 Node9_6_7 0.167552
C_8_6_7 Node8_6_7 GND 1.91748046875e-10
R_8_6_8_1 Node8_6_8 Node8_6_9 90588.23529411765
R_8_6_8_2 Node8_6_8 Node8_7_8 90588.23529411767
R_8_6_8_3 Node8_6_8 Node9_6_8 0.167552
C_8_6_8 Node8_6_8 GND 1.91748046875e-10
R_8_6_9_1 Node8_6_9 Node8_6_10 90588.23529411765
R_8_6_9_2 Node8_6_9 Node8_7_9 90588.2352941176
R_8_6_9_3 Node8_6_9 Node9_6_9 0.1675519999999999
C_8_6_9 Node8_6_9 GND 1.917480468750001e-10
R_8_6_10_1 Node8_6_10 Node8_6_11 90588.23529411767
R_8_6_10_2 Node8_6_10 Node8_7_10 90588.23529411767
R_8_6_10_3 Node8_6_10 Node9_6_10 0.167552
C_8_6_10 Node8_6_10 GND 1.91748046875e-10
R_8_6_11_1 Node8_6_11 Node8_6_12 90588.23529411767
R_8_6_11_2 Node8_6_11 Node8_7_11 90588.23529411767
R_8_6_11_3 Node8_6_11 Node9_6_11 0.167552
C_8_6_11 Node8_6_11 GND 1.91748046875e-10
R_8_6_12_1 Node8_6_12 Node8_6_13 90588.23529411767
R_8_6_12_2 Node8_6_12 Node8_7_12 90588.23529411767
R_8_6_12_3 Node8_6_12 Node9_6_12 0.167552
C_8_6_12 Node8_6_12 GND 1.91748046875e-10
R_8_6_13_1 Node8_6_13 Node8_6_14 90588.23529411767
R_8_6_13_2 Node8_6_13 Node8_7_13 90588.23529411767
R_8_6_13_3 Node8_6_13 Node9_6_13 0.167552
C_8_6_13 Node8_6_13 GND 1.91748046875e-10
R_8_6_14_1 Node8_6_14 Node8_6_15 90588.23529411762
R_8_6_14_2 Node8_6_14 Node8_7_14 90588.23529411767
R_8_6_14_3 Node8_6_14 Node9_6_14 0.167552
C_8_6_14 Node8_6_14 GND 1.91748046875e-10
R_8_6_15_2 Node8_6_15 Node8_7_15 90588.23529411759
R_8_6_15_3 Node8_6_15 Node9_6_15 0.16755199999999984
C_8_6_15 Node8_6_15 GND 1.917480468750002e-10
R_8_7_0_1 Node8_7_0 Node8_7_1 90588.23529411767
R_8_7_0_2 Node8_7_0 Node8_8_0 90588.23529411767
R_8_7_0_3 Node8_7_0 Node9_7_0 0.167552
C_8_7_0 Node8_7_0 GND 1.91748046875e-10
R_8_7_1_1 Node8_7_1 Node8_7_2 90588.23529411767
R_8_7_1_2 Node8_7_1 Node8_8_1 90588.23529411767
R_8_7_1_3 Node8_7_1 Node9_7_1 0.167552
C_8_7_1 Node8_7_1 GND 1.91748046875e-10
R_8_7_2_1 Node8_7_2 Node8_7_3 90588.23529411767
R_8_7_2_2 Node8_7_2 Node8_8_2 90588.23529411767
R_8_7_2_3 Node8_7_2 Node9_7_2 0.167552
C_8_7_2 Node8_7_2 GND 1.91748046875e-10
R_8_7_3_1 Node8_7_3 Node8_7_4 90588.23529411767
R_8_7_3_2 Node8_7_3 Node8_8_3 90588.23529411767
R_8_7_3_3 Node8_7_3 Node9_7_3 0.167552
C_8_7_3 Node8_7_3 GND 1.91748046875e-10
R_8_7_4_1 Node8_7_4 Node8_7_5 90588.23529411767
R_8_7_4_2 Node8_7_4 Node8_8_4 90588.23529411767
R_8_7_4_3 Node8_7_4 Node9_7_4 0.167552
C_8_7_4 Node8_7_4 GND 1.91748046875e-10
R_8_7_5_1 Node8_7_5 Node8_7_6 90588.23529411767
R_8_7_5_2 Node8_7_5 Node8_8_5 90588.23529411767
R_8_7_5_3 Node8_7_5 Node9_7_5 0.167552
C_8_7_5 Node8_7_5 GND 1.91748046875e-10
R_8_7_6_1 Node8_7_6 Node8_7_7 90588.23529411767
R_8_7_6_2 Node8_7_6 Node8_8_6 90588.23529411767
R_8_7_6_3 Node8_7_6 Node9_7_6 0.16755199999999998
C_8_7_6 Node8_7_6 GND 1.9174804687500003e-10
R_8_7_7_1 Node8_7_7 Node8_7_8 90588.23529411767
R_8_7_7_2 Node8_7_7 Node8_8_7 90588.23529411767
R_8_7_7_3 Node8_7_7 Node9_7_7 0.167552
C_8_7_7 Node8_7_7 GND 1.91748046875e-10
R_8_7_8_1 Node8_7_8 Node8_7_9 90588.23529411762
R_8_7_8_2 Node8_7_8 Node8_8_8 90588.23529411767
R_8_7_8_3 Node8_7_8 Node9_7_8 0.167552
C_8_7_8 Node8_7_8 GND 1.91748046875e-10
R_8_7_9_1 Node8_7_9 Node8_7_10 90588.23529411762
R_8_7_9_2 Node8_7_9 Node8_8_9 90588.23529411759
R_8_7_9_3 Node8_7_9 Node9_7_9 0.16755199999999987
C_8_7_9 Node8_7_9 GND 1.917480468750002e-10
R_8_7_10_1 Node8_7_10 Node8_7_11 90588.23529411767
R_8_7_10_2 Node8_7_10 Node8_8_10 90588.23529411767
R_8_7_10_3 Node8_7_10 Node9_7_10 0.167552
C_8_7_10 Node8_7_10 GND 1.91748046875e-10
R_8_7_11_1 Node8_7_11 Node8_7_12 90588.23529411767
R_8_7_11_2 Node8_7_11 Node8_8_11 90588.23529411767
R_8_7_11_3 Node8_7_11 Node9_7_11 0.167552
C_8_7_11 Node8_7_11 GND 1.91748046875e-10
R_8_7_12_1 Node8_7_12 Node8_7_13 90588.23529411767
R_8_7_12_2 Node8_7_12 Node8_8_12 90588.23529411767
R_8_7_12_3 Node8_7_12 Node9_7_12 0.167552
C_8_7_12 Node8_7_12 GND 1.91748046875e-10
R_8_7_13_1 Node8_7_13 Node8_7_14 90588.23529411767
R_8_7_13_2 Node8_7_13 Node8_8_13 90588.23529411767
R_8_7_13_3 Node8_7_13 Node9_7_13 0.167552
C_8_7_13 Node8_7_13 GND 1.91748046875e-10
R_8_7_14_1 Node8_7_14 Node8_7_15 90588.23529411762
R_8_7_14_2 Node8_7_14 Node8_8_14 90588.23529411767
R_8_7_14_3 Node8_7_14 Node9_7_14 0.167552
C_8_7_14 Node8_7_14 GND 1.91748046875e-10
R_8_7_15_2 Node8_7_15 Node8_8_15 90588.23529411759
R_8_7_15_3 Node8_7_15 Node9_7_15 0.16755199999999984
C_8_7_15 Node8_7_15 GND 1.917480468750002e-10
R_8_8_0_1 Node8_8_0 Node8_8_1 90588.23529411767
R_8_8_0_2 Node8_8_0 Node8_9_0 90588.23529411771
R_8_8_0_3 Node8_8_0 Node9_8_0 0.167552
C_8_8_0 Node8_8_0 GND 1.91748046875e-10
R_8_8_1_1 Node8_8_1 Node8_8_2 90588.23529411767
R_8_8_1_2 Node8_8_1 Node8_9_1 90588.23529411771
R_8_8_1_3 Node8_8_1 Node9_8_1 0.167552
C_8_8_1 Node8_8_1 GND 1.91748046875e-10
R_8_8_2_1 Node8_8_2 Node8_8_3 90588.23529411767
R_8_8_2_2 Node8_8_2 Node8_9_2 90588.23529411771
R_8_8_2_3 Node8_8_2 Node9_8_2 0.167552
C_8_8_2 Node8_8_2 GND 1.91748046875e-10
R_8_8_3_1 Node8_8_3 Node8_8_4 90588.23529411767
R_8_8_3_2 Node8_8_3 Node8_9_3 90588.23529411771
R_8_8_3_3 Node8_8_3 Node9_8_3 0.167552
C_8_8_3 Node8_8_3 GND 1.91748046875e-10
R_8_8_4_1 Node8_8_4 Node8_8_5 90588.23529411767
R_8_8_4_2 Node8_8_4 Node8_9_4 90588.23529411771
R_8_8_4_3 Node8_8_4 Node9_8_4 0.167552
C_8_8_4 Node8_8_4 GND 1.91748046875e-10
R_8_8_5_1 Node8_8_5 Node8_8_6 90588.23529411767
R_8_8_5_2 Node8_8_5 Node8_9_5 90588.23529411771
R_8_8_5_3 Node8_8_5 Node9_8_5 0.167552
C_8_8_5 Node8_8_5 GND 1.91748046875e-10
R_8_8_6_1 Node8_8_6 Node8_8_7 90588.23529411767
R_8_8_6_2 Node8_8_6 Node8_9_6 90588.23529411771
R_8_8_6_3 Node8_8_6 Node9_8_6 0.16755199999999998
C_8_8_6 Node8_8_6 GND 1.9174804687500003e-10
R_8_8_7_1 Node8_8_7 Node8_8_8 90588.23529411767
R_8_8_7_2 Node8_8_7 Node8_9_7 90588.23529411771
R_8_8_7_3 Node8_8_7 Node9_8_7 0.167552
C_8_8_7 Node8_8_7 GND 1.91748046875e-10
R_8_8_8_1 Node8_8_8 Node8_8_9 90588.23529411762
R_8_8_8_2 Node8_8_8 Node8_9_8 90588.23529411771
R_8_8_8_3 Node8_8_8 Node9_8_8 0.167552
C_8_8_8 Node8_8_8 GND 1.91748046875e-10
R_8_8_9_1 Node8_8_9 Node8_8_10 90588.23529411762
R_8_8_9_2 Node8_8_9 Node8_9_9 90588.23529411765
R_8_8_9_3 Node8_8_9 Node9_8_9 0.16755199999999987
C_8_8_9 Node8_8_9 GND 1.917480468750002e-10
R_8_8_10_1 Node8_8_10 Node8_8_11 90588.23529411767
R_8_8_10_2 Node8_8_10 Node8_9_10 90588.23529411771
R_8_8_10_3 Node8_8_10 Node9_8_10 0.167552
C_8_8_10 Node8_8_10 GND 1.91748046875e-10
R_8_8_11_1 Node8_8_11 Node8_8_12 90588.23529411767
R_8_8_11_2 Node8_8_11 Node8_9_11 90588.23529411771
R_8_8_11_3 Node8_8_11 Node9_8_11 0.167552
C_8_8_11 Node8_8_11 GND 1.91748046875e-10
R_8_8_12_1 Node8_8_12 Node8_8_13 90588.23529411767
R_8_8_12_2 Node8_8_12 Node8_9_12 90588.23529411771
R_8_8_12_3 Node8_8_12 Node9_8_12 0.167552
C_8_8_12 Node8_8_12 GND 1.91748046875e-10
R_8_8_13_1 Node8_8_13 Node8_8_14 90588.23529411767
R_8_8_13_2 Node8_8_13 Node8_9_13 90588.23529411771
R_8_8_13_3 Node8_8_13 Node9_8_13 0.167552
C_8_8_13 Node8_8_13 GND 1.91748046875e-10
R_8_8_14_1 Node8_8_14 Node8_8_15 90588.23529411762
R_8_8_14_2 Node8_8_14 Node8_9_14 90588.23529411771
R_8_8_14_3 Node8_8_14 Node9_8_14 0.167552
C_8_8_14 Node8_8_14 GND 1.91748046875e-10
R_8_8_15_2 Node8_8_15 Node8_9_15 90588.23529411762
R_8_8_15_3 Node8_8_15 Node9_8_15 0.16755199999999984
C_8_8_15 Node8_8_15 GND 1.917480468750002e-10
R_8_9_0_1 Node8_9_0 Node8_9_1 90588.23529411774
R_8_9_0_2 Node8_9_0 Node8_10_0 90588.23529411771
R_8_9_0_3 Node8_9_0 Node9_9_0 0.16755200000000012
C_8_9_0 Node8_9_0 GND 1.9174804687499988e-10
R_8_9_1_1 Node8_9_1 Node8_9_2 90588.23529411775
R_8_9_1_2 Node8_9_1 Node8_10_1 90588.23529411771
R_8_9_1_3 Node8_9_1 Node9_9_1 0.16755200000000012
C_8_9_1 Node8_9_1 GND 1.9174804687499985e-10
R_8_9_2_1 Node8_9_2 Node8_9_3 90588.23529411775
R_8_9_2_2 Node8_9_2 Node8_10_2 90588.23529411771
R_8_9_2_3 Node8_9_2 Node9_9_2 0.16755200000000012
C_8_9_2 Node8_9_2 GND 1.9174804687499985e-10
R_8_9_3_1 Node8_9_3 Node8_9_4 90588.23529411775
R_8_9_3_2 Node8_9_3 Node8_10_3 90588.23529411771
R_8_9_3_3 Node8_9_3 Node9_9_3 0.16755200000000012
C_8_9_3 Node8_9_3 GND 1.9174804687499985e-10
R_8_9_4_1 Node8_9_4 Node8_9_5 90588.23529411775
R_8_9_4_2 Node8_9_4 Node8_10_4 90588.23529411771
R_8_9_4_3 Node8_9_4 Node9_9_4 0.16755200000000012
C_8_9_4 Node8_9_4 GND 1.9174804687499985e-10
R_8_9_5_1 Node8_9_5 Node8_9_6 90588.23529411775
R_8_9_5_2 Node8_9_5 Node8_10_5 90588.23529411771
R_8_9_5_3 Node8_9_5 Node9_9_5 0.16755200000000012
C_8_9_5 Node8_9_5 GND 1.9174804687499985e-10
R_8_9_6_1 Node8_9_6 Node8_9_7 90588.23529411775
R_8_9_6_2 Node8_9_6 Node8_10_6 90588.23529411771
R_8_9_6_3 Node8_9_6 Node9_9_6 0.16755200000000012
C_8_9_6 Node8_9_6 GND 1.9174804687499983e-10
R_8_9_7_1 Node8_9_7 Node8_9_8 90588.23529411775
R_8_9_7_2 Node8_9_7 Node8_10_7 90588.23529411771
R_8_9_7_3 Node8_9_7 Node9_9_7 0.16755200000000012
C_8_9_7 Node8_9_7 GND 1.9174804687499985e-10
R_8_9_8_1 Node8_9_8 Node8_9_9 90588.23529411772
R_8_9_8_2 Node8_9_8 Node8_10_8 90588.23529411771
R_8_9_8_3 Node8_9_8 Node9_9_8 0.16755200000000012
C_8_9_8 Node8_9_8 GND 1.9174804687499985e-10
R_8_9_9_1 Node8_9_9 Node8_9_10 90588.23529411772
R_8_9_9_2 Node8_9_9 Node8_10_9 90588.23529411768
R_8_9_9_3 Node8_9_9 Node9_9_9 0.16755200000000006
C_8_9_9 Node8_9_9 GND 1.9174804687499993e-10
R_8_9_10_1 Node8_9_10 Node8_9_11 90588.23529411775
R_8_9_10_2 Node8_9_10 Node8_10_10 90588.23529411771
R_8_9_10_3 Node8_9_10 Node9_9_10 0.16755200000000012
C_8_9_10 Node8_9_10 GND 1.9174804687499985e-10
R_8_9_11_1 Node8_9_11 Node8_9_12 90588.23529411775
R_8_9_11_2 Node8_9_11 Node8_10_11 90588.23529411771
R_8_9_11_3 Node8_9_11 Node9_9_11 0.16755200000000012
C_8_9_11 Node8_9_11 GND 1.9174804687499985e-10
R_8_9_12_1 Node8_9_12 Node8_9_13 90588.23529411775
R_8_9_12_2 Node8_9_12 Node8_10_12 90588.23529411771
R_8_9_12_3 Node8_9_12 Node9_9_12 0.16755200000000012
C_8_9_12 Node8_9_12 GND 1.9174804687499985e-10
R_8_9_13_1 Node8_9_13 Node8_9_14 90588.23529411775
R_8_9_13_2 Node8_9_13 Node8_10_13 90588.23529411771
R_8_9_13_3 Node8_9_13 Node9_9_13 0.16755200000000012
C_8_9_13 Node8_9_13 GND 1.9174804687499985e-10
R_8_9_14_1 Node8_9_14 Node8_9_15 90588.23529411771
R_8_9_14_2 Node8_9_14 Node8_10_14 90588.23529411771
R_8_9_14_3 Node8_9_14 Node9_9_14 0.16755200000000012
C_8_9_14 Node8_9_14 GND 1.9174804687499985e-10
R_8_9_15_2 Node8_9_15 Node8_10_15 90588.23529411762
R_8_9_15_3 Node8_9_15 Node9_9_15 0.167552
C_8_9_15 Node8_9_15 GND 1.91748046875e-10
R_8_10_0_1 Node8_10_0 Node8_10_1 90588.23529411767
R_8_10_0_2 Node8_10_0 Node8_11_0 90588.23529411767
R_8_10_0_3 Node8_10_0 Node9_10_0 0.167552
C_8_10_0 Node8_10_0 GND 1.91748046875e-10
R_8_10_1_1 Node8_10_1 Node8_10_2 90588.23529411767
R_8_10_1_2 Node8_10_1 Node8_11_1 90588.23529411767
R_8_10_1_3 Node8_10_1 Node9_10_1 0.167552
C_8_10_1 Node8_10_1 GND 1.91748046875e-10
R_8_10_2_1 Node8_10_2 Node8_10_3 90588.23529411767
R_8_10_2_2 Node8_10_2 Node8_11_2 90588.23529411767
R_8_10_2_3 Node8_10_2 Node9_10_2 0.167552
C_8_10_2 Node8_10_2 GND 1.91748046875e-10
R_8_10_3_1 Node8_10_3 Node8_10_4 90588.23529411767
R_8_10_3_2 Node8_10_3 Node8_11_3 90588.23529411767
R_8_10_3_3 Node8_10_3 Node9_10_3 0.167552
C_8_10_3 Node8_10_3 GND 1.91748046875e-10
R_8_10_4_1 Node8_10_4 Node8_10_5 90588.23529411767
R_8_10_4_2 Node8_10_4 Node8_11_4 90588.23529411767
R_8_10_4_3 Node8_10_4 Node9_10_4 0.167552
C_8_10_4 Node8_10_4 GND 1.91748046875e-10
R_8_10_5_1 Node8_10_5 Node8_10_6 90588.23529411767
R_8_10_5_2 Node8_10_5 Node8_11_5 90588.23529411767
R_8_10_5_3 Node8_10_5 Node9_10_5 0.167552
C_8_10_5 Node8_10_5 GND 1.91748046875e-10
R_8_10_6_1 Node8_10_6 Node8_10_7 90588.23529411767
R_8_10_6_2 Node8_10_6 Node8_11_6 90588.23529411767
R_8_10_6_3 Node8_10_6 Node9_10_6 0.167552
C_8_10_6 Node8_10_6 GND 1.91748046875e-10
R_8_10_7_1 Node8_10_7 Node8_10_8 90588.23529411767
R_8_10_7_2 Node8_10_7 Node8_11_7 90588.23529411767
R_8_10_7_3 Node8_10_7 Node9_10_7 0.167552
C_8_10_7 Node8_10_7 GND 1.91748046875e-10
R_8_10_8_1 Node8_10_8 Node8_10_9 90588.23529411767
R_8_10_8_2 Node8_10_8 Node8_11_8 90588.23529411767
R_8_10_8_3 Node8_10_8 Node9_10_8 0.167552
C_8_10_8 Node8_10_8 GND 1.91748046875e-10
R_8_10_9_1 Node8_10_9 Node8_10_10 90588.23529411767
R_8_10_9_2 Node8_10_9 Node8_11_9 90588.23529411767
R_8_10_9_3 Node8_10_9 Node9_10_9 0.167552
C_8_10_9 Node8_10_9 GND 1.91748046875e-10
R_8_10_10_1 Node8_10_10 Node8_10_11 90588.23529411767
R_8_10_10_2 Node8_10_10 Node8_11_10 90588.23529411767
R_8_10_10_3 Node8_10_10 Node9_10_10 0.167552
C_8_10_10 Node8_10_10 GND 1.91748046875e-10
R_8_10_11_1 Node8_10_11 Node8_10_12 90588.23529411767
R_8_10_11_2 Node8_10_11 Node8_11_11 90588.23529411767
R_8_10_11_3 Node8_10_11 Node9_10_11 0.167552
C_8_10_11 Node8_10_11 GND 1.91748046875e-10
R_8_10_12_1 Node8_10_12 Node8_10_13 90588.23529411767
R_8_10_12_2 Node8_10_12 Node8_11_12 90588.23529411767
R_8_10_12_3 Node8_10_12 Node9_10_12 0.167552
C_8_10_12 Node8_10_12 GND 1.91748046875e-10
R_8_10_13_1 Node8_10_13 Node8_10_14 90588.23529411767
R_8_10_13_2 Node8_10_13 Node8_11_13 90588.23529411767
R_8_10_13_3 Node8_10_13 Node9_10_13 0.167552
C_8_10_13 Node8_10_13 GND 1.91748046875e-10
R_8_10_14_1 Node8_10_14 Node8_10_15 90588.23529411762
R_8_10_14_2 Node8_10_14 Node8_11_14 90588.23529411767
R_8_10_14_3 Node8_10_14 Node9_10_14 0.167552
C_8_10_14 Node8_10_14 GND 1.91748046875e-10
R_8_10_15_2 Node8_10_15 Node8_11_15 90588.23529411759
R_8_10_15_3 Node8_10_15 Node9_10_15 0.16755199999999984
C_8_10_15 Node8_10_15 GND 1.917480468750002e-10
R_8_11_0_1 Node8_11_0 Node8_11_1 90588.23529411767
R_8_11_0_2 Node8_11_0 Node8_12_0 90588.23529411767
R_8_11_0_3 Node8_11_0 Node9_11_0 0.167552
C_8_11_0 Node8_11_0 GND 1.91748046875e-10
R_8_11_1_1 Node8_11_1 Node8_11_2 90588.23529411767
R_8_11_1_2 Node8_11_1 Node8_12_1 90588.23529411767
R_8_11_1_3 Node8_11_1 Node9_11_1 0.167552
C_8_11_1 Node8_11_1 GND 1.91748046875e-10
R_8_11_2_1 Node8_11_2 Node8_11_3 90588.23529411767
R_8_11_2_2 Node8_11_2 Node8_12_2 90588.23529411767
R_8_11_2_3 Node8_11_2 Node9_11_2 0.167552
C_8_11_2 Node8_11_2 GND 1.91748046875e-10
R_8_11_3_1 Node8_11_3 Node8_11_4 90588.23529411767
R_8_11_3_2 Node8_11_3 Node8_12_3 90588.23529411767
R_8_11_3_3 Node8_11_3 Node9_11_3 0.167552
C_8_11_3 Node8_11_3 GND 1.91748046875e-10
R_8_11_4_1 Node8_11_4 Node8_11_5 90588.23529411767
R_8_11_4_2 Node8_11_4 Node8_12_4 90588.23529411767
R_8_11_4_3 Node8_11_4 Node9_11_4 0.167552
C_8_11_4 Node8_11_4 GND 1.91748046875e-10
R_8_11_5_1 Node8_11_5 Node8_11_6 90588.23529411767
R_8_11_5_2 Node8_11_5 Node8_12_5 90588.23529411767
R_8_11_5_3 Node8_11_5 Node9_11_5 0.167552
C_8_11_5 Node8_11_5 GND 1.91748046875e-10
R_8_11_6_1 Node8_11_6 Node8_11_7 90588.23529411767
R_8_11_6_2 Node8_11_6 Node8_12_6 90588.23529411767
R_8_11_6_3 Node8_11_6 Node9_11_6 0.167552
C_8_11_6 Node8_11_6 GND 1.91748046875e-10
R_8_11_7_1 Node8_11_7 Node8_11_8 90588.23529411767
R_8_11_7_2 Node8_11_7 Node8_12_7 90588.23529411767
R_8_11_7_3 Node8_11_7 Node9_11_7 0.167552
C_8_11_7 Node8_11_7 GND 1.91748046875e-10
R_8_11_8_1 Node8_11_8 Node8_11_9 90588.23529411767
R_8_11_8_2 Node8_11_8 Node8_12_8 90588.23529411767
R_8_11_8_3 Node8_11_8 Node9_11_8 0.167552
C_8_11_8 Node8_11_8 GND 1.91748046875e-10
R_8_11_9_1 Node8_11_9 Node8_11_10 90588.23529411767
R_8_11_9_2 Node8_11_9 Node8_12_9 90588.23529411767
R_8_11_9_3 Node8_11_9 Node9_11_9 0.167552
C_8_11_9 Node8_11_9 GND 1.91748046875e-10
R_8_11_10_1 Node8_11_10 Node8_11_11 90588.23529411767
R_8_11_10_2 Node8_11_10 Node8_12_10 90588.23529411767
R_8_11_10_3 Node8_11_10 Node9_11_10 0.167552
C_8_11_10 Node8_11_10 GND 1.91748046875e-10
R_8_11_11_1 Node8_11_11 Node8_11_12 90588.23529411767
R_8_11_11_2 Node8_11_11 Node8_12_11 90588.23529411767
R_8_11_11_3 Node8_11_11 Node9_11_11 0.167552
C_8_11_11 Node8_11_11 GND 1.91748046875e-10
R_8_11_12_1 Node8_11_12 Node8_11_13 90588.23529411767
R_8_11_12_2 Node8_11_12 Node8_12_12 90588.23529411767
R_8_11_12_3 Node8_11_12 Node9_11_12 0.167552
C_8_11_12 Node8_11_12 GND 1.91748046875e-10
R_8_11_13_1 Node8_11_13 Node8_11_14 90588.23529411767
R_8_11_13_2 Node8_11_13 Node8_12_13 90588.23529411767
R_8_11_13_3 Node8_11_13 Node9_11_13 0.167552
C_8_11_13 Node8_11_13 GND 1.91748046875e-10
R_8_11_14_1 Node8_11_14 Node8_11_15 90588.23529411762
R_8_11_14_2 Node8_11_14 Node8_12_14 90588.23529411767
R_8_11_14_3 Node8_11_14 Node9_11_14 0.167552
C_8_11_14 Node8_11_14 GND 1.91748046875e-10
R_8_11_15_2 Node8_11_15 Node8_12_15 90588.23529411759
R_8_11_15_3 Node8_11_15 Node9_11_15 0.16755199999999984
C_8_11_15 Node8_11_15 GND 1.917480468750002e-10
R_8_12_0_1 Node8_12_0 Node8_12_1 90588.23529411767
R_8_12_0_2 Node8_12_0 Node8_13_0 90588.23529411767
R_8_12_0_3 Node8_12_0 Node9_12_0 0.167552
C_8_12_0 Node8_12_0 GND 1.91748046875e-10
R_8_12_1_1 Node8_12_1 Node8_12_2 90588.23529411767
R_8_12_1_2 Node8_12_1 Node8_13_1 90588.23529411767
R_8_12_1_3 Node8_12_1 Node9_12_1 0.167552
C_8_12_1 Node8_12_1 GND 1.91748046875e-10
R_8_12_2_1 Node8_12_2 Node8_12_3 90588.23529411767
R_8_12_2_2 Node8_12_2 Node8_13_2 90588.23529411767
R_8_12_2_3 Node8_12_2 Node9_12_2 0.167552
C_8_12_2 Node8_12_2 GND 1.91748046875e-10
R_8_12_3_1 Node8_12_3 Node8_12_4 90588.23529411767
R_8_12_3_2 Node8_12_3 Node8_13_3 90588.23529411767
R_8_12_3_3 Node8_12_3 Node9_12_3 0.167552
C_8_12_3 Node8_12_3 GND 1.91748046875e-10
R_8_12_4_1 Node8_12_4 Node8_12_5 90588.23529411767
R_8_12_4_2 Node8_12_4 Node8_13_4 90588.23529411767
R_8_12_4_3 Node8_12_4 Node9_12_4 0.167552
C_8_12_4 Node8_12_4 GND 1.91748046875e-10
R_8_12_5_1 Node8_12_5 Node8_12_6 90588.23529411767
R_8_12_5_2 Node8_12_5 Node8_13_5 90588.23529411767
R_8_12_5_3 Node8_12_5 Node9_12_5 0.167552
C_8_12_5 Node8_12_5 GND 1.91748046875e-10
R_8_12_6_1 Node8_12_6 Node8_12_7 90588.23529411767
R_8_12_6_2 Node8_12_6 Node8_13_6 90588.23529411767
R_8_12_6_3 Node8_12_6 Node9_12_6 0.167552
C_8_12_6 Node8_12_6 GND 1.91748046875e-10
R_8_12_7_1 Node8_12_7 Node8_12_8 90588.23529411767
R_8_12_7_2 Node8_12_7 Node8_13_7 90588.23529411767
R_8_12_7_3 Node8_12_7 Node9_12_7 0.167552
C_8_12_7 Node8_12_7 GND 1.91748046875e-10
R_8_12_8_1 Node8_12_8 Node8_12_9 90588.23529411767
R_8_12_8_2 Node8_12_8 Node8_13_8 90588.23529411767
R_8_12_8_3 Node8_12_8 Node9_12_8 0.167552
C_8_12_8 Node8_12_8 GND 1.91748046875e-10
R_8_12_9_1 Node8_12_9 Node8_12_10 90588.23529411767
R_8_12_9_2 Node8_12_9 Node8_13_9 90588.23529411767
R_8_12_9_3 Node8_12_9 Node9_12_9 0.167552
C_8_12_9 Node8_12_9 GND 1.91748046875e-10
R_8_12_10_1 Node8_12_10 Node8_12_11 90588.23529411767
R_8_12_10_2 Node8_12_10 Node8_13_10 90588.23529411767
R_8_12_10_3 Node8_12_10 Node9_12_10 0.167552
C_8_12_10 Node8_12_10 GND 1.91748046875e-10
R_8_12_11_1 Node8_12_11 Node8_12_12 90588.23529411767
R_8_12_11_2 Node8_12_11 Node8_13_11 90588.23529411767
R_8_12_11_3 Node8_12_11 Node9_12_11 0.167552
C_8_12_11 Node8_12_11 GND 1.91748046875e-10
R_8_12_12_1 Node8_12_12 Node8_12_13 90588.23529411767
R_8_12_12_2 Node8_12_12 Node8_13_12 90588.23529411767
R_8_12_12_3 Node8_12_12 Node9_12_12 0.167552
C_8_12_12 Node8_12_12 GND 1.91748046875e-10
R_8_12_13_1 Node8_12_13 Node8_12_14 90588.23529411767
R_8_12_13_2 Node8_12_13 Node8_13_13 90588.23529411767
R_8_12_13_3 Node8_12_13 Node9_12_13 0.167552
C_8_12_13 Node8_12_13 GND 1.91748046875e-10
R_8_12_14_1 Node8_12_14 Node8_12_15 90588.23529411762
R_8_12_14_2 Node8_12_14 Node8_13_14 90588.23529411767
R_8_12_14_3 Node8_12_14 Node9_12_14 0.167552
C_8_12_14 Node8_12_14 GND 1.91748046875e-10
R_8_12_15_2 Node8_12_15 Node8_13_15 90588.23529411759
R_8_12_15_3 Node8_12_15 Node9_12_15 0.16755199999999984
C_8_12_15 Node8_12_15 GND 1.917480468750002e-10
R_8_13_0_1 Node8_13_0 Node8_13_1 90588.23529411767
R_8_13_0_2 Node8_13_0 Node8_14_0 90588.23529411767
R_8_13_0_3 Node8_13_0 Node9_13_0 0.167552
C_8_13_0 Node8_13_0 GND 1.91748046875e-10
R_8_13_1_1 Node8_13_1 Node8_13_2 90588.23529411767
R_8_13_1_2 Node8_13_1 Node8_14_1 90588.23529411767
R_8_13_1_3 Node8_13_1 Node9_13_1 0.167552
C_8_13_1 Node8_13_1 GND 1.91748046875e-10
R_8_13_2_1 Node8_13_2 Node8_13_3 90588.23529411767
R_8_13_2_2 Node8_13_2 Node8_14_2 90588.23529411767
R_8_13_2_3 Node8_13_2 Node9_13_2 0.167552
C_8_13_2 Node8_13_2 GND 1.91748046875e-10
R_8_13_3_1 Node8_13_3 Node8_13_4 90588.23529411767
R_8_13_3_2 Node8_13_3 Node8_14_3 90588.23529411767
R_8_13_3_3 Node8_13_3 Node9_13_3 0.167552
C_8_13_3 Node8_13_3 GND 1.91748046875e-10
R_8_13_4_1 Node8_13_4 Node8_13_5 90588.23529411767
R_8_13_4_2 Node8_13_4 Node8_14_4 90588.23529411767
R_8_13_4_3 Node8_13_4 Node9_13_4 0.167552
C_8_13_4 Node8_13_4 GND 1.91748046875e-10
R_8_13_5_1 Node8_13_5 Node8_13_6 90588.23529411767
R_8_13_5_2 Node8_13_5 Node8_14_5 90588.23529411767
R_8_13_5_3 Node8_13_5 Node9_13_5 0.167552
C_8_13_5 Node8_13_5 GND 1.91748046875e-10
R_8_13_6_1 Node8_13_6 Node8_13_7 90588.23529411767
R_8_13_6_2 Node8_13_6 Node8_14_6 90588.23529411767
R_8_13_6_3 Node8_13_6 Node9_13_6 0.167552
C_8_13_6 Node8_13_6 GND 1.91748046875e-10
R_8_13_7_1 Node8_13_7 Node8_13_8 90588.23529411767
R_8_13_7_2 Node8_13_7 Node8_14_7 90588.23529411767
R_8_13_7_3 Node8_13_7 Node9_13_7 0.167552
C_8_13_7 Node8_13_7 GND 1.91748046875e-10
R_8_13_8_1 Node8_13_8 Node8_13_9 90588.23529411767
R_8_13_8_2 Node8_13_8 Node8_14_8 90588.23529411767
R_8_13_8_3 Node8_13_8 Node9_13_8 0.167552
C_8_13_8 Node8_13_8 GND 1.91748046875e-10
R_8_13_9_1 Node8_13_9 Node8_13_10 90588.23529411767
R_8_13_9_2 Node8_13_9 Node8_14_9 90588.23529411767
R_8_13_9_3 Node8_13_9 Node9_13_9 0.167552
C_8_13_9 Node8_13_9 GND 1.91748046875e-10
R_8_13_10_1 Node8_13_10 Node8_13_11 90588.23529411767
R_8_13_10_2 Node8_13_10 Node8_14_10 90588.23529411767
R_8_13_10_3 Node8_13_10 Node9_13_10 0.167552
C_8_13_10 Node8_13_10 GND 1.91748046875e-10
R_8_13_11_1 Node8_13_11 Node8_13_12 90588.23529411767
R_8_13_11_2 Node8_13_11 Node8_14_11 90588.23529411767
R_8_13_11_3 Node8_13_11 Node9_13_11 0.167552
C_8_13_11 Node8_13_11 GND 1.91748046875e-10
R_8_13_12_1 Node8_13_12 Node8_13_13 90588.23529411767
R_8_13_12_2 Node8_13_12 Node8_14_12 90588.23529411767
R_8_13_12_3 Node8_13_12 Node9_13_12 0.167552
C_8_13_12 Node8_13_12 GND 1.91748046875e-10
R_8_13_13_1 Node8_13_13 Node8_13_14 90588.23529411767
R_8_13_13_2 Node8_13_13 Node8_14_13 90588.23529411767
R_8_13_13_3 Node8_13_13 Node9_13_13 0.167552
C_8_13_13 Node8_13_13 GND 1.91748046875e-10
R_8_13_14_1 Node8_13_14 Node8_13_15 90588.23529411762
R_8_13_14_2 Node8_13_14 Node8_14_14 90588.23529411767
R_8_13_14_3 Node8_13_14 Node9_13_14 0.167552
C_8_13_14 Node8_13_14 GND 1.91748046875e-10
R_8_13_15_2 Node8_13_15 Node8_14_15 90588.23529411759
R_8_13_15_3 Node8_13_15 Node9_13_15 0.16755199999999984
C_8_13_15 Node8_13_15 GND 1.917480468750002e-10
R_8_14_0_1 Node8_14_0 Node8_14_1 90588.23529411767
R_8_14_0_2 Node8_14_0 Node8_15_0 90588.23529411767
R_8_14_0_3 Node8_14_0 Node9_14_0 0.167552
C_8_14_0 Node8_14_0 GND 1.91748046875e-10
R_8_14_1_1 Node8_14_1 Node8_14_2 90588.23529411767
R_8_14_1_2 Node8_14_1 Node8_15_1 90588.23529411767
R_8_14_1_3 Node8_14_1 Node9_14_1 0.167552
C_8_14_1 Node8_14_1 GND 1.91748046875e-10
R_8_14_2_1 Node8_14_2 Node8_14_3 90588.23529411767
R_8_14_2_2 Node8_14_2 Node8_15_2 90588.23529411767
R_8_14_2_3 Node8_14_2 Node9_14_2 0.167552
C_8_14_2 Node8_14_2 GND 1.91748046875e-10
R_8_14_3_1 Node8_14_3 Node8_14_4 90588.23529411767
R_8_14_3_2 Node8_14_3 Node8_15_3 90588.23529411767
R_8_14_3_3 Node8_14_3 Node9_14_3 0.167552
C_8_14_3 Node8_14_3 GND 1.91748046875e-10
R_8_14_4_1 Node8_14_4 Node8_14_5 90588.23529411767
R_8_14_4_2 Node8_14_4 Node8_15_4 90588.23529411767
R_8_14_4_3 Node8_14_4 Node9_14_4 0.167552
C_8_14_4 Node8_14_4 GND 1.91748046875e-10
R_8_14_5_1 Node8_14_5 Node8_14_6 90588.23529411767
R_8_14_5_2 Node8_14_5 Node8_15_5 90588.23529411767
R_8_14_5_3 Node8_14_5 Node9_14_5 0.167552
C_8_14_5 Node8_14_5 GND 1.91748046875e-10
R_8_14_6_1 Node8_14_6 Node8_14_7 90588.23529411767
R_8_14_6_2 Node8_14_6 Node8_15_6 90588.23529411767
R_8_14_6_3 Node8_14_6 Node9_14_6 0.167552
C_8_14_6 Node8_14_6 GND 1.91748046875e-10
R_8_14_7_1 Node8_14_7 Node8_14_8 90588.23529411767
R_8_14_7_2 Node8_14_7 Node8_15_7 90588.23529411767
R_8_14_7_3 Node8_14_7 Node9_14_7 0.167552
C_8_14_7 Node8_14_7 GND 1.91748046875e-10
R_8_14_8_1 Node8_14_8 Node8_14_9 90588.23529411767
R_8_14_8_2 Node8_14_8 Node8_15_8 90588.23529411767
R_8_14_8_3 Node8_14_8 Node9_14_8 0.167552
C_8_14_8 Node8_14_8 GND 1.91748046875e-10
R_8_14_9_1 Node8_14_9 Node8_14_10 90588.23529411767
R_8_14_9_2 Node8_14_9 Node8_15_9 90588.23529411767
R_8_14_9_3 Node8_14_9 Node9_14_9 0.167552
C_8_14_9 Node8_14_9 GND 1.91748046875e-10
R_8_14_10_1 Node8_14_10 Node8_14_11 90588.23529411767
R_8_14_10_2 Node8_14_10 Node8_15_10 90588.23529411767
R_8_14_10_3 Node8_14_10 Node9_14_10 0.167552
C_8_14_10 Node8_14_10 GND 1.91748046875e-10
R_8_14_11_1 Node8_14_11 Node8_14_12 90588.23529411767
R_8_14_11_2 Node8_14_11 Node8_15_11 90588.23529411767
R_8_14_11_3 Node8_14_11 Node9_14_11 0.167552
C_8_14_11 Node8_14_11 GND 1.91748046875e-10
R_8_14_12_1 Node8_14_12 Node8_14_13 90588.23529411767
R_8_14_12_2 Node8_14_12 Node8_15_12 90588.23529411767
R_8_14_12_3 Node8_14_12 Node9_14_12 0.167552
C_8_14_12 Node8_14_12 GND 1.91748046875e-10
R_8_14_13_1 Node8_14_13 Node8_14_14 90588.23529411767
R_8_14_13_2 Node8_14_13 Node8_15_13 90588.23529411767
R_8_14_13_3 Node8_14_13 Node9_14_13 0.167552
C_8_14_13 Node8_14_13 GND 1.91748046875e-10
R_8_14_14_1 Node8_14_14 Node8_14_15 90588.23529411762
R_8_14_14_2 Node8_14_14 Node8_15_14 90588.23529411767
R_8_14_14_3 Node8_14_14 Node9_14_14 0.167552
C_8_14_14 Node8_14_14 GND 1.91748046875e-10
R_8_14_15_2 Node8_14_15 Node8_15_15 90588.23529411759
R_8_14_15_3 Node8_14_15 Node9_14_15 0.16755199999999984
C_8_14_15 Node8_14_15 GND 1.917480468750002e-10
R_8_15_0_1 Node8_15_0 Node8_15_1 90588.23529411767
R_8_15_0_3 Node8_15_0 Node9_15_0 0.167552
C_8_15_0 Node8_15_0 GND 1.91748046875e-10
R_8_15_1_1 Node8_15_1 Node8_15_2 90588.23529411767
R_8_15_1_3 Node8_15_1 Node9_15_1 0.167552
C_8_15_1 Node8_15_1 GND 1.91748046875e-10
R_8_15_2_1 Node8_15_2 Node8_15_3 90588.23529411767
R_8_15_2_3 Node8_15_2 Node9_15_2 0.167552
C_8_15_2 Node8_15_2 GND 1.91748046875e-10
R_8_15_3_1 Node8_15_3 Node8_15_4 90588.23529411767
R_8_15_3_3 Node8_15_3 Node9_15_3 0.167552
C_8_15_3 Node8_15_3 GND 1.91748046875e-10
R_8_15_4_1 Node8_15_4 Node8_15_5 90588.23529411767
R_8_15_4_3 Node8_15_4 Node9_15_4 0.167552
C_8_15_4 Node8_15_4 GND 1.91748046875e-10
R_8_15_5_1 Node8_15_5 Node8_15_6 90588.23529411767
R_8_15_5_3 Node8_15_5 Node9_15_5 0.167552
C_8_15_5 Node8_15_5 GND 1.91748046875e-10
R_8_15_6_1 Node8_15_6 Node8_15_7 90588.23529411767
R_8_15_6_3 Node8_15_6 Node9_15_6 0.167552
C_8_15_6 Node8_15_6 GND 1.91748046875e-10
R_8_15_7_1 Node8_15_7 Node8_15_8 90588.23529411767
R_8_15_7_3 Node8_15_7 Node9_15_7 0.167552
C_8_15_7 Node8_15_7 GND 1.91748046875e-10
R_8_15_8_1 Node8_15_8 Node8_15_9 90588.23529411767
R_8_15_8_3 Node8_15_8 Node9_15_8 0.167552
C_8_15_8 Node8_15_8 GND 1.91748046875e-10
R_8_15_9_1 Node8_15_9 Node8_15_10 90588.23529411767
R_8_15_9_3 Node8_15_9 Node9_15_9 0.167552
C_8_15_9 Node8_15_9 GND 1.91748046875e-10
R_8_15_10_1 Node8_15_10 Node8_15_11 90588.23529411767
R_8_15_10_3 Node8_15_10 Node9_15_10 0.167552
C_8_15_10 Node8_15_10 GND 1.91748046875e-10
R_8_15_11_1 Node8_15_11 Node8_15_12 90588.23529411767
R_8_15_11_3 Node8_15_11 Node9_15_11 0.167552
C_8_15_11 Node8_15_11 GND 1.91748046875e-10
R_8_15_12_1 Node8_15_12 Node8_15_13 90588.23529411767
R_8_15_12_3 Node8_15_12 Node9_15_12 0.167552
C_8_15_12 Node8_15_12 GND 1.91748046875e-10
R_8_15_13_1 Node8_15_13 Node8_15_14 90588.23529411767
R_8_15_13_3 Node8_15_13 Node9_15_13 0.167552
C_8_15_13 Node8_15_13 GND 1.91748046875e-10
R_8_15_14_1 Node8_15_14 Node8_15_15 90588.23529411762
R_8_15_14_3 Node8_15_14 Node9_15_14 0.167552
C_8_15_14 Node8_15_14 GND 1.91748046875e-10
R_8_15_15_3 Node8_15_15 Node9_15_15 0.1675519999999998
C_8_15_15 Node8_15_15 GND 1.9174804687500021e-10
R_9_0_0_1 Node9_0_0 Node9_0_1 8517647.058823539
R_9_0_0_2 Node9_0_0 Node9_1_0 8517647.058823535
R_9_0_0_3 Node9_0_0 Node10_0_0 15.754240000000014
C_9_0_0 Node9_0_0 GND 2.9036132812499977e-10
R_9_0_1_1 Node9_0_1 Node9_0_2 8517647.058823539
R_9_0_1_2 Node9_0_1 Node9_1_1 8517647.058823535
R_9_0_1_3 Node9_0_1 Node10_0_1 15.754240000000014
C_9_0_1 Node9_0_1 GND 2.9036132812499977e-10
R_9_0_2_1 Node9_0_2 Node9_0_3 8517647.058823539
R_9_0_2_2 Node9_0_2 Node9_1_2 8517647.058823535
R_9_0_2_3 Node9_0_2 Node10_0_2 15.754240000000014
C_9_0_2 Node9_0_2 GND 2.9036132812499977e-10
R_9_0_3_1 Node9_0_3 Node9_0_4 8517647.058823539
R_9_0_3_2 Node9_0_3 Node9_1_3 8517647.058823535
R_9_0_3_3 Node9_0_3 Node10_0_3 15.754240000000014
C_9_0_3 Node9_0_3 GND 2.9036132812499977e-10
R_9_0_4_1 Node9_0_4 Node9_0_5 8517647.058823539
R_9_0_4_2 Node9_0_4 Node9_1_4 8517647.058823535
R_9_0_4_3 Node9_0_4 Node10_0_4 15.754240000000014
C_9_0_4 Node9_0_4 GND 2.9036132812499977e-10
R_9_0_5_1 Node9_0_5 Node9_0_6 8517647.058823539
R_9_0_5_2 Node9_0_5 Node9_1_5 8517647.058823535
R_9_0_5_3 Node9_0_5 Node10_0_5 15.754240000000014
C_9_0_5 Node9_0_5 GND 2.9036132812499977e-10
R_9_0_6_1 Node9_0_6 Node9_0_7 8517647.058823539
R_9_0_6_2 Node9_0_6 Node9_1_6 8517647.058823535
R_9_0_6_3 Node9_0_6 Node10_0_6 15.754240000000014
C_9_0_6 Node9_0_6 GND 2.9036132812499977e-10
R_9_0_7_1 Node9_0_7 Node9_0_8 8517647.058823539
R_9_0_7_2 Node9_0_7 Node9_1_7 8517647.058823535
R_9_0_7_3 Node9_0_7 Node10_0_7 15.754240000000014
C_9_0_7 Node9_0_7 GND 2.9036132812499977e-10
R_9_0_8_1 Node9_0_8 Node9_0_9 8517647.058823539
R_9_0_8_2 Node9_0_8 Node9_1_8 8517647.058823535
R_9_0_8_3 Node9_0_8 Node10_0_8 15.754240000000014
C_9_0_8 Node9_0_8 GND 2.9036132812499977e-10
R_9_0_9_1 Node9_0_9 Node9_0_10 8517647.058823539
R_9_0_9_2 Node9_0_9 Node9_1_9 8517647.058823535
R_9_0_9_3 Node9_0_9 Node10_0_9 15.754240000000014
C_9_0_9 Node9_0_9 GND 2.9036132812499977e-10
R_9_0_10_1 Node9_0_10 Node9_0_11 8517647.058823539
R_9_0_10_2 Node9_0_10 Node9_1_10 8517647.058823535
R_9_0_10_3 Node9_0_10 Node10_0_10 15.754240000000014
C_9_0_10 Node9_0_10 GND 2.9036132812499977e-10
R_9_0_11_1 Node9_0_11 Node9_0_12 8517647.058823539
R_9_0_11_2 Node9_0_11 Node9_1_11 8517647.058823535
R_9_0_11_3 Node9_0_11 Node10_0_11 15.754240000000014
C_9_0_11 Node9_0_11 GND 2.9036132812499977e-10
R_9_0_12_1 Node9_0_12 Node9_0_13 8517647.058823539
R_9_0_12_2 Node9_0_12 Node9_1_12 8517647.058823535
R_9_0_12_3 Node9_0_12 Node10_0_12 15.754240000000014
C_9_0_12 Node9_0_12 GND 2.9036132812499977e-10
R_9_0_13_1 Node9_0_13 Node9_0_14 8517647.058823539
R_9_0_13_2 Node9_0_13 Node9_1_13 8517647.058823535
R_9_0_13_3 Node9_0_13 Node10_0_13 15.754240000000014
C_9_0_13 Node9_0_13 GND 2.9036132812499977e-10
R_9_0_14_1 Node9_0_14 Node9_0_15 8517647.058823535
R_9_0_14_2 Node9_0_14 Node9_1_14 8517647.058823535
R_9_0_14_3 Node9_0_14 Node10_0_14 15.754240000000014
C_9_0_14 Node9_0_14 GND 2.9036132812499977e-10
R_9_0_15_2 Node9_0_15 Node9_1_15 8517647.058823528
R_9_0_15_3 Node9_0_15 Node10_0_15 15.75424
C_9_0_15 Node9_0_15 GND 2.9036132812500003e-10
R_9_1_0_1 Node9_1_0 Node9_1_1 8517647.058823531
R_9_1_0_2 Node9_1_0 Node9_2_0 8517647.058823531
R_9_1_0_3 Node9_1_0 Node10_1_0 15.75424
C_9_1_0 Node9_1_0 GND 2.9036132812500003e-10
R_9_1_1_1 Node9_1_1 Node9_1_2 8517647.058823531
R_9_1_1_2 Node9_1_1 Node9_2_1 8517647.058823531
R_9_1_1_3 Node9_1_1 Node10_1_1 15.75424
C_9_1_1 Node9_1_1 GND 2.9036132812500003e-10
R_9_1_2_1 Node9_1_2 Node9_1_3 8517647.058823531
R_9_1_2_2 Node9_1_2 Node9_2_2 8517647.058823531
R_9_1_2_3 Node9_1_2 Node10_1_2 15.75424
C_9_1_2 Node9_1_2 GND 2.9036132812500003e-10
R_9_1_3_1 Node9_1_3 Node9_1_4 8517647.058823531
R_9_1_3_2 Node9_1_3 Node9_2_3 8517647.058823531
R_9_1_3_3 Node9_1_3 Node10_1_3 15.75424
C_9_1_3 Node9_1_3 GND 2.9036132812500003e-10
R_9_1_4_1 Node9_1_4 Node9_1_5 8517647.058823531
R_9_1_4_2 Node9_1_4 Node9_2_4 8517647.058823531
R_9_1_4_3 Node9_1_4 Node10_1_4 15.75424
C_9_1_4 Node9_1_4 GND 2.9036132812500003e-10
R_9_1_5_1 Node9_1_5 Node9_1_6 8517647.058823531
R_9_1_5_2 Node9_1_5 Node9_2_5 8517647.058823531
R_9_1_5_3 Node9_1_5 Node10_1_5 15.75424
C_9_1_5 Node9_1_5 GND 2.9036132812500003e-10
R_9_1_6_1 Node9_1_6 Node9_1_7 8517647.058823531
R_9_1_6_2 Node9_1_6 Node9_2_6 8517647.058823531
R_9_1_6_3 Node9_1_6 Node10_1_6 15.75424
C_9_1_6 Node9_1_6 GND 2.9036132812500003e-10
R_9_1_7_1 Node9_1_7 Node9_1_8 8517647.058823531
R_9_1_7_2 Node9_1_7 Node9_2_7 8517647.058823531
R_9_1_7_3 Node9_1_7 Node10_1_7 15.75424
C_9_1_7 Node9_1_7 GND 2.9036132812500003e-10
R_9_1_8_1 Node9_1_8 Node9_1_9 8517647.058823531
R_9_1_8_2 Node9_1_8 Node9_2_8 8517647.058823531
R_9_1_8_3 Node9_1_8 Node10_1_8 15.75424
C_9_1_8 Node9_1_8 GND 2.9036132812500003e-10
R_9_1_9_1 Node9_1_9 Node9_1_10 8517647.058823531
R_9_1_9_2 Node9_1_9 Node9_2_9 8517647.058823531
R_9_1_9_3 Node9_1_9 Node10_1_9 15.75424
C_9_1_9 Node9_1_9 GND 2.9036132812500003e-10
R_9_1_10_1 Node9_1_10 Node9_1_11 8517647.058823531
R_9_1_10_2 Node9_1_10 Node9_2_10 8517647.058823531
R_9_1_10_3 Node9_1_10 Node10_1_10 15.75424
C_9_1_10 Node9_1_10 GND 2.9036132812500003e-10
R_9_1_11_1 Node9_1_11 Node9_1_12 8517647.058823531
R_9_1_11_2 Node9_1_11 Node9_2_11 8517647.058823531
R_9_1_11_3 Node9_1_11 Node10_1_11 15.75424
C_9_1_11 Node9_1_11 GND 2.9036132812500003e-10
R_9_1_12_1 Node9_1_12 Node9_1_13 8517647.058823531
R_9_1_12_2 Node9_1_12 Node9_2_12 8517647.058823531
R_9_1_12_3 Node9_1_12 Node10_1_12 15.75424
C_9_1_12 Node9_1_12 GND 2.9036132812500003e-10
R_9_1_13_1 Node9_1_13 Node9_1_14 8517647.058823531
R_9_1_13_2 Node9_1_13 Node9_2_13 8517647.058823531
R_9_1_13_3 Node9_1_13 Node10_1_13 15.75424
C_9_1_13 Node9_1_13 GND 2.9036132812500003e-10
R_9_1_14_1 Node9_1_14 Node9_1_15 8517647.058823528
R_9_1_14_2 Node9_1_14 Node9_2_14 8517647.058823531
R_9_1_14_3 Node9_1_14 Node10_1_14 15.75424
C_9_1_14 Node9_1_14 GND 2.9036132812500003e-10
R_9_1_15_2 Node9_1_15 Node9_2_15 8517647.058823524
R_9_1_15_3 Node9_1_15 Node10_1_15 15.754239999999987
C_9_1_15 Node9_1_15 GND 2.903613281250003e-10
R_9_2_0_1 Node9_2_0 Node9_2_1 8517647.058823531
R_9_2_0_2 Node9_2_0 Node9_3_0 8517647.058823531
R_9_2_0_3 Node9_2_0 Node10_2_0 15.75424
C_9_2_0 Node9_2_0 GND 2.9036132812500003e-10
R_9_2_1_1 Node9_2_1 Node9_2_2 8517647.058823531
R_9_2_1_2 Node9_2_1 Node9_3_1 8517647.058823531
R_9_2_1_3 Node9_2_1 Node10_2_1 15.75424
C_9_2_1 Node9_2_1 GND 2.9036132812500003e-10
R_9_2_2_1 Node9_2_2 Node9_2_3 8517647.058823531
R_9_2_2_2 Node9_2_2 Node9_3_2 8517647.058823531
R_9_2_2_3 Node9_2_2 Node10_2_2 15.75424
C_9_2_2 Node9_2_2 GND 2.9036132812500003e-10
R_9_2_3_1 Node9_2_3 Node9_2_4 8517647.058823531
R_9_2_3_2 Node9_2_3 Node9_3_3 8517647.058823531
R_9_2_3_3 Node9_2_3 Node10_2_3 15.75424
C_9_2_3 Node9_2_3 GND 2.9036132812500003e-10
R_9_2_4_1 Node9_2_4 Node9_2_5 8517647.058823531
R_9_2_4_2 Node9_2_4 Node9_3_4 8517647.058823531
R_9_2_4_3 Node9_2_4 Node10_2_4 15.75424
C_9_2_4 Node9_2_4 GND 2.9036132812500003e-10
R_9_2_5_1 Node9_2_5 Node9_2_6 8517647.058823531
R_9_2_5_2 Node9_2_5 Node9_3_5 8517647.058823531
R_9_2_5_3 Node9_2_5 Node10_2_5 15.75424
C_9_2_5 Node9_2_5 GND 2.9036132812500003e-10
R_9_2_6_1 Node9_2_6 Node9_2_7 8517647.058823531
R_9_2_6_2 Node9_2_6 Node9_3_6 8517647.058823531
R_9_2_6_3 Node9_2_6 Node10_2_6 15.75424
C_9_2_6 Node9_2_6 GND 2.9036132812500003e-10
R_9_2_7_1 Node9_2_7 Node9_2_8 8517647.058823531
R_9_2_7_2 Node9_2_7 Node9_3_7 8517647.058823531
R_9_2_7_3 Node9_2_7 Node10_2_7 15.75424
C_9_2_7 Node9_2_7 GND 2.9036132812500003e-10
R_9_2_8_1 Node9_2_8 Node9_2_9 8517647.058823531
R_9_2_8_2 Node9_2_8 Node9_3_8 8517647.058823531
R_9_2_8_3 Node9_2_8 Node10_2_8 15.75424
C_9_2_8 Node9_2_8 GND 2.9036132812500003e-10
R_9_2_9_1 Node9_2_9 Node9_2_10 8517647.058823531
R_9_2_9_2 Node9_2_9 Node9_3_9 8517647.058823531
R_9_2_9_3 Node9_2_9 Node10_2_9 15.75424
C_9_2_9 Node9_2_9 GND 2.9036132812500003e-10
R_9_2_10_1 Node9_2_10 Node9_2_11 8517647.058823531
R_9_2_10_2 Node9_2_10 Node9_3_10 8517647.058823531
R_9_2_10_3 Node9_2_10 Node10_2_10 15.75424
C_9_2_10 Node9_2_10 GND 2.9036132812500003e-10
R_9_2_11_1 Node9_2_11 Node9_2_12 8517647.058823531
R_9_2_11_2 Node9_2_11 Node9_3_11 8517647.058823531
R_9_2_11_3 Node9_2_11 Node10_2_11 15.75424
C_9_2_11 Node9_2_11 GND 2.9036132812500003e-10
R_9_2_12_1 Node9_2_12 Node9_2_13 8517647.058823531
R_9_2_12_2 Node9_2_12 Node9_3_12 8517647.058823531
R_9_2_12_3 Node9_2_12 Node10_2_12 15.75424
C_9_2_12 Node9_2_12 GND 2.9036132812500003e-10
R_9_2_13_1 Node9_2_13 Node9_2_14 8517647.058823531
R_9_2_13_2 Node9_2_13 Node9_3_13 8517647.058823531
R_9_2_13_3 Node9_2_13 Node10_2_13 15.75424
C_9_2_13 Node9_2_13 GND 2.9036132812500003e-10
R_9_2_14_1 Node9_2_14 Node9_2_15 8517647.058823528
R_9_2_14_2 Node9_2_14 Node9_3_14 8517647.058823531
R_9_2_14_3 Node9_2_14 Node10_2_14 15.75424
C_9_2_14 Node9_2_14 GND 2.9036132812500003e-10
R_9_2_15_2 Node9_2_15 Node9_3_15 8517647.058823524
R_9_2_15_3 Node9_2_15 Node10_2_15 15.754239999999987
C_9_2_15 Node9_2_15 GND 2.903613281250003e-10
R_9_3_0_1 Node9_3_0 Node9_3_1 8517647.058823531
R_9_3_0_2 Node9_3_0 Node9_4_0 8517647.058823531
R_9_3_0_3 Node9_3_0 Node10_3_0 15.75424
C_9_3_0 Node9_3_0 GND 2.9036132812500003e-10
R_9_3_1_1 Node9_3_1 Node9_3_2 8517647.058823531
R_9_3_1_2 Node9_3_1 Node9_4_1 8517647.058823531
R_9_3_1_3 Node9_3_1 Node10_3_1 15.75424
C_9_3_1 Node9_3_1 GND 2.9036132812500003e-10
R_9_3_2_1 Node9_3_2 Node9_3_3 8517647.058823531
R_9_3_2_2 Node9_3_2 Node9_4_2 8517647.058823531
R_9_3_2_3 Node9_3_2 Node10_3_2 15.75424
C_9_3_2 Node9_3_2 GND 2.9036132812500003e-10
R_9_3_3_1 Node9_3_3 Node9_3_4 8517647.058823531
R_9_3_3_2 Node9_3_3 Node9_4_3 8517647.058823531
R_9_3_3_3 Node9_3_3 Node10_3_3 15.75424
C_9_3_3 Node9_3_3 GND 2.9036132812500003e-10
R_9_3_4_1 Node9_3_4 Node9_3_5 8517647.058823531
R_9_3_4_2 Node9_3_4 Node9_4_4 8517647.058823531
R_9_3_4_3 Node9_3_4 Node10_3_4 15.75424
C_9_3_4 Node9_3_4 GND 2.9036132812500003e-10
R_9_3_5_1 Node9_3_5 Node9_3_6 8517647.058823531
R_9_3_5_2 Node9_3_5 Node9_4_5 8517647.058823531
R_9_3_5_3 Node9_3_5 Node10_3_5 15.75424
C_9_3_5 Node9_3_5 GND 2.9036132812500003e-10
R_9_3_6_1 Node9_3_6 Node9_3_7 8517647.058823531
R_9_3_6_2 Node9_3_6 Node9_4_6 8517647.058823531
R_9_3_6_3 Node9_3_6 Node10_3_6 15.75424
C_9_3_6 Node9_3_6 GND 2.9036132812500003e-10
R_9_3_7_1 Node9_3_7 Node9_3_8 8517647.058823531
R_9_3_7_2 Node9_3_7 Node9_4_7 8517647.058823531
R_9_3_7_3 Node9_3_7 Node10_3_7 15.75424
C_9_3_7 Node9_3_7 GND 2.9036132812500003e-10
R_9_3_8_1 Node9_3_8 Node9_3_9 8517647.058823531
R_9_3_8_2 Node9_3_8 Node9_4_8 8517647.058823531
R_9_3_8_3 Node9_3_8 Node10_3_8 15.75424
C_9_3_8 Node9_3_8 GND 2.9036132812500003e-10
R_9_3_9_1 Node9_3_9 Node9_3_10 8517647.058823531
R_9_3_9_2 Node9_3_9 Node9_4_9 8517647.058823531
R_9_3_9_3 Node9_3_9 Node10_3_9 15.75424
C_9_3_9 Node9_3_9 GND 2.9036132812500003e-10
R_9_3_10_1 Node9_3_10 Node9_3_11 8517647.058823531
R_9_3_10_2 Node9_3_10 Node9_4_10 8517647.058823531
R_9_3_10_3 Node9_3_10 Node10_3_10 15.75424
C_9_3_10 Node9_3_10 GND 2.9036132812500003e-10
R_9_3_11_1 Node9_3_11 Node9_3_12 8517647.058823531
R_9_3_11_2 Node9_3_11 Node9_4_11 8517647.058823531
R_9_3_11_3 Node9_3_11 Node10_3_11 15.75424
C_9_3_11 Node9_3_11 GND 2.9036132812500003e-10
R_9_3_12_1 Node9_3_12 Node9_3_13 8517647.058823531
R_9_3_12_2 Node9_3_12 Node9_4_12 8517647.058823531
R_9_3_12_3 Node9_3_12 Node10_3_12 15.75424
C_9_3_12 Node9_3_12 GND 2.9036132812500003e-10
R_9_3_13_1 Node9_3_13 Node9_3_14 8517647.058823531
R_9_3_13_2 Node9_3_13 Node9_4_13 8517647.058823531
R_9_3_13_3 Node9_3_13 Node10_3_13 15.75424
C_9_3_13 Node9_3_13 GND 2.9036132812500003e-10
R_9_3_14_1 Node9_3_14 Node9_3_15 8517647.058823528
R_9_3_14_2 Node9_3_14 Node9_4_14 8517647.058823531
R_9_3_14_3 Node9_3_14 Node10_3_14 15.75424
C_9_3_14 Node9_3_14 GND 2.9036132812500003e-10
R_9_3_15_2 Node9_3_15 Node9_4_15 8517647.058823524
R_9_3_15_3 Node9_3_15 Node10_3_15 15.754239999999987
C_9_3_15 Node9_3_15 GND 2.903613281250003e-10
R_9_4_0_1 Node9_4_0 Node9_4_1 8517647.058823531
R_9_4_0_2 Node9_4_0 Node9_5_0 8517647.058823531
R_9_4_0_3 Node9_4_0 Node10_4_0 15.75424
C_9_4_0 Node9_4_0 GND 2.9036132812500003e-10
R_9_4_1_1 Node9_4_1 Node9_4_2 8517647.058823531
R_9_4_1_2 Node9_4_1 Node9_5_1 8517647.058823531
R_9_4_1_3 Node9_4_1 Node10_4_1 15.75424
C_9_4_1 Node9_4_1 GND 2.9036132812500003e-10
R_9_4_2_1 Node9_4_2 Node9_4_3 8517647.058823531
R_9_4_2_2 Node9_4_2 Node9_5_2 8517647.058823531
R_9_4_2_3 Node9_4_2 Node10_4_2 15.75424
C_9_4_2 Node9_4_2 GND 2.9036132812500003e-10
R_9_4_3_1 Node9_4_3 Node9_4_4 8517647.058823531
R_9_4_3_2 Node9_4_3 Node9_5_3 8517647.058823531
R_9_4_3_3 Node9_4_3 Node10_4_3 15.75424
C_9_4_3 Node9_4_3 GND 2.9036132812500003e-10
R_9_4_4_1 Node9_4_4 Node9_4_5 8517647.058823531
R_9_4_4_2 Node9_4_4 Node9_5_4 8517647.058823531
R_9_4_4_3 Node9_4_4 Node10_4_4 15.75424
C_9_4_4 Node9_4_4 GND 2.9036132812500003e-10
R_9_4_5_1 Node9_4_5 Node9_4_6 8517647.058823531
R_9_4_5_2 Node9_4_5 Node9_5_5 8517647.058823531
R_9_4_5_3 Node9_4_5 Node10_4_5 15.75424
C_9_4_5 Node9_4_5 GND 2.9036132812500003e-10
R_9_4_6_1 Node9_4_6 Node9_4_7 8517647.058823531
R_9_4_6_2 Node9_4_6 Node9_5_6 8517647.058823531
R_9_4_6_3 Node9_4_6 Node10_4_6 15.75424
C_9_4_6 Node9_4_6 GND 2.9036132812500003e-10
R_9_4_7_1 Node9_4_7 Node9_4_8 8517647.058823531
R_9_4_7_2 Node9_4_7 Node9_5_7 8517647.058823531
R_9_4_7_3 Node9_4_7 Node10_4_7 15.75424
C_9_4_7 Node9_4_7 GND 2.9036132812500003e-10
R_9_4_8_1 Node9_4_8 Node9_4_9 8517647.058823531
R_9_4_8_2 Node9_4_8 Node9_5_8 8517647.058823531
R_9_4_8_3 Node9_4_8 Node10_4_8 15.75424
C_9_4_8 Node9_4_8 GND 2.9036132812500003e-10
R_9_4_9_1 Node9_4_9 Node9_4_10 8517647.058823531
R_9_4_9_2 Node9_4_9 Node9_5_9 8517647.058823531
R_9_4_9_3 Node9_4_9 Node10_4_9 15.75424
C_9_4_9 Node9_4_9 GND 2.9036132812500003e-10
R_9_4_10_1 Node9_4_10 Node9_4_11 8517647.058823531
R_9_4_10_2 Node9_4_10 Node9_5_10 8517647.058823531
R_9_4_10_3 Node9_4_10 Node10_4_10 15.75424
C_9_4_10 Node9_4_10 GND 2.9036132812500003e-10
R_9_4_11_1 Node9_4_11 Node9_4_12 8517647.058823531
R_9_4_11_2 Node9_4_11 Node9_5_11 8517647.058823531
R_9_4_11_3 Node9_4_11 Node10_4_11 15.75424
C_9_4_11 Node9_4_11 GND 2.9036132812500003e-10
R_9_4_12_1 Node9_4_12 Node9_4_13 8517647.058823531
R_9_4_12_2 Node9_4_12 Node9_5_12 8517647.058823531
R_9_4_12_3 Node9_4_12 Node10_4_12 15.75424
C_9_4_12 Node9_4_12 GND 2.9036132812500003e-10
R_9_4_13_1 Node9_4_13 Node9_4_14 8517647.058823531
R_9_4_13_2 Node9_4_13 Node9_5_13 8517647.058823531
R_9_4_13_3 Node9_4_13 Node10_4_13 15.75424
C_9_4_13 Node9_4_13 GND 2.9036132812500003e-10
R_9_4_14_1 Node9_4_14 Node9_4_15 8517647.058823528
R_9_4_14_2 Node9_4_14 Node9_5_14 8517647.058823531
R_9_4_14_3 Node9_4_14 Node10_4_14 15.75424
C_9_4_14 Node9_4_14 GND 2.9036132812500003e-10
R_9_4_15_2 Node9_4_15 Node9_5_15 8517647.058823524
R_9_4_15_3 Node9_4_15 Node10_4_15 15.754239999999987
C_9_4_15 Node9_4_15 GND 2.903613281250003e-10
R_9_5_0_1 Node9_5_0 Node9_5_1 8517647.058823531
R_9_5_0_2 Node9_5_0 Node9_6_0 8517647.058823531
R_9_5_0_3 Node9_5_0 Node10_5_0 15.75424
C_9_5_0 Node9_5_0 GND 2.9036132812500003e-10
R_9_5_1_1 Node9_5_1 Node9_5_2 8517647.058823531
R_9_5_1_2 Node9_5_1 Node9_6_1 8517647.058823533
R_9_5_1_3 Node9_5_1 Node10_5_1 15.75424
C_9_5_1 Node9_5_1 GND 2.9036132812500003e-10
R_9_5_2_1 Node9_5_2 Node9_5_3 8517647.058823531
R_9_5_2_2 Node9_5_2 Node9_6_2 8517647.058823533
R_9_5_2_3 Node9_5_2 Node10_5_2 15.75424
C_9_5_2 Node9_5_2 GND 2.9036132812500003e-10
R_9_5_3_1 Node9_5_3 Node9_5_4 8517647.058823531
R_9_5_3_2 Node9_5_3 Node9_6_3 8517647.058823533
R_9_5_3_3 Node9_5_3 Node10_5_3 15.75424
C_9_5_3 Node9_5_3 GND 2.9036132812500003e-10
R_9_5_4_1 Node9_5_4 Node9_5_5 8517647.058823531
R_9_5_4_2 Node9_5_4 Node9_6_4 8517647.058823533
R_9_5_4_3 Node9_5_4 Node10_5_4 15.75424
C_9_5_4 Node9_5_4 GND 2.9036132812500003e-10
R_9_5_5_1 Node9_5_5 Node9_5_6 8517647.058823531
R_9_5_5_2 Node9_5_5 Node9_6_5 8517647.058823533
R_9_5_5_3 Node9_5_5 Node10_5_5 15.75424
C_9_5_5 Node9_5_5 GND 2.9036132812500003e-10
R_9_5_6_1 Node9_5_6 Node9_5_7 8517647.058823531
R_9_5_6_2 Node9_5_6 Node9_6_6 8517647.058823531
R_9_5_6_3 Node9_5_6 Node10_5_6 15.75424
C_9_5_6 Node9_5_6 GND 2.9036132812500003e-10
R_9_5_7_1 Node9_5_7 Node9_5_8 8517647.058823531
R_9_5_7_2 Node9_5_7 Node9_6_7 8517647.058823533
R_9_5_7_3 Node9_5_7 Node10_5_7 15.75424
C_9_5_7 Node9_5_7 GND 2.9036132812500003e-10
R_9_5_8_1 Node9_5_8 Node9_5_9 8517647.058823531
R_9_5_8_2 Node9_5_8 Node9_6_8 8517647.058823533
R_9_5_8_3 Node9_5_8 Node10_5_8 15.75424
C_9_5_8 Node9_5_8 GND 2.9036132812500003e-10
R_9_5_9_1 Node9_5_9 Node9_5_10 8517647.058823531
R_9_5_9_2 Node9_5_9 Node9_6_9 8517647.05882353
R_9_5_9_3 Node9_5_9 Node10_5_9 15.75424
C_9_5_9 Node9_5_9 GND 2.9036132812500003e-10
R_9_5_10_1 Node9_5_10 Node9_5_11 8517647.058823531
R_9_5_10_2 Node9_5_10 Node9_6_10 8517647.058823533
R_9_5_10_3 Node9_5_10 Node10_5_10 15.75424
C_9_5_10 Node9_5_10 GND 2.9036132812500003e-10
R_9_5_11_1 Node9_5_11 Node9_5_12 8517647.058823531
R_9_5_11_2 Node9_5_11 Node9_6_11 8517647.058823533
R_9_5_11_3 Node9_5_11 Node10_5_11 15.75424
C_9_5_11 Node9_5_11 GND 2.9036132812500003e-10
R_9_5_12_1 Node9_5_12 Node9_5_13 8517647.058823531
R_9_5_12_2 Node9_5_12 Node9_6_12 8517647.058823533
R_9_5_12_3 Node9_5_12 Node10_5_12 15.75424
C_9_5_12 Node9_5_12 GND 2.9036132812500003e-10
R_9_5_13_1 Node9_5_13 Node9_5_14 8517647.058823531
R_9_5_13_2 Node9_5_13 Node9_6_13 8517647.058823533
R_9_5_13_3 Node9_5_13 Node10_5_13 15.75424
C_9_5_13 Node9_5_13 GND 2.9036132812500003e-10
R_9_5_14_1 Node9_5_14 Node9_5_15 8517647.058823528
R_9_5_14_2 Node9_5_14 Node9_6_14 8517647.058823533
R_9_5_14_3 Node9_5_14 Node10_5_14 15.75424
C_9_5_14 Node9_5_14 GND 2.9036132812500003e-10
R_9_5_15_2 Node9_5_15 Node9_6_15 8517647.058823524
R_9_5_15_3 Node9_5_15 Node10_5_15 15.754239999999987
C_9_5_15 Node9_5_15 GND 2.903613281250003e-10
R_9_6_0_1 Node9_6_0 Node9_6_1 8517647.058823533
R_9_6_0_2 Node9_6_0 Node9_7_0 8517647.058823531
R_9_6_0_3 Node9_6_0 Node10_6_0 15.75424
C_9_6_0 Node9_6_0 GND 2.9036132812500003e-10
R_9_6_1_1 Node9_6_1 Node9_6_2 8517647.058823533
R_9_6_1_2 Node9_6_1 Node9_7_1 8517647.058823533
R_9_6_1_3 Node9_6_1 Node10_6_1 15.75424
C_9_6_1 Node9_6_1 GND 2.9036132812500003e-10
R_9_6_2_1 Node9_6_2 Node9_6_3 8517647.058823533
R_9_6_2_2 Node9_6_2 Node9_7_2 8517647.058823533
R_9_6_2_3 Node9_6_2 Node10_6_2 15.75424
C_9_6_2 Node9_6_2 GND 2.9036132812500003e-10
R_9_6_3_1 Node9_6_3 Node9_6_4 8517647.058823533
R_9_6_3_2 Node9_6_3 Node9_7_3 8517647.058823533
R_9_6_3_3 Node9_6_3 Node10_6_3 15.75424
C_9_6_3 Node9_6_3 GND 2.9036132812500003e-10
R_9_6_4_1 Node9_6_4 Node9_6_5 8517647.058823533
R_9_6_4_2 Node9_6_4 Node9_7_4 8517647.058823533
R_9_6_4_3 Node9_6_4 Node10_6_4 15.75424
C_9_6_4 Node9_6_4 GND 2.9036132812500003e-10
R_9_6_5_1 Node9_6_5 Node9_6_6 8517647.058823533
R_9_6_5_2 Node9_6_5 Node9_7_5 8517647.058823533
R_9_6_5_3 Node9_6_5 Node10_6_5 15.75424
C_9_6_5 Node9_6_5 GND 2.9036132812500003e-10
R_9_6_6_1 Node9_6_6 Node9_6_7 8517647.058823533
R_9_6_6_2 Node9_6_6 Node9_7_6 8517647.058823531
R_9_6_6_3 Node9_6_6 Node10_6_6 15.754239999999998
C_9_6_6 Node9_6_6 GND 2.903613281250001e-10
R_9_6_7_1 Node9_6_7 Node9_6_8 8517647.058823533
R_9_6_7_2 Node9_6_7 Node9_7_7 8517647.058823533
R_9_6_7_3 Node9_6_7 Node10_6_7 15.75424
C_9_6_7 Node9_6_7 GND 2.9036132812500003e-10
R_9_6_8_1 Node9_6_8 Node9_6_9 8517647.05882353
R_9_6_8_2 Node9_6_8 Node9_7_8 8517647.058823533
R_9_6_8_3 Node9_6_8 Node10_6_8 15.75424
C_9_6_8 Node9_6_8 GND 2.9036132812500003e-10
R_9_6_9_1 Node9_6_9 Node9_6_10 8517647.05882353
R_9_6_9_2 Node9_6_9 Node9_7_9 8517647.058823526
R_9_6_9_3 Node9_6_9 Node10_6_9 15.75423999999999
C_9_6_9 Node9_6_9 GND 2.903613281250002e-10
R_9_6_10_1 Node9_6_10 Node9_6_11 8517647.058823533
R_9_6_10_2 Node9_6_10 Node9_7_10 8517647.058823533
R_9_6_10_3 Node9_6_10 Node10_6_10 15.75424
C_9_6_10 Node9_6_10 GND 2.9036132812500003e-10
R_9_6_11_1 Node9_6_11 Node9_6_12 8517647.058823533
R_9_6_11_2 Node9_6_11 Node9_7_11 8517647.058823533
R_9_6_11_3 Node9_6_11 Node10_6_11 15.75424
C_9_6_11 Node9_6_11 GND 2.9036132812500003e-10
R_9_6_12_1 Node9_6_12 Node9_6_13 8517647.058823533
R_9_6_12_2 Node9_6_12 Node9_7_12 8517647.058823533
R_9_6_12_3 Node9_6_12 Node10_6_12 15.75424
C_9_6_12 Node9_6_12 GND 2.9036132812500003e-10
R_9_6_13_1 Node9_6_13 Node9_6_14 8517647.058823533
R_9_6_13_2 Node9_6_13 Node9_7_13 8517647.058823533
R_9_6_13_3 Node9_6_13 Node10_6_13 15.75424
C_9_6_13 Node9_6_13 GND 2.9036132812500003e-10
R_9_6_14_1 Node9_6_14 Node9_6_15 8517647.05882353
R_9_6_14_2 Node9_6_14 Node9_7_14 8517647.058823533
R_9_6_14_3 Node9_6_14 Node10_6_14 15.75424
C_9_6_14 Node9_6_14 GND 2.9036132812500003e-10
R_9_6_15_2 Node9_6_15 Node9_7_15 8517647.058823524
R_9_6_15_3 Node9_6_15 Node10_6_15 15.754239999999987
C_9_6_15 Node9_6_15 GND 2.903613281250003e-10
R_9_7_0_1 Node9_7_0 Node9_7_1 8517647.058823531
R_9_7_0_2 Node9_7_0 Node9_8_0 8517647.058823531
R_9_7_0_3 Node9_7_0 Node10_7_0 15.75424
C_9_7_0 Node9_7_0 GND 2.9036132812500003e-10
R_9_7_1_1 Node9_7_1 Node9_7_2 8517647.058823531
R_9_7_1_2 Node9_7_1 Node9_8_1 8517647.058823531
R_9_7_1_3 Node9_7_1 Node10_7_1 15.75424
C_9_7_1 Node9_7_1 GND 2.9036132812500003e-10
R_9_7_2_1 Node9_7_2 Node9_7_3 8517647.058823531
R_9_7_2_2 Node9_7_2 Node9_8_2 8517647.058823531
R_9_7_2_3 Node9_7_2 Node10_7_2 15.75424
C_9_7_2 Node9_7_2 GND 2.9036132812500003e-10
R_9_7_3_1 Node9_7_3 Node9_7_4 8517647.058823531
R_9_7_3_2 Node9_7_3 Node9_8_3 8517647.058823531
R_9_7_3_3 Node9_7_3 Node10_7_3 15.75424
C_9_7_3 Node9_7_3 GND 2.9036132812500003e-10
R_9_7_4_1 Node9_7_4 Node9_7_5 8517647.058823531
R_9_7_4_2 Node9_7_4 Node9_8_4 8517647.058823531
R_9_7_4_3 Node9_7_4 Node10_7_4 15.75424
C_9_7_4 Node9_7_4 GND 2.9036132812500003e-10
R_9_7_5_1 Node9_7_5 Node9_7_6 8517647.058823531
R_9_7_5_2 Node9_7_5 Node9_8_5 8517647.058823531
R_9_7_5_3 Node9_7_5 Node10_7_5 15.75424
C_9_7_5 Node9_7_5 GND 2.9036132812500003e-10
R_9_7_6_1 Node9_7_6 Node9_7_7 8517647.058823531
R_9_7_6_2 Node9_7_6 Node9_8_6 8517647.058823531
R_9_7_6_3 Node9_7_6 Node10_7_6 15.75424
C_9_7_6 Node9_7_6 GND 2.9036132812500003e-10
R_9_7_7_1 Node9_7_7 Node9_7_8 8517647.058823531
R_9_7_7_2 Node9_7_7 Node9_8_7 8517647.058823531
R_9_7_7_3 Node9_7_7 Node10_7_7 15.75424
C_9_7_7 Node9_7_7 GND 2.9036132812500003e-10
R_9_7_8_1 Node9_7_8 Node9_7_9 8517647.05882353
R_9_7_8_2 Node9_7_8 Node9_8_8 8517647.058823531
R_9_7_8_3 Node9_7_8 Node10_7_8 15.75424
C_9_7_8 Node9_7_8 GND 2.9036132812500003e-10
R_9_7_9_1 Node9_7_9 Node9_7_10 8517647.05882353
R_9_7_9_2 Node9_7_9 Node9_8_9 8517647.058823526
R_9_7_9_3 Node9_7_9 Node10_7_9 15.754239999999987
C_9_7_9 Node9_7_9 GND 2.903613281250003e-10
R_9_7_10_1 Node9_7_10 Node9_7_11 8517647.058823531
R_9_7_10_2 Node9_7_10 Node9_8_10 8517647.058823531
R_9_7_10_3 Node9_7_10 Node10_7_10 15.75424
C_9_7_10 Node9_7_10 GND 2.9036132812500003e-10
R_9_7_11_1 Node9_7_11 Node9_7_12 8517647.058823531
R_9_7_11_2 Node9_7_11 Node9_8_11 8517647.058823531
R_9_7_11_3 Node9_7_11 Node10_7_11 15.75424
C_9_7_11 Node9_7_11 GND 2.9036132812500003e-10
R_9_7_12_1 Node9_7_12 Node9_7_13 8517647.058823531
R_9_7_12_2 Node9_7_12 Node9_8_12 8517647.058823531
R_9_7_12_3 Node9_7_12 Node10_7_12 15.75424
C_9_7_12 Node9_7_12 GND 2.9036132812500003e-10
R_9_7_13_1 Node9_7_13 Node9_7_14 8517647.058823531
R_9_7_13_2 Node9_7_13 Node9_8_13 8517647.058823531
R_9_7_13_3 Node9_7_13 Node10_7_13 15.75424
C_9_7_13 Node9_7_13 GND 2.9036132812500003e-10
R_9_7_14_1 Node9_7_14 Node9_7_15 8517647.058823528
R_9_7_14_2 Node9_7_14 Node9_8_14 8517647.058823531
R_9_7_14_3 Node9_7_14 Node10_7_14 15.75424
C_9_7_14 Node9_7_14 GND 2.9036132812500003e-10
R_9_7_15_2 Node9_7_15 Node9_8_15 8517647.058823524
R_9_7_15_3 Node9_7_15 Node10_7_15 15.754239999999987
C_9_7_15 Node9_7_15 GND 2.903613281250003e-10
R_9_8_0_1 Node9_8_0 Node9_8_1 8517647.058823531
R_9_8_0_2 Node9_8_0 Node9_9_0 8517647.058823535
R_9_8_0_3 Node9_8_0 Node10_8_0 15.75424
C_9_8_0 Node9_8_0 GND 2.9036132812500003e-10
R_9_8_1_1 Node9_8_1 Node9_8_2 8517647.058823531
R_9_8_1_2 Node9_8_1 Node9_9_1 8517647.058823535
R_9_8_1_3 Node9_8_1 Node10_8_1 15.75424
C_9_8_1 Node9_8_1 GND 2.9036132812500003e-10
R_9_8_2_1 Node9_8_2 Node9_8_3 8517647.058823531
R_9_8_2_2 Node9_8_2 Node9_9_2 8517647.058823535
R_9_8_2_3 Node9_8_2 Node10_8_2 15.75424
C_9_8_2 Node9_8_2 GND 2.9036132812500003e-10
R_9_8_3_1 Node9_8_3 Node9_8_4 8517647.058823531
R_9_8_3_2 Node9_8_3 Node9_9_3 8517647.058823535
R_9_8_3_3 Node9_8_3 Node10_8_3 15.75424
C_9_8_3 Node9_8_3 GND 2.9036132812500003e-10
R_9_8_4_1 Node9_8_4 Node9_8_5 8517647.058823531
R_9_8_4_2 Node9_8_4 Node9_9_4 8517647.058823535
R_9_8_4_3 Node9_8_4 Node10_8_4 15.75424
C_9_8_4 Node9_8_4 GND 2.9036132812500003e-10
R_9_8_5_1 Node9_8_5 Node9_8_6 8517647.058823531
R_9_8_5_2 Node9_8_5 Node9_9_5 8517647.058823535
R_9_8_5_3 Node9_8_5 Node10_8_5 15.75424
C_9_8_5 Node9_8_5 GND 2.9036132812500003e-10
R_9_8_6_1 Node9_8_6 Node9_8_7 8517647.058823531
R_9_8_6_2 Node9_8_6 Node9_9_6 8517647.058823535
R_9_8_6_3 Node9_8_6 Node10_8_6 15.75424
C_9_8_6 Node9_8_6 GND 2.9036132812500003e-10
R_9_8_7_1 Node9_8_7 Node9_8_8 8517647.058823531
R_9_8_7_2 Node9_8_7 Node9_9_7 8517647.058823535
R_9_8_7_3 Node9_8_7 Node10_8_7 15.75424
C_9_8_7 Node9_8_7 GND 2.9036132812500003e-10
R_9_8_8_1 Node9_8_8 Node9_8_9 8517647.05882353
R_9_8_8_2 Node9_8_8 Node9_9_8 8517647.058823535
R_9_8_8_3 Node9_8_8 Node10_8_8 15.75424
C_9_8_8 Node9_8_8 GND 2.9036132812500003e-10
R_9_8_9_1 Node9_8_9 Node9_8_10 8517647.05882353
R_9_8_9_2 Node9_8_9 Node9_9_9 8517647.05882353
R_9_8_9_3 Node9_8_9 Node10_8_9 15.754239999999987
C_9_8_9 Node9_8_9 GND 2.903613281250003e-10
R_9_8_10_1 Node9_8_10 Node9_8_11 8517647.058823531
R_9_8_10_2 Node9_8_10 Node9_9_10 8517647.058823535
R_9_8_10_3 Node9_8_10 Node10_8_10 15.75424
C_9_8_10 Node9_8_10 GND 2.9036132812500003e-10
R_9_8_11_1 Node9_8_11 Node9_8_12 8517647.058823531
R_9_8_11_2 Node9_8_11 Node9_9_11 8517647.058823535
R_9_8_11_3 Node9_8_11 Node10_8_11 15.75424
C_9_8_11 Node9_8_11 GND 2.9036132812500003e-10
R_9_8_12_1 Node9_8_12 Node9_8_13 8517647.058823531
R_9_8_12_2 Node9_8_12 Node9_9_12 8517647.058823535
R_9_8_12_3 Node9_8_12 Node10_8_12 15.75424
C_9_8_12 Node9_8_12 GND 2.9036132812500003e-10
R_9_8_13_1 Node9_8_13 Node9_8_14 8517647.058823531
R_9_8_13_2 Node9_8_13 Node9_9_13 8517647.058823535
R_9_8_13_3 Node9_8_13 Node10_8_13 15.75424
C_9_8_13 Node9_8_13 GND 2.9036132812500003e-10
R_9_8_14_1 Node9_8_14 Node9_8_15 8517647.058823528
R_9_8_14_2 Node9_8_14 Node9_9_14 8517647.058823535
R_9_8_14_3 Node9_8_14 Node10_8_14 15.75424
C_9_8_14 Node9_8_14 GND 2.9036132812500003e-10
R_9_8_15_2 Node9_8_15 Node9_9_15 8517647.058823528
R_9_8_15_3 Node9_8_15 Node10_8_15 15.754239999999987
C_9_8_15 Node9_8_15 GND 2.903613281250003e-10
R_9_9_0_1 Node9_9_0 Node9_9_1 8517647.058823539
R_9_9_0_2 Node9_9_0 Node9_10_0 8517647.058823535
R_9_9_0_3 Node9_9_0 Node10_9_0 15.754240000000014
C_9_9_0 Node9_9_0 GND 2.903613281249998e-10
R_9_9_1_1 Node9_9_1 Node9_9_2 8517647.058823539
R_9_9_1_2 Node9_9_1 Node9_10_1 8517647.058823535
R_9_9_1_3 Node9_9_1 Node10_9_1 15.754240000000014
C_9_9_1 Node9_9_1 GND 2.9036132812499977e-10
R_9_9_2_1 Node9_9_2 Node9_9_3 8517647.058823539
R_9_9_2_2 Node9_9_2 Node9_10_2 8517647.058823535
R_9_9_2_3 Node9_9_2 Node10_9_2 15.754240000000014
C_9_9_2 Node9_9_2 GND 2.9036132812499977e-10
R_9_9_3_1 Node9_9_3 Node9_9_4 8517647.058823539
R_9_9_3_2 Node9_9_3 Node9_10_3 8517647.058823535
R_9_9_3_3 Node9_9_3 Node10_9_3 15.754240000000014
C_9_9_3 Node9_9_3 GND 2.9036132812499977e-10
R_9_9_4_1 Node9_9_4 Node9_9_5 8517647.058823539
R_9_9_4_2 Node9_9_4 Node9_10_4 8517647.058823535
R_9_9_4_3 Node9_9_4 Node10_9_4 15.754240000000014
C_9_9_4 Node9_9_4 GND 2.9036132812499977e-10
R_9_9_5_1 Node9_9_5 Node9_9_6 8517647.058823539
R_9_9_5_2 Node9_9_5 Node9_10_5 8517647.058823535
R_9_9_5_3 Node9_9_5 Node10_9_5 15.754240000000014
C_9_9_5 Node9_9_5 GND 2.9036132812499977e-10
R_9_9_6_1 Node9_9_6 Node9_9_7 8517647.058823539
R_9_9_6_2 Node9_9_6 Node9_10_6 8517647.058823535
R_9_9_6_3 Node9_9_6 Node10_9_6 15.754240000000014
C_9_9_6 Node9_9_6 GND 2.9036132812499977e-10
R_9_9_7_1 Node9_9_7 Node9_9_8 8517647.058823539
R_9_9_7_2 Node9_9_7 Node9_10_7 8517647.058823535
R_9_9_7_3 Node9_9_7 Node10_9_7 15.754240000000014
C_9_9_7 Node9_9_7 GND 2.9036132812499977e-10
R_9_9_8_1 Node9_9_8 Node9_9_9 8517647.058823537
R_9_9_8_2 Node9_9_8 Node9_10_8 8517647.058823535
R_9_9_8_3 Node9_9_8 Node10_9_8 15.754240000000014
C_9_9_8 Node9_9_8 GND 2.9036132812499977e-10
R_9_9_9_1 Node9_9_9 Node9_9_10 8517647.058823537
R_9_9_9_2 Node9_9_9 Node9_10_9 8517647.058823533
R_9_9_9_3 Node9_9_9 Node10_9_9 15.754240000000003
C_9_9_9 Node9_9_9 GND 2.903613281249999e-10
R_9_9_10_1 Node9_9_10 Node9_9_11 8517647.058823539
R_9_9_10_2 Node9_9_10 Node9_10_10 8517647.058823535
R_9_9_10_3 Node9_9_10 Node10_9_10 15.754240000000014
C_9_9_10 Node9_9_10 GND 2.9036132812499977e-10
R_9_9_11_1 Node9_9_11 Node9_9_12 8517647.058823539
R_9_9_11_2 Node9_9_11 Node9_10_11 8517647.058823535
R_9_9_11_3 Node9_9_11 Node10_9_11 15.754240000000014
C_9_9_11 Node9_9_11 GND 2.9036132812499977e-10
R_9_9_12_1 Node9_9_12 Node9_9_13 8517647.058823539
R_9_9_12_2 Node9_9_12 Node9_10_12 8517647.058823535
R_9_9_12_3 Node9_9_12 Node10_9_12 15.754240000000014
C_9_9_12 Node9_9_12 GND 2.9036132812499977e-10
R_9_9_13_1 Node9_9_13 Node9_9_14 8517647.058823539
R_9_9_13_2 Node9_9_13 Node9_10_13 8517647.058823535
R_9_9_13_3 Node9_9_13 Node10_9_13 15.754240000000014
C_9_9_13 Node9_9_13 GND 2.9036132812499977e-10
R_9_9_14_1 Node9_9_14 Node9_9_15 8517647.058823535
R_9_9_14_2 Node9_9_14 Node9_10_14 8517647.058823535
R_9_9_14_3 Node9_9_14 Node10_9_14 15.754240000000014
C_9_9_14 Node9_9_14 GND 2.9036132812499977e-10
R_9_9_15_2 Node9_9_15 Node9_10_15 8517647.058823528
R_9_9_15_3 Node9_9_15 Node10_9_15 15.75424
C_9_9_15 Node9_9_15 GND 2.9036132812500003e-10
R_9_10_0_1 Node9_10_0 Node9_10_1 8517647.058823531
R_9_10_0_2 Node9_10_0 Node9_11_0 8517647.058823531
R_9_10_0_3 Node9_10_0 Node10_10_0 15.75424
C_9_10_0 Node9_10_0 GND 2.9036132812500003e-10
R_9_10_1_1 Node9_10_1 Node9_10_2 8517647.058823531
R_9_10_1_2 Node9_10_1 Node9_11_1 8517647.058823531
R_9_10_1_3 Node9_10_1 Node10_10_1 15.75424
C_9_10_1 Node9_10_1 GND 2.9036132812500003e-10
R_9_10_2_1 Node9_10_2 Node9_10_3 8517647.058823531
R_9_10_2_2 Node9_10_2 Node9_11_2 8517647.058823531
R_9_10_2_3 Node9_10_2 Node10_10_2 15.75424
C_9_10_2 Node9_10_2 GND 2.9036132812500003e-10
R_9_10_3_1 Node9_10_3 Node9_10_4 8517647.058823531
R_9_10_3_2 Node9_10_3 Node9_11_3 8517647.058823531
R_9_10_3_3 Node9_10_3 Node10_10_3 15.75424
C_9_10_3 Node9_10_3 GND 2.9036132812500003e-10
R_9_10_4_1 Node9_10_4 Node9_10_5 8517647.058823531
R_9_10_4_2 Node9_10_4 Node9_11_4 8517647.058823531
R_9_10_4_3 Node9_10_4 Node10_10_4 15.75424
C_9_10_4 Node9_10_4 GND 2.9036132812500003e-10
R_9_10_5_1 Node9_10_5 Node9_10_6 8517647.058823531
R_9_10_5_2 Node9_10_5 Node9_11_5 8517647.058823531
R_9_10_5_3 Node9_10_5 Node10_10_5 15.75424
C_9_10_5 Node9_10_5 GND 2.9036132812500003e-10
R_9_10_6_1 Node9_10_6 Node9_10_7 8517647.058823531
R_9_10_6_2 Node9_10_6 Node9_11_6 8517647.058823531
R_9_10_6_3 Node9_10_6 Node10_10_6 15.75424
C_9_10_6 Node9_10_6 GND 2.9036132812500003e-10
R_9_10_7_1 Node9_10_7 Node9_10_8 8517647.058823531
R_9_10_7_2 Node9_10_7 Node9_11_7 8517647.058823531
R_9_10_7_3 Node9_10_7 Node10_10_7 15.75424
C_9_10_7 Node9_10_7 GND 2.9036132812500003e-10
R_9_10_8_1 Node9_10_8 Node9_10_9 8517647.058823531
R_9_10_8_2 Node9_10_8 Node9_11_8 8517647.058823531
R_9_10_8_3 Node9_10_8 Node10_10_8 15.75424
C_9_10_8 Node9_10_8 GND 2.9036132812500003e-10
R_9_10_9_1 Node9_10_9 Node9_10_10 8517647.058823531
R_9_10_9_2 Node9_10_9 Node9_11_9 8517647.058823531
R_9_10_9_3 Node9_10_9 Node10_10_9 15.75424
C_9_10_9 Node9_10_9 GND 2.9036132812500003e-10
R_9_10_10_1 Node9_10_10 Node9_10_11 8517647.058823531
R_9_10_10_2 Node9_10_10 Node9_11_10 8517647.058823531
R_9_10_10_3 Node9_10_10 Node10_10_10 15.75424
C_9_10_10 Node9_10_10 GND 2.9036132812500003e-10
R_9_10_11_1 Node9_10_11 Node9_10_12 8517647.058823531
R_9_10_11_2 Node9_10_11 Node9_11_11 8517647.058823531
R_9_10_11_3 Node9_10_11 Node10_10_11 15.75424
C_9_10_11 Node9_10_11 GND 2.9036132812500003e-10
R_9_10_12_1 Node9_10_12 Node9_10_13 8517647.058823531
R_9_10_12_2 Node9_10_12 Node9_11_12 8517647.058823531
R_9_10_12_3 Node9_10_12 Node10_10_12 15.75424
C_9_10_12 Node9_10_12 GND 2.9036132812500003e-10
R_9_10_13_1 Node9_10_13 Node9_10_14 8517647.058823531
R_9_10_13_2 Node9_10_13 Node9_11_13 8517647.058823531
R_9_10_13_3 Node9_10_13 Node10_10_13 15.75424
C_9_10_13 Node9_10_13 GND 2.9036132812500003e-10
R_9_10_14_1 Node9_10_14 Node9_10_15 8517647.058823528
R_9_10_14_2 Node9_10_14 Node9_11_14 8517647.058823531
R_9_10_14_3 Node9_10_14 Node10_10_14 15.75424
C_9_10_14 Node9_10_14 GND 2.9036132812500003e-10
R_9_10_15_2 Node9_10_15 Node9_11_15 8517647.058823524
R_9_10_15_3 Node9_10_15 Node10_10_15 15.754239999999987
C_9_10_15 Node9_10_15 GND 2.903613281250003e-10
R_9_11_0_1 Node9_11_0 Node9_11_1 8517647.058823531
R_9_11_0_2 Node9_11_0 Node9_12_0 8517647.058823531
R_9_11_0_3 Node9_11_0 Node10_11_0 15.75424
C_9_11_0 Node9_11_0 GND 2.9036132812500003e-10
R_9_11_1_1 Node9_11_1 Node9_11_2 8517647.058823531
R_9_11_1_2 Node9_11_1 Node9_12_1 8517647.058823531
R_9_11_1_3 Node9_11_1 Node10_11_1 15.75424
C_9_11_1 Node9_11_1 GND 2.9036132812500003e-10
R_9_11_2_1 Node9_11_2 Node9_11_3 8517647.058823531
R_9_11_2_2 Node9_11_2 Node9_12_2 8517647.058823531
R_9_11_2_3 Node9_11_2 Node10_11_2 15.75424
C_9_11_2 Node9_11_2 GND 2.9036132812500003e-10
R_9_11_3_1 Node9_11_3 Node9_11_4 8517647.058823531
R_9_11_3_2 Node9_11_3 Node9_12_3 8517647.058823531
R_9_11_3_3 Node9_11_3 Node10_11_3 15.75424
C_9_11_3 Node9_11_3 GND 2.9036132812500003e-10
R_9_11_4_1 Node9_11_4 Node9_11_5 8517647.058823531
R_9_11_4_2 Node9_11_4 Node9_12_4 8517647.058823531
R_9_11_4_3 Node9_11_4 Node10_11_4 15.75424
C_9_11_4 Node9_11_4 GND 2.9036132812500003e-10
R_9_11_5_1 Node9_11_5 Node9_11_6 8517647.058823531
R_9_11_5_2 Node9_11_5 Node9_12_5 8517647.058823531
R_9_11_5_3 Node9_11_5 Node10_11_5 15.75424
C_9_11_5 Node9_11_5 GND 2.9036132812500003e-10
R_9_11_6_1 Node9_11_6 Node9_11_7 8517647.058823531
R_9_11_6_2 Node9_11_6 Node9_12_6 8517647.058823531
R_9_11_6_3 Node9_11_6 Node10_11_6 15.75424
C_9_11_6 Node9_11_6 GND 2.9036132812500003e-10
R_9_11_7_1 Node9_11_7 Node9_11_8 8517647.058823531
R_9_11_7_2 Node9_11_7 Node9_12_7 8517647.058823531
R_9_11_7_3 Node9_11_7 Node10_11_7 15.75424
C_9_11_7 Node9_11_7 GND 2.9036132812500003e-10
R_9_11_8_1 Node9_11_8 Node9_11_9 8517647.058823531
R_9_11_8_2 Node9_11_8 Node9_12_8 8517647.058823531
R_9_11_8_3 Node9_11_8 Node10_11_8 15.75424
C_9_11_8 Node9_11_8 GND 2.9036132812500003e-10
R_9_11_9_1 Node9_11_9 Node9_11_10 8517647.058823531
R_9_11_9_2 Node9_11_9 Node9_12_9 8517647.058823531
R_9_11_9_3 Node9_11_9 Node10_11_9 15.75424
C_9_11_9 Node9_11_9 GND 2.9036132812500003e-10
R_9_11_10_1 Node9_11_10 Node9_11_11 8517647.058823531
R_9_11_10_2 Node9_11_10 Node9_12_10 8517647.058823531
R_9_11_10_3 Node9_11_10 Node10_11_10 15.75424
C_9_11_10 Node9_11_10 GND 2.9036132812500003e-10
R_9_11_11_1 Node9_11_11 Node9_11_12 8517647.058823531
R_9_11_11_2 Node9_11_11 Node9_12_11 8517647.058823531
R_9_11_11_3 Node9_11_11 Node10_11_11 15.75424
C_9_11_11 Node9_11_11 GND 2.9036132812500003e-10
R_9_11_12_1 Node9_11_12 Node9_11_13 8517647.058823531
R_9_11_12_2 Node9_11_12 Node9_12_12 8517647.058823531
R_9_11_12_3 Node9_11_12 Node10_11_12 15.75424
C_9_11_12 Node9_11_12 GND 2.9036132812500003e-10
R_9_11_13_1 Node9_11_13 Node9_11_14 8517647.058823531
R_9_11_13_2 Node9_11_13 Node9_12_13 8517647.058823531
R_9_11_13_3 Node9_11_13 Node10_11_13 15.75424
C_9_11_13 Node9_11_13 GND 2.9036132812500003e-10
R_9_11_14_1 Node9_11_14 Node9_11_15 8517647.058823528
R_9_11_14_2 Node9_11_14 Node9_12_14 8517647.058823531
R_9_11_14_3 Node9_11_14 Node10_11_14 15.75424
C_9_11_14 Node9_11_14 GND 2.9036132812500003e-10
R_9_11_15_2 Node9_11_15 Node9_12_15 8517647.058823524
R_9_11_15_3 Node9_11_15 Node10_11_15 15.754239999999987
C_9_11_15 Node9_11_15 GND 2.903613281250003e-10
R_9_12_0_1 Node9_12_0 Node9_12_1 8517647.058823531
R_9_12_0_2 Node9_12_0 Node9_13_0 8517647.058823531
R_9_12_0_3 Node9_12_0 Node10_12_0 15.75424
C_9_12_0 Node9_12_0 GND 2.9036132812500003e-10
R_9_12_1_1 Node9_12_1 Node9_12_2 8517647.058823531
R_9_12_1_2 Node9_12_1 Node9_13_1 8517647.058823531
R_9_12_1_3 Node9_12_1 Node10_12_1 15.75424
C_9_12_1 Node9_12_1 GND 2.9036132812500003e-10
R_9_12_2_1 Node9_12_2 Node9_12_3 8517647.058823531
R_9_12_2_2 Node9_12_2 Node9_13_2 8517647.058823531
R_9_12_2_3 Node9_12_2 Node10_12_2 15.75424
C_9_12_2 Node9_12_2 GND 2.9036132812500003e-10
R_9_12_3_1 Node9_12_3 Node9_12_4 8517647.058823531
R_9_12_3_2 Node9_12_3 Node9_13_3 8517647.058823531
R_9_12_3_3 Node9_12_3 Node10_12_3 15.75424
C_9_12_3 Node9_12_3 GND 2.9036132812500003e-10
R_9_12_4_1 Node9_12_4 Node9_12_5 8517647.058823531
R_9_12_4_2 Node9_12_4 Node9_13_4 8517647.058823531
R_9_12_4_3 Node9_12_4 Node10_12_4 15.75424
C_9_12_4 Node9_12_4 GND 2.9036132812500003e-10
R_9_12_5_1 Node9_12_5 Node9_12_6 8517647.058823531
R_9_12_5_2 Node9_12_5 Node9_13_5 8517647.058823531
R_9_12_5_3 Node9_12_5 Node10_12_5 15.75424
C_9_12_5 Node9_12_5 GND 2.9036132812500003e-10
R_9_12_6_1 Node9_12_6 Node9_12_7 8517647.058823531
R_9_12_6_2 Node9_12_6 Node9_13_6 8517647.058823531
R_9_12_6_3 Node9_12_6 Node10_12_6 15.75424
C_9_12_6 Node9_12_6 GND 2.9036132812500003e-10
R_9_12_7_1 Node9_12_7 Node9_12_8 8517647.058823531
R_9_12_7_2 Node9_12_7 Node9_13_7 8517647.058823531
R_9_12_7_3 Node9_12_7 Node10_12_7 15.75424
C_9_12_7 Node9_12_7 GND 2.9036132812500003e-10
R_9_12_8_1 Node9_12_8 Node9_12_9 8517647.058823531
R_9_12_8_2 Node9_12_8 Node9_13_8 8517647.058823531
R_9_12_8_3 Node9_12_8 Node10_12_8 15.75424
C_9_12_8 Node9_12_8 GND 2.9036132812500003e-10
R_9_12_9_1 Node9_12_9 Node9_12_10 8517647.058823531
R_9_12_9_2 Node9_12_9 Node9_13_9 8517647.058823531
R_9_12_9_3 Node9_12_9 Node10_12_9 15.75424
C_9_12_9 Node9_12_9 GND 2.9036132812500003e-10
R_9_12_10_1 Node9_12_10 Node9_12_11 8517647.058823531
R_9_12_10_2 Node9_12_10 Node9_13_10 8517647.058823531
R_9_12_10_3 Node9_12_10 Node10_12_10 15.75424
C_9_12_10 Node9_12_10 GND 2.9036132812500003e-10
R_9_12_11_1 Node9_12_11 Node9_12_12 8517647.058823531
R_9_12_11_2 Node9_12_11 Node9_13_11 8517647.058823531
R_9_12_11_3 Node9_12_11 Node10_12_11 15.75424
C_9_12_11 Node9_12_11 GND 2.9036132812500003e-10
R_9_12_12_1 Node9_12_12 Node9_12_13 8517647.058823531
R_9_12_12_2 Node9_12_12 Node9_13_12 8517647.058823531
R_9_12_12_3 Node9_12_12 Node10_12_12 15.75424
C_9_12_12 Node9_12_12 GND 2.9036132812500003e-10
R_9_12_13_1 Node9_12_13 Node9_12_14 8517647.058823531
R_9_12_13_2 Node9_12_13 Node9_13_13 8517647.058823531
R_9_12_13_3 Node9_12_13 Node10_12_13 15.75424
C_9_12_13 Node9_12_13 GND 2.9036132812500003e-10
R_9_12_14_1 Node9_12_14 Node9_12_15 8517647.058823528
R_9_12_14_2 Node9_12_14 Node9_13_14 8517647.058823531
R_9_12_14_3 Node9_12_14 Node10_12_14 15.75424
C_9_12_14 Node9_12_14 GND 2.9036132812500003e-10
R_9_12_15_2 Node9_12_15 Node9_13_15 8517647.058823524
R_9_12_15_3 Node9_12_15 Node10_12_15 15.754239999999987
C_9_12_15 Node9_12_15 GND 2.903613281250003e-10
R_9_13_0_1 Node9_13_0 Node9_13_1 8517647.058823531
R_9_13_0_2 Node9_13_0 Node9_14_0 8517647.058823531
R_9_13_0_3 Node9_13_0 Node10_13_0 15.75424
C_9_13_0 Node9_13_0 GND 2.9036132812500003e-10
R_9_13_1_1 Node9_13_1 Node9_13_2 8517647.058823531
R_9_13_1_2 Node9_13_1 Node9_14_1 8517647.058823531
R_9_13_1_3 Node9_13_1 Node10_13_1 15.75424
C_9_13_1 Node9_13_1 GND 2.9036132812500003e-10
R_9_13_2_1 Node9_13_2 Node9_13_3 8517647.058823531
R_9_13_2_2 Node9_13_2 Node9_14_2 8517647.058823531
R_9_13_2_3 Node9_13_2 Node10_13_2 15.75424
C_9_13_2 Node9_13_2 GND 2.9036132812500003e-10
R_9_13_3_1 Node9_13_3 Node9_13_4 8517647.058823531
R_9_13_3_2 Node9_13_3 Node9_14_3 8517647.058823531
R_9_13_3_3 Node9_13_3 Node10_13_3 15.75424
C_9_13_3 Node9_13_3 GND 2.9036132812500003e-10
R_9_13_4_1 Node9_13_4 Node9_13_5 8517647.058823531
R_9_13_4_2 Node9_13_4 Node9_14_4 8517647.058823531
R_9_13_4_3 Node9_13_4 Node10_13_4 15.75424
C_9_13_4 Node9_13_4 GND 2.9036132812500003e-10
R_9_13_5_1 Node9_13_5 Node9_13_6 8517647.058823531
R_9_13_5_2 Node9_13_5 Node9_14_5 8517647.058823531
R_9_13_5_3 Node9_13_5 Node10_13_5 15.75424
C_9_13_5 Node9_13_5 GND 2.9036132812500003e-10
R_9_13_6_1 Node9_13_6 Node9_13_7 8517647.058823531
R_9_13_6_2 Node9_13_6 Node9_14_6 8517647.058823531
R_9_13_6_3 Node9_13_6 Node10_13_6 15.75424
C_9_13_6 Node9_13_6 GND 2.9036132812500003e-10
R_9_13_7_1 Node9_13_7 Node9_13_8 8517647.058823531
R_9_13_7_2 Node9_13_7 Node9_14_7 8517647.058823531
R_9_13_7_3 Node9_13_7 Node10_13_7 15.75424
C_9_13_7 Node9_13_7 GND 2.9036132812500003e-10
R_9_13_8_1 Node9_13_8 Node9_13_9 8517647.058823531
R_9_13_8_2 Node9_13_8 Node9_14_8 8517647.058823531
R_9_13_8_3 Node9_13_8 Node10_13_8 15.75424
C_9_13_8 Node9_13_8 GND 2.9036132812500003e-10
R_9_13_9_1 Node9_13_9 Node9_13_10 8517647.058823531
R_9_13_9_2 Node9_13_9 Node9_14_9 8517647.058823531
R_9_13_9_3 Node9_13_9 Node10_13_9 15.75424
C_9_13_9 Node9_13_9 GND 2.9036132812500003e-10
R_9_13_10_1 Node9_13_10 Node9_13_11 8517647.058823531
R_9_13_10_2 Node9_13_10 Node9_14_10 8517647.058823531
R_9_13_10_3 Node9_13_10 Node10_13_10 15.75424
C_9_13_10 Node9_13_10 GND 2.9036132812500003e-10
R_9_13_11_1 Node9_13_11 Node9_13_12 8517647.058823531
R_9_13_11_2 Node9_13_11 Node9_14_11 8517647.058823531
R_9_13_11_3 Node9_13_11 Node10_13_11 15.75424
C_9_13_11 Node9_13_11 GND 2.9036132812500003e-10
R_9_13_12_1 Node9_13_12 Node9_13_13 8517647.058823531
R_9_13_12_2 Node9_13_12 Node9_14_12 8517647.058823531
R_9_13_12_3 Node9_13_12 Node10_13_12 15.75424
C_9_13_12 Node9_13_12 GND 2.9036132812500003e-10
R_9_13_13_1 Node9_13_13 Node9_13_14 8517647.058823531
R_9_13_13_2 Node9_13_13 Node9_14_13 8517647.058823531
R_9_13_13_3 Node9_13_13 Node10_13_13 15.75424
C_9_13_13 Node9_13_13 GND 2.9036132812500003e-10
R_9_13_14_1 Node9_13_14 Node9_13_15 8517647.058823528
R_9_13_14_2 Node9_13_14 Node9_14_14 8517647.058823531
R_9_13_14_3 Node9_13_14 Node10_13_14 15.75424
C_9_13_14 Node9_13_14 GND 2.9036132812500003e-10
R_9_13_15_2 Node9_13_15 Node9_14_15 8517647.058823524
R_9_13_15_3 Node9_13_15 Node10_13_15 15.754239999999987
C_9_13_15 Node9_13_15 GND 2.903613281250003e-10
R_9_14_0_1 Node9_14_0 Node9_14_1 8517647.058823531
R_9_14_0_2 Node9_14_0 Node9_15_0 8517647.058823531
R_9_14_0_3 Node9_14_0 Node10_14_0 15.75424
C_9_14_0 Node9_14_0 GND 2.9036132812500003e-10
R_9_14_1_1 Node9_14_1 Node9_14_2 8517647.058823531
R_9_14_1_2 Node9_14_1 Node9_15_1 8517647.058823531
R_9_14_1_3 Node9_14_1 Node10_14_1 15.75424
C_9_14_1 Node9_14_1 GND 2.9036132812500003e-10
R_9_14_2_1 Node9_14_2 Node9_14_3 8517647.058823531
R_9_14_2_2 Node9_14_2 Node9_15_2 8517647.058823531
R_9_14_2_3 Node9_14_2 Node10_14_2 15.75424
C_9_14_2 Node9_14_2 GND 2.9036132812500003e-10
R_9_14_3_1 Node9_14_3 Node9_14_4 8517647.058823531
R_9_14_3_2 Node9_14_3 Node9_15_3 8517647.058823531
R_9_14_3_3 Node9_14_3 Node10_14_3 15.75424
C_9_14_3 Node9_14_3 GND 2.9036132812500003e-10
R_9_14_4_1 Node9_14_4 Node9_14_5 8517647.058823531
R_9_14_4_2 Node9_14_4 Node9_15_4 8517647.058823531
R_9_14_4_3 Node9_14_4 Node10_14_4 15.75424
C_9_14_4 Node9_14_4 GND 2.9036132812500003e-10
R_9_14_5_1 Node9_14_5 Node9_14_6 8517647.058823531
R_9_14_5_2 Node9_14_5 Node9_15_5 8517647.058823531
R_9_14_5_3 Node9_14_5 Node10_14_5 15.75424
C_9_14_5 Node9_14_5 GND 2.9036132812500003e-10
R_9_14_6_1 Node9_14_6 Node9_14_7 8517647.058823531
R_9_14_6_2 Node9_14_6 Node9_15_6 8517647.058823531
R_9_14_6_3 Node9_14_6 Node10_14_6 15.75424
C_9_14_6 Node9_14_6 GND 2.9036132812500003e-10
R_9_14_7_1 Node9_14_7 Node9_14_8 8517647.058823531
R_9_14_7_2 Node9_14_7 Node9_15_7 8517647.058823531
R_9_14_7_3 Node9_14_7 Node10_14_7 15.75424
C_9_14_7 Node9_14_7 GND 2.9036132812500003e-10
R_9_14_8_1 Node9_14_8 Node9_14_9 8517647.058823531
R_9_14_8_2 Node9_14_8 Node9_15_8 8517647.058823531
R_9_14_8_3 Node9_14_8 Node10_14_8 15.75424
C_9_14_8 Node9_14_8 GND 2.9036132812500003e-10
R_9_14_9_1 Node9_14_9 Node9_14_10 8517647.058823531
R_9_14_9_2 Node9_14_9 Node9_15_9 8517647.058823531
R_9_14_9_3 Node9_14_9 Node10_14_9 15.75424
C_9_14_9 Node9_14_9 GND 2.9036132812500003e-10
R_9_14_10_1 Node9_14_10 Node9_14_11 8517647.058823531
R_9_14_10_2 Node9_14_10 Node9_15_10 8517647.058823531
R_9_14_10_3 Node9_14_10 Node10_14_10 15.75424
C_9_14_10 Node9_14_10 GND 2.9036132812500003e-10
R_9_14_11_1 Node9_14_11 Node9_14_12 8517647.058823531
R_9_14_11_2 Node9_14_11 Node9_15_11 8517647.058823531
R_9_14_11_3 Node9_14_11 Node10_14_11 15.75424
C_9_14_11 Node9_14_11 GND 2.9036132812500003e-10
R_9_14_12_1 Node9_14_12 Node9_14_13 8517647.058823531
R_9_14_12_2 Node9_14_12 Node9_15_12 8517647.058823531
R_9_14_12_3 Node9_14_12 Node10_14_12 15.75424
C_9_14_12 Node9_14_12 GND 2.9036132812500003e-10
R_9_14_13_1 Node9_14_13 Node9_14_14 8517647.058823531
R_9_14_13_2 Node9_14_13 Node9_15_13 8517647.058823531
R_9_14_13_3 Node9_14_13 Node10_14_13 15.75424
C_9_14_13 Node9_14_13 GND 2.9036132812500003e-10
R_9_14_14_1 Node9_14_14 Node9_14_15 8517647.058823528
R_9_14_14_2 Node9_14_14 Node9_15_14 8517647.058823531
R_9_14_14_3 Node9_14_14 Node10_14_14 15.75424
C_9_14_14 Node9_14_14 GND 2.9036132812500003e-10
R_9_14_15_2 Node9_14_15 Node9_15_15 8517647.058823522
R_9_14_15_3 Node9_14_15 Node10_14_15 15.754239999999987
C_9_14_15 Node9_14_15 GND 2.903613281250003e-10
R_9_15_0_1 Node9_15_0 Node9_15_1 8517647.058823531
R_9_15_0_3 Node9_15_0 Node10_15_0 15.75424
C_9_15_0 Node9_15_0 GND 2.9036132812500003e-10
R_9_15_1_1 Node9_15_1 Node9_15_2 8517647.058823531
R_9_15_1_3 Node9_15_1 Node10_15_1 15.75424
C_9_15_1 Node9_15_1 GND 2.9036132812500003e-10
R_9_15_2_1 Node9_15_2 Node9_15_3 8517647.058823531
R_9_15_2_3 Node9_15_2 Node10_15_2 15.75424
C_9_15_2 Node9_15_2 GND 2.9036132812500003e-10
R_9_15_3_1 Node9_15_3 Node9_15_4 8517647.058823531
R_9_15_3_3 Node9_15_3 Node10_15_3 15.75424
C_9_15_3 Node9_15_3 GND 2.9036132812500003e-10
R_9_15_4_1 Node9_15_4 Node9_15_5 8517647.058823531
R_9_15_4_3 Node9_15_4 Node10_15_4 15.75424
C_9_15_4 Node9_15_4 GND 2.9036132812500003e-10
R_9_15_5_1 Node9_15_5 Node9_15_6 8517647.058823531
R_9_15_5_3 Node9_15_5 Node10_15_5 15.75424
C_9_15_5 Node9_15_5 GND 2.9036132812500003e-10
R_9_15_6_1 Node9_15_6 Node9_15_7 8517647.058823531
R_9_15_6_3 Node9_15_6 Node10_15_6 15.75424
C_9_15_6 Node9_15_6 GND 2.9036132812500003e-10
R_9_15_7_1 Node9_15_7 Node9_15_8 8517647.058823531
R_9_15_7_3 Node9_15_7 Node10_15_7 15.75424
C_9_15_7 Node9_15_7 GND 2.9036132812500003e-10
R_9_15_8_1 Node9_15_8 Node9_15_9 8517647.058823531
R_9_15_8_3 Node9_15_8 Node10_15_8 15.75424
C_9_15_8 Node9_15_8 GND 2.9036132812500003e-10
R_9_15_9_1 Node9_15_9 Node9_15_10 8517647.058823531
R_9_15_9_3 Node9_15_9 Node10_15_9 15.75424
C_9_15_9 Node9_15_9 GND 2.9036132812500003e-10
R_9_15_10_1 Node9_15_10 Node9_15_11 8517647.058823531
R_9_15_10_3 Node9_15_10 Node10_15_10 15.75424
C_9_15_10 Node9_15_10 GND 2.9036132812500003e-10
R_9_15_11_1 Node9_15_11 Node9_15_12 8517647.058823531
R_9_15_11_3 Node9_15_11 Node10_15_11 15.75424
C_9_15_11 Node9_15_11 GND 2.9036132812500003e-10
R_9_15_12_1 Node9_15_12 Node9_15_13 8517647.058823531
R_9_15_12_3 Node9_15_12 Node10_15_12 15.75424
C_9_15_12 Node9_15_12 GND 2.9036132812500003e-10
R_9_15_13_1 Node9_15_13 Node9_15_14 8517647.058823531
R_9_15_13_3 Node9_15_13 Node10_15_13 15.75424
C_9_15_13 Node9_15_13 GND 2.9036132812500003e-10
R_9_15_14_1 Node9_15_14 Node9_15_15 8517647.058823526
R_9_15_14_3 Node9_15_14 Node10_15_14 15.75424
C_9_15_14 Node9_15_14 GND 2.9036132812500003e-10
R_9_15_15_3 Node9_15_15 Node10_15_15 15.754239999999983
C_9_15_15 Node9_15_15 GND 2.9036132812500034e-10
I_10_0_0 GND Node10_0_0 PWL(0s 0A 3.33us 3.906249999999996e-08A 6.66us 3.906249999999996e-08A 9.99us 3.906249999999996e-08A 13.32us 3.906249999999996e-08A 16.65us 3.906249999999996e-08A 19.98us 3.906249999999996e-08A 23.310000000000002us 3.906249999999996e-08A 26.64us 3.906249999999996e-08A 29.97us 3.906249999999996e-08A 33.3us 3.906249999999996e-08A 36.63us 3.906249999999996e-08A 39.96us 3.906249999999996e-08A 43.29us 3.906249999999996e-08A 46.620000000000005us 3.906249999999996e-08A 49.95us 3.906249999999996e-08A 53.28us 3.906249999999996e-08A 56.61us 3.906249999999996e-08A 59.94us 3.906249999999996e-08A 63.27us 3.906249999999996e-08A 66.6us 3.906249999999996e-08A 69.93us 3.906249999999996e-08A 73.26us 3.906249999999996e-08A 76.59us 3.906249999999996e-08A 79.92us 3.906249999999996e-08A 83.25us 3.906249999999996e-08A 86.58us 3.906249999999996e-08A 89.91us 3.906249999999996e-08A 93.24000000000001us 3.906249999999996e-08A 96.57000000000001us 3.906249999999996e-08A 99.9us 3.906249999999996e-08A)
R_10_0_0_1 Node10_0_0 Node10_0_1 15400.000000000013
R_10_0_0_2 Node10_0_0 Node10_1_0 15400.000000000007
R_10_0_0_3 Node10_0_0 Node11_0_0 0.9856000000000009
C_10_0_0 Node10_0_0 GND 1.127929687499999e-09
I_10_0_1 GND Node10_0_1 PWL(0s 0A 3.33us 3.906249999999996e-08A 6.66us 3.906249999999996e-08A 9.99us 3.906249999999996e-08A 13.32us 3.906249999999996e-08A 16.65us 3.906249999999996e-08A 19.98us 3.906249999999996e-08A 23.310000000000002us 3.906249999999996e-08A 26.64us 3.906249999999996e-08A 29.97us 3.906249999999996e-08A 33.3us 3.906249999999996e-08A 36.63us 3.906249999999996e-08A 39.96us 3.906249999999996e-08A 43.29us 3.906249999999996e-08A 46.620000000000005us 3.906249999999996e-08A 49.95us 3.906249999999996e-08A 53.28us 3.906249999999996e-08A 56.61us 3.906249999999996e-08A 59.94us 3.906249999999996e-08A 63.27us 3.906249999999996e-08A 66.6us 3.906249999999996e-08A 69.93us 3.906249999999996e-08A 73.26us 3.906249999999996e-08A 76.59us 3.906249999999996e-08A 79.92us 3.906249999999996e-08A 83.25us 3.906249999999996e-08A 86.58us 3.906249999999996e-08A 89.91us 3.906249999999996e-08A 93.24000000000001us 3.906249999999996e-08A 96.57000000000001us 3.906249999999996e-08A 99.9us 3.906249999999996e-08A)
R_10_0_1_1 Node10_0_1 Node10_0_2 15400.000000000013
R_10_0_1_2 Node10_0_1 Node10_1_1 15400.000000000007
R_10_0_1_3 Node10_0_1 Node11_0_1 0.9856000000000009
C_10_0_1 Node10_0_1 GND 1.127929687499999e-09
I_10_0_2 GND Node10_0_2 PWL(0s 0A 3.33us 3.906249999999996e-08A 6.66us 3.906249999999996e-08A 9.99us 3.906249999999996e-08A 13.32us 3.906249999999996e-08A 16.65us 3.906249999999996e-08A 19.98us 3.906249999999996e-08A 23.310000000000002us 3.906249999999996e-08A 26.64us 3.906249999999996e-08A 29.97us 3.906249999999996e-08A 33.3us 3.906249999999996e-08A 36.63us 3.906249999999996e-08A 39.96us 3.906249999999996e-08A 43.29us 3.906249999999996e-08A 46.620000000000005us 3.906249999999996e-08A 49.95us 3.906249999999996e-08A 53.28us 3.906249999999996e-08A 56.61us 3.906249999999996e-08A 59.94us 3.906249999999996e-08A 63.27us 3.906249999999996e-08A 66.6us 3.906249999999996e-08A 69.93us 3.906249999999996e-08A 73.26us 3.906249999999996e-08A 76.59us 3.906249999999996e-08A 79.92us 3.906249999999996e-08A 83.25us 3.906249999999996e-08A 86.58us 3.906249999999996e-08A 89.91us 3.906249999999996e-08A 93.24000000000001us 3.906249999999996e-08A 96.57000000000001us 3.906249999999996e-08A 99.9us 3.906249999999996e-08A)
R_10_0_2_1 Node10_0_2 Node10_0_3 15400.000000000013
R_10_0_2_2 Node10_0_2 Node10_1_2 15400.000000000007
R_10_0_2_3 Node10_0_2 Node11_0_2 0.9856000000000009
C_10_0_2 Node10_0_2 GND 1.127929687499999e-09
I_10_0_3 GND Node10_0_3 PWL(0s 0A 3.33us 3.906249999999996e-08A 6.66us 3.906249999999996e-08A 9.99us 3.906249999999996e-08A 13.32us 3.906249999999996e-08A 16.65us 3.906249999999996e-08A 19.98us 3.906249999999996e-08A 23.310000000000002us 3.906249999999996e-08A 26.64us 3.906249999999996e-08A 29.97us 3.906249999999996e-08A 33.3us 3.906249999999996e-08A 36.63us 3.906249999999996e-08A 39.96us 3.906249999999996e-08A 43.29us 3.906249999999996e-08A 46.620000000000005us 3.906249999999996e-08A 49.95us 3.906249999999996e-08A 53.28us 3.906249999999996e-08A 56.61us 3.906249999999996e-08A 59.94us 3.906249999999996e-08A 63.27us 3.906249999999996e-08A 66.6us 3.906249999999996e-08A 69.93us 3.906249999999996e-08A 73.26us 3.906249999999996e-08A 76.59us 3.906249999999996e-08A 79.92us 3.906249999999996e-08A 83.25us 3.906249999999996e-08A 86.58us 3.906249999999996e-08A 89.91us 3.906249999999996e-08A 93.24000000000001us 3.906249999999996e-08A 96.57000000000001us 3.906249999999996e-08A 99.9us 3.906249999999996e-08A)
R_10_0_3_1 Node10_0_3 Node10_0_4 15400.000000000013
R_10_0_3_2 Node10_0_3 Node10_1_3 15400.000000000007
R_10_0_3_3 Node10_0_3 Node11_0_3 0.9856000000000009
C_10_0_3 Node10_0_3 GND 1.127929687499999e-09
I_10_0_4 GND Node10_0_4 PWL(0s 0A 3.33us 3.906249999999996e-08A 6.66us 3.906249999999996e-08A 9.99us 3.906249999999996e-08A 13.32us 3.906249999999996e-08A 16.65us 3.906249999999996e-08A 19.98us 3.906249999999996e-08A 23.310000000000002us 3.906249999999996e-08A 26.64us 3.906249999999996e-08A 29.97us 3.906249999999996e-08A 33.3us 3.906249999999996e-08A 36.63us 3.906249999999996e-08A 39.96us 3.906249999999996e-08A 43.29us 3.906249999999996e-08A 46.620000000000005us 3.906249999999996e-08A 49.95us 3.906249999999996e-08A 53.28us 3.906249999999996e-08A 56.61us 3.906249999999996e-08A 59.94us 3.906249999999996e-08A 63.27us 3.906249999999996e-08A 66.6us 3.906249999999996e-08A 69.93us 3.906249999999996e-08A 73.26us 3.906249999999996e-08A 76.59us 3.906249999999996e-08A 79.92us 3.906249999999996e-08A 83.25us 3.906249999999996e-08A 86.58us 3.906249999999996e-08A 89.91us 3.906249999999996e-08A 93.24000000000001us 3.906249999999996e-08A 96.57000000000001us 3.906249999999996e-08A 99.9us 3.906249999999996e-08A)
R_10_0_4_1 Node10_0_4 Node10_0_5 15400.000000000013
R_10_0_4_2 Node10_0_4 Node10_1_4 15400.000000000007
R_10_0_4_3 Node10_0_4 Node11_0_4 0.9856000000000009
C_10_0_4 Node10_0_4 GND 1.127929687499999e-09
I_10_0_5 GND Node10_0_5 PWL(0s 0A 3.33us 3.906249999999996e-08A 6.66us 3.906249999999996e-08A 9.99us 3.906249999999996e-08A 13.32us 3.906249999999996e-08A 16.65us 3.906249999999996e-08A 19.98us 3.906249999999996e-08A 23.310000000000002us 3.906249999999996e-08A 26.64us 3.906249999999996e-08A 29.97us 3.906249999999996e-08A 33.3us 3.906249999999996e-08A 36.63us 3.906249999999996e-08A 39.96us 3.906249999999996e-08A 43.29us 3.906249999999996e-08A 46.620000000000005us 3.906249999999996e-08A 49.95us 3.906249999999996e-08A 53.28us 3.906249999999996e-08A 56.61us 3.906249999999996e-08A 59.94us 3.906249999999996e-08A 63.27us 3.906249999999996e-08A 66.6us 3.906249999999996e-08A 69.93us 3.906249999999996e-08A 73.26us 3.906249999999996e-08A 76.59us 3.906249999999996e-08A 79.92us 3.906249999999996e-08A 83.25us 3.906249999999996e-08A 86.58us 3.906249999999996e-08A 89.91us 3.906249999999996e-08A 93.24000000000001us 3.906249999999996e-08A 96.57000000000001us 3.906249999999996e-08A 99.9us 3.906249999999996e-08A)
R_10_0_5_1 Node10_0_5 Node10_0_6 15400.000000000013
R_10_0_5_2 Node10_0_5 Node10_1_5 15400.000000000007
R_10_0_5_3 Node10_0_5 Node11_0_5 0.9856000000000009
C_10_0_5 Node10_0_5 GND 1.127929687499999e-09
I_10_0_6 GND Node10_0_6 PWL(0s 0A 3.33us 3.906249999999996e-08A 6.66us 3.906249999999996e-08A 9.99us 3.906249999999996e-08A 13.32us 3.906249999999996e-08A 16.65us 3.906249999999996e-08A 19.98us 3.906249999999996e-08A 23.310000000000002us 3.906249999999996e-08A 26.64us 3.906249999999996e-08A 29.97us 3.906249999999996e-08A 33.3us 3.906249999999996e-08A 36.63us 3.906249999999996e-08A 39.96us 3.906249999999996e-08A 43.29us 3.906249999999996e-08A 46.620000000000005us 3.906249999999996e-08A 49.95us 3.906249999999996e-08A 53.28us 3.906249999999996e-08A 56.61us 3.906249999999996e-08A 59.94us 3.906249999999996e-08A 63.27us 3.906249999999996e-08A 66.6us 3.906249999999996e-08A 69.93us 3.906249999999996e-08A 73.26us 3.906249999999996e-08A 76.59us 3.906249999999996e-08A 79.92us 3.906249999999996e-08A 83.25us 3.906249999999996e-08A 86.58us 3.906249999999996e-08A 89.91us 3.906249999999996e-08A 93.24000000000001us 3.906249999999996e-08A 96.57000000000001us 3.906249999999996e-08A 99.9us 3.906249999999996e-08A)
R_10_0_6_1 Node10_0_6 Node10_0_7 15400.000000000013
R_10_0_6_2 Node10_0_6 Node10_1_6 15400.000000000007
R_10_0_6_3 Node10_0_6 Node11_0_6 0.9856000000000009
C_10_0_6 Node10_0_6 GND 1.127929687499999e-09
I_10_0_7 GND Node10_0_7 PWL(0s 0A 3.33us 3.906249999999996e-08A 6.66us 3.906249999999996e-08A 9.99us 3.906249999999996e-08A 13.32us 3.906249999999996e-08A 16.65us 3.906249999999996e-08A 19.98us 3.906249999999996e-08A 23.310000000000002us 3.906249999999996e-08A 26.64us 3.906249999999996e-08A 29.97us 3.906249999999996e-08A 33.3us 3.906249999999996e-08A 36.63us 3.906249999999996e-08A 39.96us 3.906249999999996e-08A 43.29us 3.906249999999996e-08A 46.620000000000005us 3.906249999999996e-08A 49.95us 3.906249999999996e-08A 53.28us 3.906249999999996e-08A 56.61us 3.906249999999996e-08A 59.94us 3.906249999999996e-08A 63.27us 3.906249999999996e-08A 66.6us 3.906249999999996e-08A 69.93us 3.906249999999996e-08A 73.26us 3.906249999999996e-08A 76.59us 3.906249999999996e-08A 79.92us 3.906249999999996e-08A 83.25us 3.906249999999996e-08A 86.58us 3.906249999999996e-08A 89.91us 3.906249999999996e-08A 93.24000000000001us 3.906249999999996e-08A 96.57000000000001us 3.906249999999996e-08A 99.9us 3.906249999999996e-08A)
R_10_0_7_1 Node10_0_7 Node10_0_8 15400.000000000013
R_10_0_7_2 Node10_0_7 Node10_1_7 15400.000000000007
R_10_0_7_3 Node10_0_7 Node11_0_7 0.9856000000000009
C_10_0_7 Node10_0_7 GND 1.127929687499999e-09
I_10_0_8 GND Node10_0_8 PWL(0s 0A 3.33us 3.906249999999996e-08A 6.66us 3.906249999999996e-08A 9.99us 3.906249999999996e-08A 13.32us 3.906249999999996e-08A 16.65us 3.906249999999996e-08A 19.98us 3.906249999999996e-08A 23.310000000000002us 3.906249999999996e-08A 26.64us 3.906249999999996e-08A 29.97us 3.906249999999996e-08A 33.3us 3.906249999999996e-08A 36.63us 3.906249999999996e-08A 39.96us 3.906249999999996e-08A 43.29us 3.906249999999996e-08A 46.620000000000005us 3.906249999999996e-08A 49.95us 3.906249999999996e-08A 53.28us 3.906249999999996e-08A 56.61us 3.906249999999996e-08A 59.94us 3.906249999999996e-08A 63.27us 3.906249999999996e-08A 66.6us 3.906249999999996e-08A 69.93us 3.906249999999996e-08A 73.26us 3.906249999999996e-08A 76.59us 3.906249999999996e-08A 79.92us 3.906249999999996e-08A 83.25us 3.906249999999996e-08A 86.58us 3.906249999999996e-08A 89.91us 3.906249999999996e-08A 93.24000000000001us 3.906249999999996e-08A 96.57000000000001us 3.906249999999996e-08A 99.9us 3.906249999999996e-08A)
R_10_0_8_1 Node10_0_8 Node10_0_9 15400.000000000013
R_10_0_8_2 Node10_0_8 Node10_1_8 15400.000000000007
R_10_0_8_3 Node10_0_8 Node11_0_8 0.9856000000000009
C_10_0_8 Node10_0_8 GND 1.127929687499999e-09
I_10_0_9 GND Node10_0_9 PWL(0s 0A 3.33us 3.906249999999996e-08A 6.66us 3.906249999999996e-08A 9.99us 3.906249999999996e-08A 13.32us 3.906249999999996e-08A 16.65us 3.906249999999996e-08A 19.98us 3.906249999999996e-08A 23.310000000000002us 3.906249999999996e-08A 26.64us 3.906249999999996e-08A 29.97us 3.906249999999996e-08A 33.3us 3.906249999999996e-08A 36.63us 3.906249999999996e-08A 39.96us 3.906249999999996e-08A 43.29us 3.906249999999996e-08A 46.620000000000005us 3.906249999999996e-08A 49.95us 3.906249999999996e-08A 53.28us 3.906249999999996e-08A 56.61us 3.906249999999996e-08A 59.94us 3.906249999999996e-08A 63.27us 3.906249999999996e-08A 66.6us 3.906249999999996e-08A 69.93us 3.906249999999996e-08A 73.26us 3.906249999999996e-08A 76.59us 3.906249999999996e-08A 79.92us 3.906249999999996e-08A 83.25us 3.906249999999996e-08A 86.58us 3.906249999999996e-08A 89.91us 3.906249999999996e-08A 93.24000000000001us 3.906249999999996e-08A 96.57000000000001us 3.906249999999996e-08A 99.9us 3.906249999999996e-08A)
R_10_0_9_1 Node10_0_9 Node10_0_10 15400.000000000013
R_10_0_9_2 Node10_0_9 Node10_1_9 15400.000000000007
R_10_0_9_3 Node10_0_9 Node11_0_9 0.9856000000000009
C_10_0_9 Node10_0_9 GND 1.127929687499999e-09
I_10_0_10 GND Node10_0_10 PWL(0s 0A 3.33us 3.906249999999996e-08A 6.66us 3.906249999999996e-08A 9.99us 3.906249999999996e-08A 13.32us 3.906249999999996e-08A 16.65us 3.906249999999996e-08A 19.98us 3.906249999999996e-08A 23.310000000000002us 3.906249999999996e-08A 26.64us 3.906249999999996e-08A 29.97us 3.906249999999996e-08A 33.3us 3.906249999999996e-08A 36.63us 3.906249999999996e-08A 39.96us 3.906249999999996e-08A 43.29us 3.906249999999996e-08A 46.620000000000005us 3.906249999999996e-08A 49.95us 3.906249999999996e-08A 53.28us 3.906249999999996e-08A 56.61us 3.906249999999996e-08A 59.94us 3.906249999999996e-08A 63.27us 3.906249999999996e-08A 66.6us 3.906249999999996e-08A 69.93us 3.906249999999996e-08A 73.26us 3.906249999999996e-08A 76.59us 3.906249999999996e-08A 79.92us 3.906249999999996e-08A 83.25us 3.906249999999996e-08A 86.58us 3.906249999999996e-08A 89.91us 3.906249999999996e-08A 93.24000000000001us 3.906249999999996e-08A 96.57000000000001us 3.906249999999996e-08A 99.9us 3.906249999999996e-08A)
R_10_0_10_1 Node10_0_10 Node10_0_11 15400.000000000013
R_10_0_10_2 Node10_0_10 Node10_1_10 15400.000000000007
R_10_0_10_3 Node10_0_10 Node11_0_10 0.9856000000000009
C_10_0_10 Node10_0_10 GND 1.127929687499999e-09
I_10_0_11 GND Node10_0_11 PWL(0s 0A 3.33us 3.906249999999996e-08A 6.66us 3.906249999999996e-08A 9.99us 3.906249999999996e-08A 13.32us 3.906249999999996e-08A 16.65us 3.906249999999996e-08A 19.98us 3.906249999999996e-08A 23.310000000000002us 3.906249999999996e-08A 26.64us 3.906249999999996e-08A 29.97us 3.906249999999996e-08A 33.3us 3.906249999999996e-08A 36.63us 3.906249999999996e-08A 39.96us 3.906249999999996e-08A 43.29us 3.906249999999996e-08A 46.620000000000005us 3.906249999999996e-08A 49.95us 3.906249999999996e-08A 53.28us 3.906249999999996e-08A 56.61us 3.906249999999996e-08A 59.94us 3.906249999999996e-08A 63.27us 3.906249999999996e-08A 66.6us 3.906249999999996e-08A 69.93us 3.906249999999996e-08A 73.26us 3.906249999999996e-08A 76.59us 3.906249999999996e-08A 79.92us 3.906249999999996e-08A 83.25us 3.906249999999996e-08A 86.58us 3.906249999999996e-08A 89.91us 3.906249999999996e-08A 93.24000000000001us 3.906249999999996e-08A 96.57000000000001us 3.906249999999996e-08A 99.9us 3.906249999999996e-08A)
R_10_0_11_1 Node10_0_11 Node10_0_12 15400.000000000013
R_10_0_11_2 Node10_0_11 Node10_1_11 15400.000000000007
R_10_0_11_3 Node10_0_11 Node11_0_11 0.9856000000000009
C_10_0_11 Node10_0_11 GND 1.127929687499999e-09
I_10_0_12 GND Node10_0_12 PWL(0s 0A 3.33us 3.906249999999996e-08A 6.66us 3.906249999999996e-08A 9.99us 3.906249999999996e-08A 13.32us 3.906249999999996e-08A 16.65us 3.906249999999996e-08A 19.98us 3.906249999999996e-08A 23.310000000000002us 3.906249999999996e-08A 26.64us 3.906249999999996e-08A 29.97us 3.906249999999996e-08A 33.3us 3.906249999999996e-08A 36.63us 3.906249999999996e-08A 39.96us 3.906249999999996e-08A 43.29us 3.906249999999996e-08A 46.620000000000005us 3.906249999999996e-08A 49.95us 3.906249999999996e-08A 53.28us 3.906249999999996e-08A 56.61us 3.906249999999996e-08A 59.94us 3.906249999999996e-08A 63.27us 3.906249999999996e-08A 66.6us 3.906249999999996e-08A 69.93us 3.906249999999996e-08A 73.26us 3.906249999999996e-08A 76.59us 3.906249999999996e-08A 79.92us 3.906249999999996e-08A 83.25us 3.906249999999996e-08A 86.58us 3.906249999999996e-08A 89.91us 3.906249999999996e-08A 93.24000000000001us 3.906249999999996e-08A 96.57000000000001us 3.906249999999996e-08A 99.9us 3.906249999999996e-08A)
R_10_0_12_1 Node10_0_12 Node10_0_13 15400.000000000013
R_10_0_12_2 Node10_0_12 Node10_1_12 15400.000000000007
R_10_0_12_3 Node10_0_12 Node11_0_12 0.9856000000000009
C_10_0_12 Node10_0_12 GND 1.127929687499999e-09
I_10_0_13 GND Node10_0_13 PWL(0s 0A 3.33us 3.906249999999996e-08A 6.66us 3.906249999999996e-08A 9.99us 3.906249999999996e-08A 13.32us 3.906249999999996e-08A 16.65us 3.906249999999996e-08A 19.98us 3.906249999999996e-08A 23.310000000000002us 3.906249999999996e-08A 26.64us 3.906249999999996e-08A 29.97us 3.906249999999996e-08A 33.3us 3.906249999999996e-08A 36.63us 3.906249999999996e-08A 39.96us 3.906249999999996e-08A 43.29us 3.906249999999996e-08A 46.620000000000005us 3.906249999999996e-08A 49.95us 3.906249999999996e-08A 53.28us 3.906249999999996e-08A 56.61us 3.906249999999996e-08A 59.94us 3.906249999999996e-08A 63.27us 3.906249999999996e-08A 66.6us 3.906249999999996e-08A 69.93us 3.906249999999996e-08A 73.26us 3.906249999999996e-08A 76.59us 3.906249999999996e-08A 79.92us 3.906249999999996e-08A 83.25us 3.906249999999996e-08A 86.58us 3.906249999999996e-08A 89.91us 3.906249999999996e-08A 93.24000000000001us 3.906249999999996e-08A 96.57000000000001us 3.906249999999996e-08A 99.9us 3.906249999999996e-08A)
R_10_0_13_1 Node10_0_13 Node10_0_14 15400.000000000013
R_10_0_13_2 Node10_0_13 Node10_1_13 15400.000000000007
R_10_0_13_3 Node10_0_13 Node11_0_13 0.9856000000000009
C_10_0_13 Node10_0_13 GND 1.127929687499999e-09
I_10_0_14 GND Node10_0_14 PWL(0s 0A 3.33us 3.906249999999996e-08A 6.66us 3.906249999999996e-08A 9.99us 3.906249999999996e-08A 13.32us 3.906249999999996e-08A 16.65us 3.906249999999996e-08A 19.98us 3.906249999999996e-08A 23.310000000000002us 3.906249999999996e-08A 26.64us 3.906249999999996e-08A 29.97us 3.906249999999996e-08A 33.3us 3.906249999999996e-08A 36.63us 3.906249999999996e-08A 39.96us 3.906249999999996e-08A 43.29us 3.906249999999996e-08A 46.620000000000005us 3.906249999999996e-08A 49.95us 3.906249999999996e-08A 53.28us 3.906249999999996e-08A 56.61us 3.906249999999996e-08A 59.94us 3.906249999999996e-08A 63.27us 3.906249999999996e-08A 66.6us 3.906249999999996e-08A 69.93us 3.906249999999996e-08A 73.26us 3.906249999999996e-08A 76.59us 3.906249999999996e-08A 79.92us 3.906249999999996e-08A 83.25us 3.906249999999996e-08A 86.58us 3.906249999999996e-08A 89.91us 3.906249999999996e-08A 93.24000000000001us 3.906249999999996e-08A 96.57000000000001us 3.906249999999996e-08A 99.9us 3.906249999999996e-08A)
R_10_0_14_1 Node10_0_14 Node10_0_15 15400.000000000007
R_10_0_14_2 Node10_0_14 Node10_1_14 15400.000000000007
R_10_0_14_3 Node10_0_14 Node11_0_14 0.9856000000000009
C_10_0_14 Node10_0_14 GND 1.127929687499999e-09
I_10_0_15 GND Node10_0_15 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 3.906249999999999e-08A 39.96us 3.906249999999999e-08A 43.29us 3.906249999999999e-08A 46.620000000000005us 3.906249999999999e-08A 49.95us 3.906249999999999e-08A 53.28us 3.906249999999999e-08A 56.61us 3.906249999999999e-08A 59.94us 3.906249999999999e-08A 63.27us 3.906249999999999e-08A 66.6us 3.906249999999999e-08A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_10_0_15_2 Node10_0_15 Node10_1_15 15399.999999999993
R_10_0_15_3 Node10_0_15 Node11_0_15 0.9856000000000001
C_10_0_15 Node10_0_15 GND 1.1279296875e-09
I_10_1_0 GND Node10_1_0 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 3.906249999999999e-08A 39.96us 3.906249999999999e-08A 43.29us 3.906249999999999e-08A 46.620000000000005us 3.906249999999999e-08A 49.95us 3.906249999999999e-08A 53.28us 3.906249999999999e-08A 56.61us 3.906249999999999e-08A 59.94us 3.906249999999999e-08A 63.27us 3.906249999999999e-08A 66.6us 3.906249999999999e-08A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_10_1_0_1 Node10_1_0 Node10_1_1 15400.0
R_10_1_0_2 Node10_1_0 Node10_2_0 15400.0
R_10_1_0_3 Node10_1_0 Node11_1_0 0.9856000000000001
C_10_1_0 Node10_1_0 GND 1.1279296875e-09
I_10_1_1 GND Node10_1_1 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 3.906249999999999e-08A 39.96us 3.906249999999999e-08A 43.29us 3.906249999999999e-08A 46.620000000000005us 3.906249999999999e-08A 49.95us 3.906249999999999e-08A 53.28us 3.906249999999999e-08A 56.61us 3.906249999999999e-08A 59.94us 3.906249999999999e-08A 63.27us 3.906249999999999e-08A 66.6us 3.906249999999999e-08A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_10_1_1_1 Node10_1_1 Node10_1_2 15400.0
R_10_1_1_2 Node10_1_1 Node10_2_1 15400.0
R_10_1_1_3 Node10_1_1 Node11_1_1 0.9856000000000001
C_10_1_1 Node10_1_1 GND 1.1279296875e-09
I_10_1_2 GND Node10_1_2 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 3.906249999999999e-08A 39.96us 3.906249999999999e-08A 43.29us 3.906249999999999e-08A 46.620000000000005us 3.906249999999999e-08A 49.95us 3.906249999999999e-08A 53.28us 3.906249999999999e-08A 56.61us 3.906249999999999e-08A 59.94us 3.906249999999999e-08A 63.27us 3.906249999999999e-08A 66.6us 3.906249999999999e-08A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_10_1_2_1 Node10_1_2 Node10_1_3 15400.0
R_10_1_2_2 Node10_1_2 Node10_2_2 15400.0
R_10_1_2_3 Node10_1_2 Node11_1_2 0.9856000000000001
C_10_1_2 Node10_1_2 GND 1.1279296875e-09
I_10_1_3 GND Node10_1_3 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 3.906249999999999e-08A 39.96us 3.906249999999999e-08A 43.29us 3.906249999999999e-08A 46.620000000000005us 3.906249999999999e-08A 49.95us 3.906249999999999e-08A 53.28us 3.906249999999999e-08A 56.61us 3.906249999999999e-08A 59.94us 3.906249999999999e-08A 63.27us 3.906249999999999e-08A 66.6us 3.906249999999999e-08A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_10_1_3_1 Node10_1_3 Node10_1_4 15400.0
R_10_1_3_2 Node10_1_3 Node10_2_3 15400.0
R_10_1_3_3 Node10_1_3 Node11_1_3 0.9856000000000001
C_10_1_3 Node10_1_3 GND 1.1279296875e-09
I_10_1_4 GND Node10_1_4 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 3.906249999999999e-08A 39.96us 3.906249999999999e-08A 43.29us 3.906249999999999e-08A 46.620000000000005us 3.906249999999999e-08A 49.95us 3.906249999999999e-08A 53.28us 3.906249999999999e-08A 56.61us 3.906249999999999e-08A 59.94us 3.906249999999999e-08A 63.27us 3.906249999999999e-08A 66.6us 3.906249999999999e-08A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_10_1_4_1 Node10_1_4 Node10_1_5 15400.0
R_10_1_4_2 Node10_1_4 Node10_2_4 15400.0
R_10_1_4_3 Node10_1_4 Node11_1_4 0.9856000000000001
C_10_1_4 Node10_1_4 GND 1.1279296875e-09
I_10_1_5 GND Node10_1_5 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 3.906249999999999e-08A 39.96us 3.906249999999999e-08A 43.29us 3.906249999999999e-08A 46.620000000000005us 3.906249999999999e-08A 49.95us 3.906249999999999e-08A 53.28us 3.906249999999999e-08A 56.61us 3.906249999999999e-08A 59.94us 3.906249999999999e-08A 63.27us 3.906249999999999e-08A 66.6us 3.906249999999999e-08A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_10_1_5_1 Node10_1_5 Node10_1_6 15400.0
R_10_1_5_2 Node10_1_5 Node10_2_5 15400.0
R_10_1_5_3 Node10_1_5 Node11_1_5 0.9856000000000001
C_10_1_5 Node10_1_5 GND 1.1279296875e-09
I_10_1_6 GND Node10_1_6 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 3.906249999999999e-08A 39.96us 3.906249999999999e-08A 43.29us 3.906249999999999e-08A 46.620000000000005us 3.906249999999999e-08A 49.95us 3.906249999999999e-08A 53.28us 3.906249999999999e-08A 56.61us 3.906249999999999e-08A 59.94us 3.906249999999999e-08A 63.27us 3.906249999999999e-08A 66.6us 3.906249999999999e-08A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_10_1_6_1 Node10_1_6 Node10_1_7 15400.0
R_10_1_6_2 Node10_1_6 Node10_2_6 15400.0
R_10_1_6_3 Node10_1_6 Node11_1_6 0.9856000000000001
C_10_1_6 Node10_1_6 GND 1.1279296875e-09
I_10_1_7 GND Node10_1_7 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 3.906249999999999e-08A 39.96us 3.906249999999999e-08A 43.29us 3.906249999999999e-08A 46.620000000000005us 3.906249999999999e-08A 49.95us 3.906249999999999e-08A 53.28us 3.906249999999999e-08A 56.61us 3.906249999999999e-08A 59.94us 3.906249999999999e-08A 63.27us 3.906249999999999e-08A 66.6us 3.906249999999999e-08A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_10_1_7_1 Node10_1_7 Node10_1_8 15400.0
R_10_1_7_2 Node10_1_7 Node10_2_7 15400.0
R_10_1_7_3 Node10_1_7 Node11_1_7 0.9856000000000001
C_10_1_7 Node10_1_7 GND 1.1279296875e-09
I_10_1_8 GND Node10_1_8 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 3.906249999999999e-08A 39.96us 3.906249999999999e-08A 43.29us 3.906249999999999e-08A 46.620000000000005us 3.906249999999999e-08A 49.95us 3.906249999999999e-08A 53.28us 3.906249999999999e-08A 56.61us 3.906249999999999e-08A 59.94us 3.906249999999999e-08A 63.27us 3.906249999999999e-08A 66.6us 3.906249999999999e-08A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_10_1_8_1 Node10_1_8 Node10_1_9 15400.0
R_10_1_8_2 Node10_1_8 Node10_2_8 15400.0
R_10_1_8_3 Node10_1_8 Node11_1_8 0.9856000000000001
C_10_1_8 Node10_1_8 GND 1.1279296875e-09
I_10_1_9 GND Node10_1_9 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 3.906249999999999e-08A 39.96us 3.906249999999999e-08A 43.29us 3.906249999999999e-08A 46.620000000000005us 3.906249999999999e-08A 49.95us 3.906249999999999e-08A 53.28us 3.906249999999999e-08A 56.61us 3.906249999999999e-08A 59.94us 3.906249999999999e-08A 63.27us 3.906249999999999e-08A 66.6us 3.906249999999999e-08A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_10_1_9_1 Node10_1_9 Node10_1_10 15400.0
R_10_1_9_2 Node10_1_9 Node10_2_9 15400.0
R_10_1_9_3 Node10_1_9 Node11_1_9 0.9856000000000001
C_10_1_9 Node10_1_9 GND 1.1279296875e-09
I_10_1_10 GND Node10_1_10 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 3.906249999999999e-08A 39.96us 3.906249999999999e-08A 43.29us 3.906249999999999e-08A 46.620000000000005us 3.906249999999999e-08A 49.95us 3.906249999999999e-08A 53.28us 3.906249999999999e-08A 56.61us 3.906249999999999e-08A 59.94us 3.906249999999999e-08A 63.27us 3.906249999999999e-08A 66.6us 3.906249999999999e-08A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_10_1_10_1 Node10_1_10 Node10_1_11 15400.0
R_10_1_10_2 Node10_1_10 Node10_2_10 15400.0
R_10_1_10_3 Node10_1_10 Node11_1_10 0.9856000000000001
C_10_1_10 Node10_1_10 GND 1.1279296875e-09
I_10_1_11 GND Node10_1_11 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 3.906249999999999e-08A 39.96us 3.906249999999999e-08A 43.29us 3.906249999999999e-08A 46.620000000000005us 3.906249999999999e-08A 49.95us 3.906249999999999e-08A 53.28us 3.906249999999999e-08A 56.61us 3.906249999999999e-08A 59.94us 3.906249999999999e-08A 63.27us 3.906249999999999e-08A 66.6us 3.906249999999999e-08A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_10_1_11_1 Node10_1_11 Node10_1_12 15400.0
R_10_1_11_2 Node10_1_11 Node10_2_11 15400.0
R_10_1_11_3 Node10_1_11 Node11_1_11 0.9856000000000001
C_10_1_11 Node10_1_11 GND 1.1279296875e-09
I_10_1_12 GND Node10_1_12 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 3.906249999999999e-08A 39.96us 3.906249999999999e-08A 43.29us 3.906249999999999e-08A 46.620000000000005us 3.906249999999999e-08A 49.95us 3.906249999999999e-08A 53.28us 3.906249999999999e-08A 56.61us 3.906249999999999e-08A 59.94us 3.906249999999999e-08A 63.27us 3.906249999999999e-08A 66.6us 3.906249999999999e-08A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_10_1_12_1 Node10_1_12 Node10_1_13 15400.0
R_10_1_12_2 Node10_1_12 Node10_2_12 15400.0
R_10_1_12_3 Node10_1_12 Node11_1_12 0.9856000000000001
C_10_1_12 Node10_1_12 GND 1.1279296875e-09
I_10_1_13 GND Node10_1_13 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 3.906249999999999e-08A 39.96us 3.906249999999999e-08A 43.29us 3.906249999999999e-08A 46.620000000000005us 3.906249999999999e-08A 49.95us 3.906249999999999e-08A 53.28us 3.906249999999999e-08A 56.61us 3.906249999999999e-08A 59.94us 3.906249999999999e-08A 63.27us 3.906249999999999e-08A 66.6us 3.906249999999999e-08A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_10_1_13_1 Node10_1_13 Node10_1_14 15400.0
R_10_1_13_2 Node10_1_13 Node10_2_13 15400.0
R_10_1_13_3 Node10_1_13 Node11_1_13 0.9856000000000001
C_10_1_13 Node10_1_13 GND 1.1279296875e-09
I_10_1_14 GND Node10_1_14 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 3.906249999999999e-08A 39.96us 3.906249999999999e-08A 43.29us 3.906249999999999e-08A 46.620000000000005us 3.906249999999999e-08A 49.95us 3.906249999999999e-08A 53.28us 3.906249999999999e-08A 56.61us 3.906249999999999e-08A 59.94us 3.906249999999999e-08A 63.27us 3.906249999999999e-08A 66.6us 3.906249999999999e-08A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_10_1_14_1 Node10_1_14 Node10_1_15 15399.999999999993
R_10_1_14_2 Node10_1_14 Node10_2_14 15400.0
R_10_1_14_3 Node10_1_14 Node11_1_14 0.9856000000000001
C_10_1_14 Node10_1_14 GND 1.1279296875e-09
I_10_1_15 GND Node10_1_15 PWL(0s 0A 3.33us 3.906250000000002e-08A 6.66us 3.906250000000002e-08A 9.99us 3.906250000000002e-08A 13.32us 3.906250000000002e-08A 16.65us 3.906250000000002e-08A 19.98us 3.906250000000002e-08A 23.310000000000002us 3.906250000000002e-08A 26.64us 3.906250000000002e-08A 29.97us 3.906250000000002e-08A 33.3us 3.906250000000002e-08A 36.63us 3.906250000000002e-08A 39.96us 3.906250000000002e-08A 43.29us 3.906250000000002e-08A 46.620000000000005us 3.906250000000002e-08A 49.95us 3.906250000000002e-08A 53.28us 3.906250000000002e-08A 56.61us 3.906250000000002e-08A 59.94us 3.906250000000002e-08A 63.27us 3.906250000000002e-08A 66.6us 3.906250000000002e-08A 69.93us 3.906250000000002e-08A 73.26us 3.906250000000002e-08A 76.59us 3.906250000000002e-08A 79.92us 3.906250000000002e-08A 83.25us 3.906250000000002e-08A 86.58us 3.906250000000002e-08A 89.91us 3.906250000000002e-08A 93.24000000000001us 3.906250000000002e-08A 96.57000000000001us 3.906250000000002e-08A 99.9us 3.906250000000002e-08A)
R_10_1_15_2 Node10_1_15 Node10_2_15 15399.999999999987
R_10_1_15_3 Node10_1_15 Node11_1_15 0.9855999999999993
C_10_1_15 Node10_1_15 GND 1.127929687500001e-09
I_10_2_0 GND Node10_2_0 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 3.906249999999999e-08A 39.96us 3.906249999999999e-08A 43.29us 3.906249999999999e-08A 46.620000000000005us 3.906249999999999e-08A 49.95us 3.906249999999999e-08A 53.28us 3.906249999999999e-08A 56.61us 3.906249999999999e-08A 59.94us 3.906249999999999e-08A 63.27us 3.906249999999999e-08A 66.6us 3.906249999999999e-08A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_10_2_0_1 Node10_2_0 Node10_2_1 15400.0
R_10_2_0_2 Node10_2_0 Node10_3_0 15400.0
R_10_2_0_3 Node10_2_0 Node11_2_0 0.9856000000000001
C_10_2_0 Node10_2_0 GND 1.1279296875e-09
I_10_2_1 GND Node10_2_1 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 3.906249999999999e-08A 39.96us 3.906249999999999e-08A 43.29us 3.906249999999999e-08A 46.620000000000005us 3.906249999999999e-08A 49.95us 3.906249999999999e-08A 53.28us 3.906249999999999e-08A 56.61us 3.906249999999999e-08A 59.94us 3.906249999999999e-08A 63.27us 3.906249999999999e-08A 66.6us 3.906249999999999e-08A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_10_2_1_1 Node10_2_1 Node10_2_2 15400.0
R_10_2_1_2 Node10_2_1 Node10_3_1 15400.0
R_10_2_1_3 Node10_2_1 Node11_2_1 0.9856000000000001
C_10_2_1 Node10_2_1 GND 1.1279296875e-09
I_10_2_2 GND Node10_2_2 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 3.906249999999999e-08A 39.96us 3.906249999999999e-08A 43.29us 3.906249999999999e-08A 46.620000000000005us 3.906249999999999e-08A 49.95us 3.906249999999999e-08A 53.28us 3.906249999999999e-08A 56.61us 3.906249999999999e-08A 59.94us 3.906249999999999e-08A 63.27us 3.906249999999999e-08A 66.6us 3.906249999999999e-08A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_10_2_2_1 Node10_2_2 Node10_2_3 15400.0
R_10_2_2_2 Node10_2_2 Node10_3_2 15400.0
R_10_2_2_3 Node10_2_2 Node11_2_2 0.9856000000000001
C_10_2_2 Node10_2_2 GND 1.1279296875e-09
I_10_2_3 GND Node10_2_3 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 3.906249999999999e-08A 39.96us 3.906249999999999e-08A 43.29us 3.906249999999999e-08A 46.620000000000005us 3.906249999999999e-08A 49.95us 3.906249999999999e-08A 53.28us 3.906249999999999e-08A 56.61us 3.906249999999999e-08A 59.94us 3.906249999999999e-08A 63.27us 3.906249999999999e-08A 66.6us 3.906249999999999e-08A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_10_2_3_1 Node10_2_3 Node10_2_4 15400.0
R_10_2_3_2 Node10_2_3 Node10_3_3 15400.0
R_10_2_3_3 Node10_2_3 Node11_2_3 0.9856000000000001
C_10_2_3 Node10_2_3 GND 1.1279296875e-09
I_10_2_4 GND Node10_2_4 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 3.906249999999999e-08A 39.96us 3.906249999999999e-08A 43.29us 3.906249999999999e-08A 46.620000000000005us 3.906249999999999e-08A 49.95us 3.906249999999999e-08A 53.28us 3.906249999999999e-08A 56.61us 3.906249999999999e-08A 59.94us 3.906249999999999e-08A 63.27us 3.906249999999999e-08A 66.6us 3.906249999999999e-08A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_10_2_4_1 Node10_2_4 Node10_2_5 15400.0
R_10_2_4_2 Node10_2_4 Node10_3_4 15400.0
R_10_2_4_3 Node10_2_4 Node11_2_4 0.9856000000000001
C_10_2_4 Node10_2_4 GND 1.1279296875e-09
I_10_2_5 GND Node10_2_5 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 3.906249999999999e-08A 39.96us 3.906249999999999e-08A 43.29us 3.906249999999999e-08A 46.620000000000005us 3.906249999999999e-08A 49.95us 3.906249999999999e-08A 53.28us 3.906249999999999e-08A 56.61us 3.906249999999999e-08A 59.94us 3.906249999999999e-08A 63.27us 3.906249999999999e-08A 66.6us 3.906249999999999e-08A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_10_2_5_1 Node10_2_5 Node10_2_6 15400.0
R_10_2_5_2 Node10_2_5 Node10_3_5 15400.0
R_10_2_5_3 Node10_2_5 Node11_2_5 0.9856000000000001
C_10_2_5 Node10_2_5 GND 1.1279296875e-09
I_10_2_6 GND Node10_2_6 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 3.906249999999999e-08A 39.96us 3.906249999999999e-08A 43.29us 3.906249999999999e-08A 46.620000000000005us 3.906249999999999e-08A 49.95us 3.906249999999999e-08A 53.28us 3.906249999999999e-08A 56.61us 3.906249999999999e-08A 59.94us 3.906249999999999e-08A 63.27us 3.906249999999999e-08A 66.6us 3.906249999999999e-08A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_10_2_6_1 Node10_2_6 Node10_2_7 15400.0
R_10_2_6_2 Node10_2_6 Node10_3_6 15400.0
R_10_2_6_3 Node10_2_6 Node11_2_6 0.9856000000000001
C_10_2_6 Node10_2_6 GND 1.1279296875e-09
I_10_2_7 GND Node10_2_7 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 3.906249999999999e-08A 39.96us 3.906249999999999e-08A 43.29us 3.906249999999999e-08A 46.620000000000005us 3.906249999999999e-08A 49.95us 3.906249999999999e-08A 53.28us 3.906249999999999e-08A 56.61us 3.906249999999999e-08A 59.94us 3.906249999999999e-08A 63.27us 3.906249999999999e-08A 66.6us 3.906249999999999e-08A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_10_2_7_1 Node10_2_7 Node10_2_8 15400.0
R_10_2_7_2 Node10_2_7 Node10_3_7 15400.0
R_10_2_7_3 Node10_2_7 Node11_2_7 0.9856000000000001
C_10_2_7 Node10_2_7 GND 1.1279296875e-09
I_10_2_8 GND Node10_2_8 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 3.906249999999999e-08A 39.96us 3.906249999999999e-08A 43.29us 3.906249999999999e-08A 46.620000000000005us 3.906249999999999e-08A 49.95us 3.906249999999999e-08A 53.28us 3.906249999999999e-08A 56.61us 3.906249999999999e-08A 59.94us 3.906249999999999e-08A 63.27us 3.906249999999999e-08A 66.6us 3.906249999999999e-08A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_10_2_8_1 Node10_2_8 Node10_2_9 15400.0
R_10_2_8_2 Node10_2_8 Node10_3_8 15400.0
R_10_2_8_3 Node10_2_8 Node11_2_8 0.9856000000000001
C_10_2_8 Node10_2_8 GND 1.1279296875e-09
I_10_2_9 GND Node10_2_9 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 3.906249999999999e-08A 39.96us 3.906249999999999e-08A 43.29us 3.906249999999999e-08A 46.620000000000005us 3.906249999999999e-08A 49.95us 3.906249999999999e-08A 53.28us 3.906249999999999e-08A 56.61us 3.906249999999999e-08A 59.94us 3.906249999999999e-08A 63.27us 3.906249999999999e-08A 66.6us 3.906249999999999e-08A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_10_2_9_1 Node10_2_9 Node10_2_10 15400.0
R_10_2_9_2 Node10_2_9 Node10_3_9 15400.0
R_10_2_9_3 Node10_2_9 Node11_2_9 0.9856000000000001
C_10_2_9 Node10_2_9 GND 1.1279296875e-09
I_10_2_10 GND Node10_2_10 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 3.906249999999999e-08A 39.96us 3.906249999999999e-08A 43.29us 3.906249999999999e-08A 46.620000000000005us 3.906249999999999e-08A 49.95us 3.906249999999999e-08A 53.28us 3.906249999999999e-08A 56.61us 3.906249999999999e-08A 59.94us 3.906249999999999e-08A 63.27us 3.906249999999999e-08A 66.6us 3.906249999999999e-08A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_10_2_10_1 Node10_2_10 Node10_2_11 15400.0
R_10_2_10_2 Node10_2_10 Node10_3_10 15400.0
R_10_2_10_3 Node10_2_10 Node11_2_10 0.9856000000000001
C_10_2_10 Node10_2_10 GND 1.1279296875e-09
I_10_2_11 GND Node10_2_11 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 3.906249999999999e-08A 39.96us 3.906249999999999e-08A 43.29us 3.906249999999999e-08A 46.620000000000005us 3.906249999999999e-08A 49.95us 3.906249999999999e-08A 53.28us 3.906249999999999e-08A 56.61us 3.906249999999999e-08A 59.94us 3.906249999999999e-08A 63.27us 3.906249999999999e-08A 66.6us 3.906249999999999e-08A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_10_2_11_1 Node10_2_11 Node10_2_12 15400.0
R_10_2_11_2 Node10_2_11 Node10_3_11 15400.0
R_10_2_11_3 Node10_2_11 Node11_2_11 0.9856000000000001
C_10_2_11 Node10_2_11 GND 1.1279296875e-09
I_10_2_12 GND Node10_2_12 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 3.906249999999999e-08A 39.96us 3.906249999999999e-08A 43.29us 3.906249999999999e-08A 46.620000000000005us 3.906249999999999e-08A 49.95us 3.906249999999999e-08A 53.28us 3.906249999999999e-08A 56.61us 3.906249999999999e-08A 59.94us 3.906249999999999e-08A 63.27us 3.906249999999999e-08A 66.6us 3.906249999999999e-08A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_10_2_12_1 Node10_2_12 Node10_2_13 15400.0
R_10_2_12_2 Node10_2_12 Node10_3_12 15400.0
R_10_2_12_3 Node10_2_12 Node11_2_12 0.9856000000000001
C_10_2_12 Node10_2_12 GND 1.1279296875e-09
I_10_2_13 GND Node10_2_13 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 3.906249999999999e-08A 39.96us 3.906249999999999e-08A 43.29us 3.906249999999999e-08A 46.620000000000005us 3.906249999999999e-08A 49.95us 3.906249999999999e-08A 53.28us 3.906249999999999e-08A 56.61us 3.906249999999999e-08A 59.94us 3.906249999999999e-08A 63.27us 3.906249999999999e-08A 66.6us 3.906249999999999e-08A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_10_2_13_1 Node10_2_13 Node10_2_14 15400.0
R_10_2_13_2 Node10_2_13 Node10_3_13 15400.0
R_10_2_13_3 Node10_2_13 Node11_2_13 0.9856000000000001
C_10_2_13 Node10_2_13 GND 1.1279296875e-09
I_10_2_14 GND Node10_2_14 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 3.906249999999999e-08A 39.96us 3.906249999999999e-08A 43.29us 3.906249999999999e-08A 46.620000000000005us 3.906249999999999e-08A 49.95us 3.906249999999999e-08A 53.28us 3.906249999999999e-08A 56.61us 3.906249999999999e-08A 59.94us 3.906249999999999e-08A 63.27us 3.906249999999999e-08A 66.6us 3.906249999999999e-08A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_10_2_14_1 Node10_2_14 Node10_2_15 15399.999999999993
R_10_2_14_2 Node10_2_14 Node10_3_14 15400.0
R_10_2_14_3 Node10_2_14 Node11_2_14 0.9856000000000001
C_10_2_14 Node10_2_14 GND 1.1279296875e-09
I_10_2_15 GND Node10_2_15 PWL(0s 0A 3.33us 3.906250000000002e-08A 6.66us 3.906250000000002e-08A 9.99us 3.906250000000002e-08A 13.32us 3.906250000000002e-08A 16.65us 3.906250000000002e-08A 19.98us 3.906250000000002e-08A 23.310000000000002us 3.906250000000002e-08A 26.64us 3.906250000000002e-08A 29.97us 3.906250000000002e-08A 33.3us 3.906250000000002e-08A 36.63us 3.906250000000002e-08A 39.96us 3.906250000000002e-08A 43.29us 3.906250000000002e-08A 46.620000000000005us 3.906250000000002e-08A 49.95us 3.906250000000002e-08A 53.28us 3.906250000000002e-08A 56.61us 3.906250000000002e-08A 59.94us 3.906250000000002e-08A 63.27us 3.906250000000002e-08A 66.6us 3.906250000000002e-08A 69.93us 3.906250000000002e-08A 73.26us 3.906250000000002e-08A 76.59us 3.906250000000002e-08A 79.92us 3.906250000000002e-08A 83.25us 3.906250000000002e-08A 86.58us 3.906250000000002e-08A 89.91us 3.906250000000002e-08A 93.24000000000001us 3.906250000000002e-08A 96.57000000000001us 3.906250000000002e-08A 99.9us 3.906250000000002e-08A)
R_10_2_15_2 Node10_2_15 Node10_3_15 15399.999999999987
R_10_2_15_3 Node10_2_15 Node11_2_15 0.9855999999999993
C_10_2_15 Node10_2_15 GND 1.127929687500001e-09
I_10_3_0 GND Node10_3_0 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 3.906249999999999e-08A 39.96us 3.906249999999999e-08A 43.29us 3.906249999999999e-08A 46.620000000000005us 3.906249999999999e-08A 49.95us 3.906249999999999e-08A 53.28us 3.906249999999999e-08A 56.61us 3.906249999999999e-08A 59.94us 3.906249999999999e-08A 63.27us 3.906249999999999e-08A 66.6us 3.906249999999999e-08A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_10_3_0_1 Node10_3_0 Node10_3_1 15400.0
R_10_3_0_2 Node10_3_0 Node10_4_0 15400.0
R_10_3_0_3 Node10_3_0 Node11_3_0 0.9856000000000001
C_10_3_0 Node10_3_0 GND 1.1279296875e-09
I_10_3_1 GND Node10_3_1 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 3.906249999999999e-08A 39.96us 3.906249999999999e-08A 43.29us 3.906249999999999e-08A 46.620000000000005us 3.906249999999999e-08A 49.95us 3.906249999999999e-08A 53.28us 3.906249999999999e-08A 56.61us 3.906249999999999e-08A 59.94us 3.906249999999999e-08A 63.27us 3.906249999999999e-08A 66.6us 3.906249999999999e-08A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_10_3_1_1 Node10_3_1 Node10_3_2 15400.0
R_10_3_1_2 Node10_3_1 Node10_4_1 15400.0
R_10_3_1_3 Node10_3_1 Node11_3_1 0.9856000000000001
C_10_3_1 Node10_3_1 GND 1.1279296875e-09
I_10_3_2 GND Node10_3_2 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 3.906249999999999e-08A 39.96us 3.906249999999999e-08A 43.29us 3.906249999999999e-08A 46.620000000000005us 3.906249999999999e-08A 49.95us 3.906249999999999e-08A 53.28us 3.906249999999999e-08A 56.61us 3.906249999999999e-08A 59.94us 3.906249999999999e-08A 63.27us 3.906249999999999e-08A 66.6us 3.906249999999999e-08A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_10_3_2_1 Node10_3_2 Node10_3_3 15400.0
R_10_3_2_2 Node10_3_2 Node10_4_2 15400.0
R_10_3_2_3 Node10_3_2 Node11_3_2 0.9856000000000001
C_10_3_2 Node10_3_2 GND 1.1279296875e-09
I_10_3_3 GND Node10_3_3 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 3.906249999999999e-08A 39.96us 3.906249999999999e-08A 43.29us 3.906249999999999e-08A 46.620000000000005us 3.906249999999999e-08A 49.95us 3.906249999999999e-08A 53.28us 3.906249999999999e-08A 56.61us 3.906249999999999e-08A 59.94us 3.906249999999999e-08A 63.27us 3.906249999999999e-08A 66.6us 3.906249999999999e-08A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_10_3_3_1 Node10_3_3 Node10_3_4 15400.0
R_10_3_3_2 Node10_3_3 Node10_4_3 15400.0
R_10_3_3_3 Node10_3_3 Node11_3_3 0.9856000000000001
C_10_3_3 Node10_3_3 GND 1.1279296875e-09
I_10_3_4 GND Node10_3_4 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 3.906249999999999e-08A 39.96us 3.906249999999999e-08A 43.29us 3.906249999999999e-08A 46.620000000000005us 3.906249999999999e-08A 49.95us 3.906249999999999e-08A 53.28us 3.906249999999999e-08A 56.61us 3.906249999999999e-08A 59.94us 3.906249999999999e-08A 63.27us 3.906249999999999e-08A 66.6us 3.906249999999999e-08A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_10_3_4_1 Node10_3_4 Node10_3_5 15400.0
R_10_3_4_2 Node10_3_4 Node10_4_4 15400.0
R_10_3_4_3 Node10_3_4 Node11_3_4 0.9856000000000001
C_10_3_4 Node10_3_4 GND 1.1279296875e-09
I_10_3_5 GND Node10_3_5 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 3.906249999999999e-08A 39.96us 3.906249999999999e-08A 43.29us 3.906249999999999e-08A 46.620000000000005us 3.906249999999999e-08A 49.95us 3.906249999999999e-08A 53.28us 3.906249999999999e-08A 56.61us 3.906249999999999e-08A 59.94us 3.906249999999999e-08A 63.27us 3.906249999999999e-08A 66.6us 3.906249999999999e-08A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_10_3_5_1 Node10_3_5 Node10_3_6 15400.0
R_10_3_5_2 Node10_3_5 Node10_4_5 15400.0
R_10_3_5_3 Node10_3_5 Node11_3_5 0.9856000000000001
C_10_3_5 Node10_3_5 GND 1.1279296875e-09
I_10_3_6 GND Node10_3_6 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 3.906249999999999e-08A 39.96us 3.906249999999999e-08A 43.29us 3.906249999999999e-08A 46.620000000000005us 3.906249999999999e-08A 49.95us 3.906249999999999e-08A 53.28us 3.906249999999999e-08A 56.61us 3.906249999999999e-08A 59.94us 3.906249999999999e-08A 63.27us 3.906249999999999e-08A 66.6us 3.906249999999999e-08A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_10_3_6_1 Node10_3_6 Node10_3_7 15400.0
R_10_3_6_2 Node10_3_6 Node10_4_6 15400.0
R_10_3_6_3 Node10_3_6 Node11_3_6 0.9856000000000001
C_10_3_6 Node10_3_6 GND 1.1279296875e-09
I_10_3_7 GND Node10_3_7 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 3.906249999999999e-08A 39.96us 3.906249999999999e-08A 43.29us 3.906249999999999e-08A 46.620000000000005us 3.906249999999999e-08A 49.95us 3.906249999999999e-08A 53.28us 3.906249999999999e-08A 56.61us 3.906249999999999e-08A 59.94us 3.906249999999999e-08A 63.27us 3.906249999999999e-08A 66.6us 3.906249999999999e-08A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_10_3_7_1 Node10_3_7 Node10_3_8 15400.0
R_10_3_7_2 Node10_3_7 Node10_4_7 15400.0
R_10_3_7_3 Node10_3_7 Node11_3_7 0.9856000000000001
C_10_3_7 Node10_3_7 GND 1.1279296875e-09
I_10_3_8 GND Node10_3_8 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 3.906249999999999e-08A 39.96us 3.906249999999999e-08A 43.29us 3.906249999999999e-08A 46.620000000000005us 3.906249999999999e-08A 49.95us 3.906249999999999e-08A 53.28us 3.906249999999999e-08A 56.61us 3.906249999999999e-08A 59.94us 3.906249999999999e-08A 63.27us 3.906249999999999e-08A 66.6us 3.906249999999999e-08A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_10_3_8_1 Node10_3_8 Node10_3_9 15400.0
R_10_3_8_2 Node10_3_8 Node10_4_8 15400.0
R_10_3_8_3 Node10_3_8 Node11_3_8 0.9856000000000001
C_10_3_8 Node10_3_8 GND 1.1279296875e-09
I_10_3_9 GND Node10_3_9 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 3.906249999999999e-08A 39.96us 3.906249999999999e-08A 43.29us 3.906249999999999e-08A 46.620000000000005us 3.906249999999999e-08A 49.95us 3.906249999999999e-08A 53.28us 3.906249999999999e-08A 56.61us 3.906249999999999e-08A 59.94us 3.906249999999999e-08A 63.27us 3.906249999999999e-08A 66.6us 3.906249999999999e-08A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_10_3_9_1 Node10_3_9 Node10_3_10 15400.0
R_10_3_9_2 Node10_3_9 Node10_4_9 15400.0
R_10_3_9_3 Node10_3_9 Node11_3_9 0.9856000000000001
C_10_3_9 Node10_3_9 GND 1.1279296875e-09
I_10_3_10 GND Node10_3_10 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 3.906249999999999e-08A 39.96us 3.906249999999999e-08A 43.29us 3.906249999999999e-08A 46.620000000000005us 3.906249999999999e-08A 49.95us 3.906249999999999e-08A 53.28us 3.906249999999999e-08A 56.61us 3.906249999999999e-08A 59.94us 3.906249999999999e-08A 63.27us 3.906249999999999e-08A 66.6us 3.906249999999999e-08A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_10_3_10_1 Node10_3_10 Node10_3_11 15400.0
R_10_3_10_2 Node10_3_10 Node10_4_10 15400.0
R_10_3_10_3 Node10_3_10 Node11_3_10 0.9856000000000001
C_10_3_10 Node10_3_10 GND 1.1279296875e-09
I_10_3_11 GND Node10_3_11 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 3.906249999999999e-08A 39.96us 3.906249999999999e-08A 43.29us 3.906249999999999e-08A 46.620000000000005us 3.906249999999999e-08A 49.95us 3.906249999999999e-08A 53.28us 3.906249999999999e-08A 56.61us 3.906249999999999e-08A 59.94us 3.906249999999999e-08A 63.27us 3.906249999999999e-08A 66.6us 3.906249999999999e-08A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_10_3_11_1 Node10_3_11 Node10_3_12 15400.0
R_10_3_11_2 Node10_3_11 Node10_4_11 15400.0
R_10_3_11_3 Node10_3_11 Node11_3_11 0.9856000000000001
C_10_3_11 Node10_3_11 GND 1.1279296875e-09
I_10_3_12 GND Node10_3_12 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 3.906249999999999e-08A 39.96us 3.906249999999999e-08A 43.29us 3.906249999999999e-08A 46.620000000000005us 3.906249999999999e-08A 49.95us 3.906249999999999e-08A 53.28us 3.906249999999999e-08A 56.61us 3.906249999999999e-08A 59.94us 3.906249999999999e-08A 63.27us 3.906249999999999e-08A 66.6us 3.906249999999999e-08A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_10_3_12_1 Node10_3_12 Node10_3_13 15400.0
R_10_3_12_2 Node10_3_12 Node10_4_12 15400.0
R_10_3_12_3 Node10_3_12 Node11_3_12 0.9856000000000001
C_10_3_12 Node10_3_12 GND 1.1279296875e-09
I_10_3_13 GND Node10_3_13 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 3.906249999999999e-08A 39.96us 3.906249999999999e-08A 43.29us 3.906249999999999e-08A 46.620000000000005us 3.906249999999999e-08A 49.95us 3.906249999999999e-08A 53.28us 3.906249999999999e-08A 56.61us 3.906249999999999e-08A 59.94us 3.906249999999999e-08A 63.27us 3.906249999999999e-08A 66.6us 3.906249999999999e-08A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_10_3_13_1 Node10_3_13 Node10_3_14 15400.0
R_10_3_13_2 Node10_3_13 Node10_4_13 15400.0
R_10_3_13_3 Node10_3_13 Node11_3_13 0.9856000000000001
C_10_3_13 Node10_3_13 GND 1.1279296875e-09
I_10_3_14 GND Node10_3_14 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 3.906249999999999e-08A 39.96us 3.906249999999999e-08A 43.29us 3.906249999999999e-08A 46.620000000000005us 3.906249999999999e-08A 49.95us 3.906249999999999e-08A 53.28us 3.906249999999999e-08A 56.61us 3.906249999999999e-08A 59.94us 3.906249999999999e-08A 63.27us 3.906249999999999e-08A 66.6us 3.906249999999999e-08A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_10_3_14_1 Node10_3_14 Node10_3_15 15399.999999999993
R_10_3_14_2 Node10_3_14 Node10_4_14 15400.0
R_10_3_14_3 Node10_3_14 Node11_3_14 0.9856000000000001
C_10_3_14 Node10_3_14 GND 1.1279296875e-09
I_10_3_15 GND Node10_3_15 PWL(0s 0A 3.33us 3.906250000000002e-08A 6.66us 3.906250000000002e-08A 9.99us 3.906250000000002e-08A 13.32us 3.906250000000002e-08A 16.65us 3.906250000000002e-08A 19.98us 3.906250000000002e-08A 23.310000000000002us 3.906250000000002e-08A 26.64us 3.906250000000002e-08A 29.97us 3.906250000000002e-08A 33.3us 3.906250000000002e-08A 36.63us 3.906250000000002e-08A 39.96us 3.906250000000002e-08A 43.29us 3.906250000000002e-08A 46.620000000000005us 3.906250000000002e-08A 49.95us 3.906250000000002e-08A 53.28us 3.906250000000002e-08A 56.61us 3.906250000000002e-08A 59.94us 3.906250000000002e-08A 63.27us 3.906250000000002e-08A 66.6us 3.906250000000002e-08A 69.93us 3.906250000000002e-08A 73.26us 3.906250000000002e-08A 76.59us 3.906250000000002e-08A 79.92us 3.906250000000002e-08A 83.25us 3.906250000000002e-08A 86.58us 3.906250000000002e-08A 89.91us 3.906250000000002e-08A 93.24000000000001us 3.906250000000002e-08A 96.57000000000001us 3.906250000000002e-08A 99.9us 3.906250000000002e-08A)
R_10_3_15_2 Node10_3_15 Node10_4_15 15399.999999999987
R_10_3_15_3 Node10_3_15 Node11_3_15 0.9855999999999993
C_10_3_15 Node10_3_15 GND 1.127929687500001e-09
I_10_4_0 GND Node10_4_0 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 3.906249999999999e-08A 39.96us 3.906249999999999e-08A 43.29us 3.906249999999999e-08A 46.620000000000005us 3.906249999999999e-08A 49.95us 3.906249999999999e-08A 53.28us 3.906249999999999e-08A 56.61us 3.906249999999999e-08A 59.94us 3.906249999999999e-08A 63.27us 3.906249999999999e-08A 66.6us 3.906249999999999e-08A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_10_4_0_1 Node10_4_0 Node10_4_1 15400.0
R_10_4_0_2 Node10_4_0 Node10_5_0 15400.0
R_10_4_0_3 Node10_4_0 Node11_4_0 0.9856000000000001
C_10_4_0 Node10_4_0 GND 1.1279296875e-09
I_10_4_1 GND Node10_4_1 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 3.906249999999999e-08A 39.96us 3.906249999999999e-08A 43.29us 3.906249999999999e-08A 46.620000000000005us 3.906249999999999e-08A 49.95us 3.906249999999999e-08A 53.28us 3.906249999999999e-08A 56.61us 3.906249999999999e-08A 59.94us 3.906249999999999e-08A 63.27us 3.906249999999999e-08A 66.6us 3.906249999999999e-08A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_10_4_1_1 Node10_4_1 Node10_4_2 15400.0
R_10_4_1_2 Node10_4_1 Node10_5_1 15400.0
R_10_4_1_3 Node10_4_1 Node11_4_1 0.9856000000000001
C_10_4_1 Node10_4_1 GND 1.1279296875e-09
I_10_4_2 GND Node10_4_2 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 3.906249999999999e-08A 39.96us 3.906249999999999e-08A 43.29us 3.906249999999999e-08A 46.620000000000005us 3.906249999999999e-08A 49.95us 3.906249999999999e-08A 53.28us 3.906249999999999e-08A 56.61us 3.906249999999999e-08A 59.94us 3.906249999999999e-08A 63.27us 3.906249999999999e-08A 66.6us 3.906249999999999e-08A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_10_4_2_1 Node10_4_2 Node10_4_3 15400.0
R_10_4_2_2 Node10_4_2 Node10_5_2 15400.0
R_10_4_2_3 Node10_4_2 Node11_4_2 0.9856000000000001
C_10_4_2 Node10_4_2 GND 1.1279296875e-09
I_10_4_3 GND Node10_4_3 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 3.906249999999999e-08A 39.96us 3.906249999999999e-08A 43.29us 3.906249999999999e-08A 46.620000000000005us 3.906249999999999e-08A 49.95us 3.906249999999999e-08A 53.28us 3.906249999999999e-08A 56.61us 3.906249999999999e-08A 59.94us 3.906249999999999e-08A 63.27us 3.906249999999999e-08A 66.6us 3.906249999999999e-08A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_10_4_3_1 Node10_4_3 Node10_4_4 15400.0
R_10_4_3_2 Node10_4_3 Node10_5_3 15400.0
R_10_4_3_3 Node10_4_3 Node11_4_3 0.9856000000000001
C_10_4_3 Node10_4_3 GND 1.1279296875e-09
I_10_4_4 GND Node10_4_4 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 3.906249999999999e-08A 39.96us 3.906249999999999e-08A 43.29us 3.906249999999999e-08A 46.620000000000005us 3.906249999999999e-08A 49.95us 3.906249999999999e-08A 53.28us 3.906249999999999e-08A 56.61us 3.906249999999999e-08A 59.94us 3.906249999999999e-08A 63.27us 3.906249999999999e-08A 66.6us 3.906249999999999e-08A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_10_4_4_1 Node10_4_4 Node10_4_5 15400.0
R_10_4_4_2 Node10_4_4 Node10_5_4 15400.0
R_10_4_4_3 Node10_4_4 Node11_4_4 0.9856000000000001
C_10_4_4 Node10_4_4 GND 1.1279296875e-09
I_10_4_5 GND Node10_4_5 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 3.906249999999999e-08A 39.96us 3.906249999999999e-08A 43.29us 3.906249999999999e-08A 46.620000000000005us 3.906249999999999e-08A 49.95us 3.906249999999999e-08A 53.28us 3.906249999999999e-08A 56.61us 3.906249999999999e-08A 59.94us 3.906249999999999e-08A 63.27us 3.906249999999999e-08A 66.6us 3.906249999999999e-08A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_10_4_5_1 Node10_4_5 Node10_4_6 15400.0
R_10_4_5_2 Node10_4_5 Node10_5_5 15400.0
R_10_4_5_3 Node10_4_5 Node11_4_5 0.9856000000000001
C_10_4_5 Node10_4_5 GND 1.1279296875e-09
I_10_4_6 GND Node10_4_6 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 3.906249999999999e-08A 39.96us 3.906249999999999e-08A 43.29us 3.906249999999999e-08A 46.620000000000005us 3.906249999999999e-08A 49.95us 3.906249999999999e-08A 53.28us 3.906249999999999e-08A 56.61us 3.906249999999999e-08A 59.94us 3.906249999999999e-08A 63.27us 3.906249999999999e-08A 66.6us 3.906249999999999e-08A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_10_4_6_1 Node10_4_6 Node10_4_7 15400.0
R_10_4_6_2 Node10_4_6 Node10_5_6 15400.0
R_10_4_6_3 Node10_4_6 Node11_4_6 0.9856000000000001
C_10_4_6 Node10_4_6 GND 1.1279296875e-09
I_10_4_7 GND Node10_4_7 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 3.906249999999999e-08A 39.96us 3.906249999999999e-08A 43.29us 3.906249999999999e-08A 46.620000000000005us 3.906249999999999e-08A 49.95us 3.906249999999999e-08A 53.28us 3.906249999999999e-08A 56.61us 3.906249999999999e-08A 59.94us 3.906249999999999e-08A 63.27us 3.906249999999999e-08A 66.6us 3.906249999999999e-08A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_10_4_7_1 Node10_4_7 Node10_4_8 15400.0
R_10_4_7_2 Node10_4_7 Node10_5_7 15400.0
R_10_4_7_3 Node10_4_7 Node11_4_7 0.9856000000000001
C_10_4_7 Node10_4_7 GND 1.1279296875e-09
I_10_4_8 GND Node10_4_8 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 3.906249999999999e-08A 39.96us 3.906249999999999e-08A 43.29us 3.906249999999999e-08A 46.620000000000005us 3.906249999999999e-08A 49.95us 3.906249999999999e-08A 53.28us 3.906249999999999e-08A 56.61us 3.906249999999999e-08A 59.94us 3.906249999999999e-08A 63.27us 3.906249999999999e-08A 66.6us 3.906249999999999e-08A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_10_4_8_1 Node10_4_8 Node10_4_9 15400.0
R_10_4_8_2 Node10_4_8 Node10_5_8 15400.0
R_10_4_8_3 Node10_4_8 Node11_4_8 0.9856000000000001
C_10_4_8 Node10_4_8 GND 1.1279296875e-09
I_10_4_9 GND Node10_4_9 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 3.906249999999999e-08A 39.96us 3.906249999999999e-08A 43.29us 3.906249999999999e-08A 46.620000000000005us 3.906249999999999e-08A 49.95us 3.906249999999999e-08A 53.28us 3.906249999999999e-08A 56.61us 3.906249999999999e-08A 59.94us 3.906249999999999e-08A 63.27us 3.906249999999999e-08A 66.6us 3.906249999999999e-08A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_10_4_9_1 Node10_4_9 Node10_4_10 15400.0
R_10_4_9_2 Node10_4_9 Node10_5_9 15400.0
R_10_4_9_3 Node10_4_9 Node11_4_9 0.9856000000000001
C_10_4_9 Node10_4_9 GND 1.1279296875e-09
I_10_4_10 GND Node10_4_10 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 3.906249999999999e-08A 39.96us 3.906249999999999e-08A 43.29us 3.906249999999999e-08A 46.620000000000005us 3.906249999999999e-08A 49.95us 3.906249999999999e-08A 53.28us 3.906249999999999e-08A 56.61us 3.906249999999999e-08A 59.94us 3.906249999999999e-08A 63.27us 3.906249999999999e-08A 66.6us 3.906249999999999e-08A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_10_4_10_1 Node10_4_10 Node10_4_11 15400.0
R_10_4_10_2 Node10_4_10 Node10_5_10 15400.0
R_10_4_10_3 Node10_4_10 Node11_4_10 0.9856000000000001
C_10_4_10 Node10_4_10 GND 1.1279296875e-09
I_10_4_11 GND Node10_4_11 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 3.906249999999999e-08A 39.96us 3.906249999999999e-08A 43.29us 3.906249999999999e-08A 46.620000000000005us 3.906249999999999e-08A 49.95us 3.906249999999999e-08A 53.28us 3.906249999999999e-08A 56.61us 3.906249999999999e-08A 59.94us 3.906249999999999e-08A 63.27us 3.906249999999999e-08A 66.6us 3.906249999999999e-08A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_10_4_11_1 Node10_4_11 Node10_4_12 15400.0
R_10_4_11_2 Node10_4_11 Node10_5_11 15400.0
R_10_4_11_3 Node10_4_11 Node11_4_11 0.9856000000000001
C_10_4_11 Node10_4_11 GND 1.1279296875e-09
I_10_4_12 GND Node10_4_12 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 3.906249999999999e-08A 39.96us 3.906249999999999e-08A 43.29us 3.906249999999999e-08A 46.620000000000005us 3.906249999999999e-08A 49.95us 3.906249999999999e-08A 53.28us 3.906249999999999e-08A 56.61us 3.906249999999999e-08A 59.94us 3.906249999999999e-08A 63.27us 3.906249999999999e-08A 66.6us 3.906249999999999e-08A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_10_4_12_1 Node10_4_12 Node10_4_13 15400.0
R_10_4_12_2 Node10_4_12 Node10_5_12 15400.0
R_10_4_12_3 Node10_4_12 Node11_4_12 0.9856000000000001
C_10_4_12 Node10_4_12 GND 1.1279296875e-09
I_10_4_13 GND Node10_4_13 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 3.906249999999999e-08A 39.96us 3.906249999999999e-08A 43.29us 3.906249999999999e-08A 46.620000000000005us 3.906249999999999e-08A 49.95us 3.906249999999999e-08A 53.28us 3.906249999999999e-08A 56.61us 3.906249999999999e-08A 59.94us 3.906249999999999e-08A 63.27us 3.906249999999999e-08A 66.6us 3.906249999999999e-08A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_10_4_13_1 Node10_4_13 Node10_4_14 15400.0
R_10_4_13_2 Node10_4_13 Node10_5_13 15400.0
R_10_4_13_3 Node10_4_13 Node11_4_13 0.9856000000000001
C_10_4_13 Node10_4_13 GND 1.1279296875e-09
I_10_4_14 GND Node10_4_14 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 3.906249999999999e-08A 39.96us 3.906249999999999e-08A 43.29us 3.906249999999999e-08A 46.620000000000005us 3.906249999999999e-08A 49.95us 3.906249999999999e-08A 53.28us 3.906249999999999e-08A 56.61us 3.906249999999999e-08A 59.94us 3.906249999999999e-08A 63.27us 3.906249999999999e-08A 66.6us 3.906249999999999e-08A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_10_4_14_1 Node10_4_14 Node10_4_15 15399.999999999993
R_10_4_14_2 Node10_4_14 Node10_5_14 15400.0
R_10_4_14_3 Node10_4_14 Node11_4_14 0.9856000000000001
C_10_4_14 Node10_4_14 GND 1.1279296875e-09
I_10_4_15 GND Node10_4_15 PWL(0s 0A 3.33us 3.906250000000002e-08A 6.66us 3.906250000000002e-08A 9.99us 3.906250000000002e-08A 13.32us 3.906250000000002e-08A 16.65us 3.906250000000002e-08A 19.98us 3.906250000000002e-08A 23.310000000000002us 3.906250000000002e-08A 26.64us 3.906250000000002e-08A 29.97us 3.906250000000002e-08A 33.3us 3.906250000000002e-08A 36.63us 3.906250000000002e-08A 39.96us 3.906250000000002e-08A 43.29us 3.906250000000002e-08A 46.620000000000005us 3.906250000000002e-08A 49.95us 3.906250000000002e-08A 53.28us 3.906250000000002e-08A 56.61us 3.906250000000002e-08A 59.94us 3.906250000000002e-08A 63.27us 3.906250000000002e-08A 66.6us 3.906250000000002e-08A 69.93us 3.906250000000002e-08A 73.26us 3.906250000000002e-08A 76.59us 3.906250000000002e-08A 79.92us 3.906250000000002e-08A 83.25us 3.906250000000002e-08A 86.58us 3.906250000000002e-08A 89.91us 3.906250000000002e-08A 93.24000000000001us 3.906250000000002e-08A 96.57000000000001us 3.906250000000002e-08A 99.9us 3.906250000000002e-08A)
R_10_4_15_2 Node10_4_15 Node10_5_15 15399.999999999987
R_10_4_15_3 Node10_4_15 Node11_4_15 0.9855999999999993
C_10_4_15 Node10_4_15 GND 1.127929687500001e-09
I_10_5_0 GND Node10_5_0 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 3.906249999999999e-08A 39.96us 3.906249999999999e-08A 43.29us 3.906249999999999e-08A 46.620000000000005us 3.906249999999999e-08A 49.95us 3.906249999999999e-08A 53.28us 3.906249999999999e-08A 56.61us 3.906249999999999e-08A 59.94us 3.906249999999999e-08A 63.27us 3.906249999999999e-08A 66.6us 3.906249999999999e-08A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_10_5_0_1 Node10_5_0 Node10_5_1 15400.0
R_10_5_0_2 Node10_5_0 Node10_6_0 11200.000000000004
R_10_5_0_3 Node10_5_0 Node11_5_0 0.9856000000000001
C_10_5_0 Node10_5_0 GND 1.1279296875e-09
I_10_5_1 GND Node10_5_1 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 3.906249999999999e-08A 39.96us 3.906249999999999e-08A 43.29us 3.906249999999999e-08A 46.620000000000005us 3.906249999999999e-08A 49.95us 3.906249999999999e-08A 53.28us 3.906249999999999e-08A 56.61us 3.906249999999999e-08A 59.94us 3.906249999999999e-08A 63.27us 3.906249999999999e-08A 66.6us 3.906249999999999e-08A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_10_5_1_1 Node10_5_1 Node10_5_2 15400.0
R_10_5_1_2 Node10_5_1 Node10_6_1 11200.000000000004
R_10_5_1_3 Node10_5_1 Node11_5_1 0.9856000000000001
C_10_5_1 Node10_5_1 GND 1.1279296875e-09
I_10_5_2 GND Node10_5_2 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 3.906249999999999e-08A 39.96us 3.906249999999999e-08A 43.29us 3.906249999999999e-08A 46.620000000000005us 3.906249999999999e-08A 49.95us 3.906249999999999e-08A 53.28us 3.906249999999999e-08A 56.61us 3.906249999999999e-08A 59.94us 3.906249999999999e-08A 63.27us 3.906249999999999e-08A 66.6us 3.906249999999999e-08A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_10_5_2_1 Node10_5_2 Node10_5_3 15400.0
R_10_5_2_2 Node10_5_2 Node10_6_2 11200.000000000004
R_10_5_2_3 Node10_5_2 Node11_5_2 0.9856000000000001
C_10_5_2 Node10_5_2 GND 1.1279296875e-09
I_10_5_3 GND Node10_5_3 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 3.906249999999999e-08A 39.96us 3.906249999999999e-08A 43.29us 3.906249999999999e-08A 46.620000000000005us 3.906249999999999e-08A 49.95us 3.906249999999999e-08A 53.28us 3.906249999999999e-08A 56.61us 3.906249999999999e-08A 59.94us 3.906249999999999e-08A 63.27us 3.906249999999999e-08A 66.6us 3.906249999999999e-08A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_10_5_3_1 Node10_5_3 Node10_5_4 15400.0
R_10_5_3_2 Node10_5_3 Node10_6_3 12176.744186046515
R_10_5_3_3 Node10_5_3 Node11_5_3 0.9856000000000001
C_10_5_3 Node10_5_3 GND 1.1279296875e-09
I_10_5_4 GND Node10_5_4 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 3.906249999999999e-08A 39.96us 3.906249999999999e-08A 43.29us 3.906249999999999e-08A 46.620000000000005us 3.906249999999999e-08A 49.95us 3.906249999999999e-08A 53.28us 3.906249999999999e-08A 56.61us 3.906249999999999e-08A 59.94us 3.906249999999999e-08A 63.27us 3.906249999999999e-08A 66.6us 3.906249999999999e-08A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_10_5_4_1 Node10_5_4 Node10_5_5 15400.0
R_10_5_4_2 Node10_5_4 Node10_6_4 12512.500000000004
R_10_5_4_3 Node10_5_4 Node11_5_4 0.9856000000000001
C_10_5_4 Node10_5_4 GND 1.1279296875e-09
I_10_5_5 GND Node10_5_5 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 3.906249999999999e-08A 39.96us 3.906249999999999e-08A 43.29us 3.906249999999999e-08A 46.620000000000005us 3.906249999999999e-08A 49.95us 3.906249999999999e-08A 53.28us 3.906249999999999e-08A 56.61us 3.906249999999999e-08A 59.94us 3.906249999999999e-08A 63.27us 3.906249999999999e-08A 66.6us 3.906249999999999e-08A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_10_5_5_1 Node10_5_5 Node10_5_6 15400.0
R_10_5_5_2 Node10_5_5 Node10_6_5 12512.500000000004
R_10_5_5_3 Node10_5_5 Node11_5_5 0.9856000000000001
C_10_5_5 Node10_5_5 GND 1.1279296875e-09
I_10_5_6 GND Node10_5_6 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 3.906249999999999e-08A 39.96us 3.906249999999999e-08A 43.29us 3.906249999999999e-08A 46.620000000000005us 3.906249999999999e-08A 49.95us 3.906249999999999e-08A 53.28us 3.906249999999999e-08A 56.61us 3.906249999999999e-08A 59.94us 3.906249999999999e-08A 63.27us 3.906249999999999e-08A 66.6us 3.906249999999999e-08A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_10_5_6_1 Node10_5_6 Node10_5_7 15400.0
R_10_5_6_2 Node10_5_6 Node10_6_6 16449.999999999996
R_10_5_6_3 Node10_5_6 Node11_5_6 0.9856000000000001
C_10_5_6 Node10_5_6 GND 1.1279296875e-09
I_10_5_7 GND Node10_5_7 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 3.906249999999999e-08A 39.96us 3.906249999999999e-08A 43.29us 3.906249999999999e-08A 46.620000000000005us 3.906249999999999e-08A 49.95us 3.906249999999999e-08A 53.28us 3.906249999999999e-08A 56.61us 3.906249999999999e-08A 59.94us 3.906249999999999e-08A 63.27us 3.906249999999999e-08A 66.6us 3.906249999999999e-08A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_10_5_7_1 Node10_5_7 Node10_5_8 15400.0
R_10_5_7_2 Node10_5_7 Node10_6_7 26949.999999999953
R_10_5_7_3 Node10_5_7 Node11_5_7 0.9856000000000001
C_10_5_7 Node10_5_7 GND 1.1279296875e-09
I_10_5_8 GND Node10_5_8 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 3.906249999999999e-08A 39.96us 3.906249999999999e-08A 43.29us 3.906249999999999e-08A 46.620000000000005us 3.906249999999999e-08A 49.95us 3.906249999999999e-08A 53.28us 3.906249999999999e-08A 56.61us 3.906249999999999e-08A 59.94us 3.906249999999999e-08A 63.27us 3.906249999999999e-08A 66.6us 3.906249999999999e-08A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_10_5_8_1 Node10_5_8 Node10_5_9 15400.0
R_10_5_8_2 Node10_5_8 Node10_6_8 26949.999999999953
R_10_5_8_3 Node10_5_8 Node11_5_8 0.9856000000000001
C_10_5_8 Node10_5_8 GND 1.1279296875e-09
I_10_5_9 GND Node10_5_9 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 3.906249999999999e-08A 39.96us 3.906249999999999e-08A 43.29us 3.906249999999999e-08A 46.620000000000005us 3.906249999999999e-08A 49.95us 3.906249999999999e-08A 53.28us 3.906249999999999e-08A 56.61us 3.906249999999999e-08A 59.94us 3.906249999999999e-08A 63.27us 3.906249999999999e-08A 66.6us 3.906249999999999e-08A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_10_5_9_1 Node10_5_9 Node10_5_10 15400.0
R_10_5_9_2 Node10_5_9 Node10_6_9 26949.999999999953
R_10_5_9_3 Node10_5_9 Node11_5_9 0.9856000000000001
C_10_5_9 Node10_5_9 GND 1.1279296875e-09
I_10_5_10 GND Node10_5_10 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 3.906249999999999e-08A 39.96us 3.906249999999999e-08A 43.29us 3.906249999999999e-08A 46.620000000000005us 3.906249999999999e-08A 49.95us 3.906249999999999e-08A 53.28us 3.906249999999999e-08A 56.61us 3.906249999999999e-08A 59.94us 3.906249999999999e-08A 63.27us 3.906249999999999e-08A 66.6us 3.906249999999999e-08A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_10_5_10_1 Node10_5_10 Node10_5_11 15400.0
R_10_5_10_2 Node10_5_10 Node10_6_10 26949.999999999953
R_10_5_10_3 Node10_5_10 Node11_5_10 0.9856000000000001
C_10_5_10 Node10_5_10 GND 1.1279296875e-09
I_10_5_11 GND Node10_5_11 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 3.906249999999999e-08A 39.96us 3.906249999999999e-08A 43.29us 3.906249999999999e-08A 46.620000000000005us 3.906249999999999e-08A 49.95us 3.906249999999999e-08A 53.28us 3.906249999999999e-08A 56.61us 3.906249999999999e-08A 59.94us 3.906249999999999e-08A 63.27us 3.906249999999999e-08A 66.6us 3.906249999999999e-08A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_10_5_11_1 Node10_5_11 Node10_5_12 15400.0
R_10_5_11_2 Node10_5_11 Node10_6_11 26949.999999999953
R_10_5_11_3 Node10_5_11 Node11_5_11 0.9856000000000001
C_10_5_11 Node10_5_11 GND 1.1279296875e-09
I_10_5_12 GND Node10_5_12 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 3.906249999999999e-08A 39.96us 3.906249999999999e-08A 43.29us 3.906249999999999e-08A 46.620000000000005us 3.906249999999999e-08A 49.95us 3.906249999999999e-08A 53.28us 3.906249999999999e-08A 56.61us 3.906249999999999e-08A 59.94us 3.906249999999999e-08A 63.27us 3.906249999999999e-08A 66.6us 3.906249999999999e-08A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_10_5_12_1 Node10_5_12 Node10_5_13 15400.0
R_10_5_12_2 Node10_5_12 Node10_6_12 26949.999999999953
R_10_5_12_3 Node10_5_12 Node11_5_12 0.9856000000000001
C_10_5_12 Node10_5_12 GND 1.1279296875e-09
I_10_5_13 GND Node10_5_13 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 3.906249999999999e-08A 39.96us 3.906249999999999e-08A 43.29us 3.906249999999999e-08A 46.620000000000005us 3.906249999999999e-08A 49.95us 3.906249999999999e-08A 53.28us 3.906249999999999e-08A 56.61us 3.906249999999999e-08A 59.94us 3.906249999999999e-08A 63.27us 3.906249999999999e-08A 66.6us 3.906249999999999e-08A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_10_5_13_1 Node10_5_13 Node10_5_14 15400.0
R_10_5_13_2 Node10_5_13 Node10_6_13 26949.999999999953
R_10_5_13_3 Node10_5_13 Node11_5_13 0.9856000000000001
C_10_5_13 Node10_5_13 GND 1.1279296875e-09
I_10_5_14 GND Node10_5_14 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 3.906249999999999e-08A 39.96us 3.906249999999999e-08A 43.29us 3.906249999999999e-08A 46.620000000000005us 3.906249999999999e-08A 49.95us 3.906249999999999e-08A 53.28us 3.906249999999999e-08A 56.61us 3.906249999999999e-08A 59.94us 3.906249999999999e-08A 63.27us 3.906249999999999e-08A 66.6us 3.906249999999999e-08A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_10_5_14_1 Node10_5_14 Node10_5_15 15399.999999999993
R_10_5_14_2 Node10_5_14 Node10_6_14 26949.999999999953
R_10_5_14_3 Node10_5_14 Node11_5_14 0.9856000000000001
C_10_5_14 Node10_5_14 GND 1.1279296875e-09
I_10_5_15 GND Node10_5_15 PWL(0s 0A 3.33us 3.906250000000002e-08A 6.66us 3.906250000000002e-08A 9.99us 3.906250000000002e-08A 13.32us 3.906250000000002e-08A 16.65us 3.906250000000002e-08A 19.98us 3.906250000000002e-08A 23.310000000000002us 3.906250000000002e-08A 26.64us 3.906250000000002e-08A 29.97us 3.906250000000002e-08A 33.3us 3.906250000000002e-08A 36.63us 3.906250000000002e-08A 39.96us 3.906250000000002e-08A 43.29us 3.906250000000002e-08A 46.620000000000005us 3.906250000000002e-08A 49.95us 3.906250000000002e-08A 53.28us 3.906250000000002e-08A 56.61us 3.906250000000002e-08A 59.94us 3.906250000000002e-08A 63.27us 3.906250000000002e-08A 66.6us 3.906250000000002e-08A 69.93us 3.906250000000002e-08A 73.26us 3.906250000000002e-08A 76.59us 3.906250000000002e-08A 79.92us 3.906250000000002e-08A 83.25us 3.906250000000002e-08A 86.58us 3.906250000000002e-08A 89.91us 3.906250000000002e-08A 93.24000000000001us 3.906250000000002e-08A 96.57000000000001us 3.906250000000002e-08A 99.9us 3.906250000000002e-08A)
R_10_5_15_2 Node10_5_15 Node10_6_15 26949.999999999924
R_10_5_15_3 Node10_5_15 Node11_5_15 0.9855999999999993
C_10_5_15 Node10_5_15 GND 1.127929687500001e-09
I_10_6_0 GND Node10_6_0 PWL(0s 0A 3.33us 8.59374999999999e-08A 6.66us 8.59374999999999e-08A 9.99us 8.59374999999999e-08A 13.32us 8.59374999999999e-08A 16.65us 8.59374999999999e-08A 19.98us 8.59374999999999e-08A 23.310000000000002us 8.59374999999999e-08A 26.64us 8.59374999999999e-08A 29.97us 8.59374999999999e-08A 33.3us 8.59374999999999e-08A 36.63us 8.59374999999999e-08A 39.96us 8.59374999999999e-08A 43.29us 8.59374999999999e-08A 46.620000000000005us 8.59374999999999e-08A 49.95us 8.59374999999999e-08A 53.28us 8.59374999999999e-08A 56.61us 8.59374999999999e-08A 59.94us 8.59374999999999e-08A 63.27us 8.59374999999999e-08A 66.6us 8.59374999999999e-08A 69.93us 8.59374999999999e-08A 73.26us 8.59374999999999e-08A 76.59us 8.59374999999999e-08A 79.92us 8.59374999999999e-08A 83.25us 8.59374999999999e-08A 86.58us 8.59374999999999e-08A 89.91us 8.59374999999999e-08A 93.24000000000001us 8.59374999999999e-08A 96.57000000000001us 8.59374999999999e-08A 99.9us 8.59374999999999e-08A)
R_10_6_0_1 Node10_6_0 Node10_6_1 7000.000000000007
R_10_6_0_2 Node10_6_0 Node10_7_0 6066.66666666667
R_10_6_0_3 Node10_6_0 Node11_6_0 0.44800000000000045
C_10_6_0 Node10_6_0 GND 2.481445312499998e-09
I_10_6_1 GND Node10_6_1 PWL(0s 0A 3.33us 8.59374999999999e-08A 6.66us 8.59374999999999e-08A 9.99us 8.59374999999999e-08A 13.32us 8.59374999999999e-08A 16.65us 8.59374999999999e-08A 19.98us 8.59374999999999e-08A 23.310000000000002us 8.59374999999999e-08A 26.64us 8.59374999999999e-08A 29.97us 8.59374999999999e-08A 33.3us 8.59374999999999e-08A 36.63us 8.59374999999999e-08A 39.96us 8.59374999999999e-08A 43.29us 8.59374999999999e-08A 46.620000000000005us 8.59374999999999e-08A 49.95us 8.59374999999999e-08A 53.28us 8.59374999999999e-08A 56.61us 8.59374999999999e-08A 59.94us 8.59374999999999e-08A 63.27us 8.59374999999999e-08A 66.6us 8.59374999999999e-08A 69.93us 8.59374999999999e-08A 73.26us 8.59374999999999e-08A 76.59us 8.59374999999999e-08A 79.92us 8.59374999999999e-08A 83.25us 8.59374999999999e-08A 86.58us 8.59374999999999e-08A 89.91us 8.59374999999999e-08A 93.24000000000001us 8.59374999999999e-08A 96.57000000000001us 8.59374999999999e-08A 99.9us 8.59374999999999e-08A)
R_10_6_1_1 Node10_6_1 Node10_6_2 7000.000000000007
R_10_6_1_2 Node10_6_1 Node10_7_1 6066.66666666667
R_10_6_1_3 Node10_6_1 Node11_6_1 0.44800000000000045
C_10_6_1 Node10_6_1 GND 2.481445312499998e-09
I_10_6_2 GND Node10_6_2 PWL(0s 0A 3.33us 8.59374999999999e-08A 6.66us 8.59374999999999e-08A 9.99us 8.59374999999999e-08A 13.32us 8.59374999999999e-08A 16.65us 8.59374999999999e-08A 19.98us 8.59374999999999e-08A 23.310000000000002us 8.59374999999999e-08A 26.64us 8.59374999999999e-08A 29.97us 8.59374999999999e-08A 33.3us 8.59374999999999e-08A 36.63us 8.59374999999999e-08A 39.96us 8.59374999999999e-08A 43.29us 8.59374999999999e-08A 46.620000000000005us 8.59374999999999e-08A 49.95us 8.59374999999999e-08A 53.28us 8.59374999999999e-08A 56.61us 8.59374999999999e-08A 59.94us 8.59374999999999e-08A 63.27us 8.59374999999999e-08A 66.6us 8.59374999999999e-08A 69.93us 8.59374999999999e-08A 73.26us 8.59374999999999e-08A 76.59us 8.59374999999999e-08A 79.92us 8.59374999999999e-08A 83.25us 8.59374999999999e-08A 86.58us 8.59374999999999e-08A 89.91us 8.59374999999999e-08A 93.24000000000001us 8.59374999999999e-08A 96.57000000000001us 8.59374999999999e-08A 99.9us 8.59374999999999e-08A)
R_10_6_2_1 Node10_6_2 Node10_6_3 7976.744186046519
R_10_6_2_2 Node10_6_2 Node10_7_2 6066.66666666667
R_10_6_2_3 Node10_6_2 Node11_6_2 0.44800000000000045
C_10_6_2 Node10_6_2 GND 2.481445312499998e-09
I_10_6_3 GND Node10_6_3 PWL(0s 0A 3.33us 6.718749999999994e-08A 6.66us 6.718749999999994e-08A 9.99us 6.718749999999994e-08A 13.32us 6.718749999999994e-08A 16.65us 6.718749999999994e-08A 19.98us 6.718749999999994e-08A 23.310000000000002us 6.718749999999994e-08A 26.64us 6.718749999999994e-08A 29.97us 6.718749999999994e-08A 33.3us 6.718749999999994e-08A 36.63us 6.718749999999994e-08A 39.96us 6.718749999999994e-08A 43.29us 6.718749999999994e-08A 46.620000000000005us 6.718749999999994e-08A 49.95us 6.718749999999994e-08A 53.28us 6.718749999999994e-08A 56.61us 6.718749999999994e-08A 59.94us 6.718749999999994e-08A 63.27us 6.718749999999994e-08A 66.6us 6.718749999999994e-08A 69.93us 6.718749999999994e-08A 73.26us 6.718749999999994e-08A 76.59us 6.718749999999994e-08A 79.92us 6.718749999999994e-08A 83.25us 6.718749999999994e-08A 86.58us 6.718749999999994e-08A 89.91us 6.718749999999994e-08A 93.24000000000001us 6.718749999999994e-08A 96.57000000000001us 6.718749999999994e-08A 99.9us 6.718749999999994e-08A)
R_10_6_3_1 Node10_6_3 Node10_6_4 9289.244186046519
R_10_6_3_2 Node10_6_3 Node10_7_3 7976.744186046515
R_10_6_3_3 Node10_6_3 Node11_6_3 0.573023255813954
C_10_6_3 Node10_6_3 GND 1.9400390624999985e-09
I_10_6_4 GND Node10_6_4 PWL(0s 0A 3.33us 6.249999999999996e-08A 6.66us 6.249999999999996e-08A 9.99us 6.249999999999996e-08A 13.32us 6.249999999999996e-08A 16.65us 6.249999999999996e-08A 19.98us 6.249999999999996e-08A 23.310000000000002us 6.249999999999996e-08A 26.64us 6.249999999999996e-08A 29.97us 6.249999999999996e-08A 33.3us 6.249999999999996e-08A 36.63us 6.249999999999996e-08A 39.96us 6.249999999999996e-08A 43.29us 6.249999999999996e-08A 46.620000000000005us 6.249999999999996e-08A 49.95us 6.249999999999996e-08A 53.28us 6.249999999999996e-08A 56.61us 6.249999999999996e-08A 59.94us 6.249999999999996e-08A 63.27us 6.249999999999996e-08A 66.6us 6.249999999999996e-08A 69.93us 6.249999999999996e-08A 73.26us 6.249999999999996e-08A 76.59us 6.249999999999996e-08A 79.92us 6.249999999999996e-08A 83.25us 6.249999999999996e-08A 86.58us 6.249999999999996e-08A 89.91us 6.249999999999996e-08A 93.24000000000001us 6.249999999999996e-08A 96.57000000000001us 6.249999999999996e-08A 99.9us 6.249999999999996e-08A)
R_10_6_4_1 Node10_6_4 Node10_6_5 9625.000000000007
R_10_6_4_2 Node10_6_4 Node10_7_4 8662.500000000004
R_10_6_4_3 Node10_6_4 Node11_6_4 0.6160000000000005
C_10_6_4 Node10_6_4 GND 1.8046874999999987e-09
I_10_6_5 GND Node10_6_5 PWL(0s 0A 3.33us 6.249999999999996e-08A 6.66us 6.249999999999996e-08A 9.99us 6.249999999999996e-08A 13.32us 6.249999999999996e-08A 16.65us 6.249999999999996e-08A 19.98us 6.249999999999996e-08A 23.310000000000002us 6.249999999999996e-08A 26.64us 6.249999999999996e-08A 29.97us 6.249999999999996e-08A 33.3us 6.249999999999996e-08A 36.63us 6.249999999999996e-08A 39.96us 6.249999999999996e-08A 43.29us 6.249999999999996e-08A 46.620000000000005us 6.249999999999996e-08A 49.95us 6.249999999999996e-08A 53.28us 6.249999999999996e-08A 56.61us 6.249999999999996e-08A 59.94us 6.249999999999996e-08A 63.27us 6.249999999999996e-08A 66.6us 6.249999999999996e-08A 69.93us 6.249999999999996e-08A 73.26us 6.249999999999996e-08A 76.59us 6.249999999999996e-08A 79.92us 6.249999999999996e-08A 83.25us 6.249999999999996e-08A 86.58us 6.249999999999996e-08A 89.91us 6.249999999999996e-08A 93.24000000000001us 6.249999999999996e-08A 96.57000000000001us 6.249999999999996e-08A 99.9us 6.249999999999996e-08A)
R_10_6_5_1 Node10_6_5 Node10_6_6 13562.5
R_10_6_5_2 Node10_6_5 Node10_7_5 8662.500000000004
R_10_6_5_3 Node10_6_5 Node11_6_5 0.6160000000000005
C_10_6_5 Node10_6_5 GND 1.8046874999999987e-09
I_10_6_6 GND Node10_6_6 PWL(0s 0A 3.33us 3.4375000000000015e-08A 6.66us 3.4375000000000015e-08A 9.99us 3.4375000000000015e-08A 13.32us 3.4375000000000015e-08A 16.65us 3.4375000000000015e-08A 19.98us 3.4375000000000015e-08A 23.310000000000002us 3.4375000000000015e-08A 26.64us 3.4375000000000015e-08A 29.97us 3.4375000000000015e-08A 33.3us 3.4375000000000015e-08A 36.63us 3.4375000000000015e-08A 39.96us 3.4375000000000015e-08A 43.29us 3.4375000000000015e-08A 46.620000000000005us 3.4375000000000015e-08A 49.95us 3.4375000000000015e-08A 53.28us 3.4375000000000015e-08A 56.61us 3.4375000000000015e-08A 59.94us 3.4375000000000015e-08A 63.27us 3.4375000000000015e-08A 66.6us 3.4375000000000015e-08A 69.93us 3.4375000000000015e-08A 73.26us 3.4375000000000015e-08A 76.59us 3.4375000000000015e-08A 79.92us 3.4375000000000015e-08A 83.25us 3.4375000000000015e-08A 86.58us 3.4375000000000015e-08A 89.91us 3.4375000000000015e-08A 93.24000000000001us 3.4375000000000015e-08A 96.57000000000001us 3.4375000000000015e-08A 99.9us 3.4375000000000015e-08A)
R_10_6_6_1 Node10_6_6 Node10_6_7 27999.99999999995
R_10_6_6_2 Node10_6_6 Node10_7_6 18374.999999999993
R_10_6_6_3 Node10_6_6 Node11_6_6 1.1199999999999994
C_10_6_6 Node10_6_6 GND 9.925781250000005e-10
I_10_6_7 GND Node10_6_7 PWL(0s 0A 3.33us 1.5625000000000036e-08A 6.66us 1.5625000000000036e-08A 9.99us 1.5625000000000036e-08A 13.32us 1.5625000000000036e-08A 16.65us 1.5625000000000036e-08A 19.98us 1.5625000000000036e-08A 23.310000000000002us 1.5625000000000036e-08A 26.64us 1.5625000000000036e-08A 29.97us 1.5625000000000036e-08A 33.3us 1.5625000000000036e-08A 36.63us 1.5625000000000036e-08A 39.96us 1.5625000000000036e-08A 43.29us 1.5625000000000036e-08A 46.620000000000005us 1.5625000000000036e-08A 49.95us 1.5625000000000036e-08A 53.28us 1.5625000000000036e-08A 56.61us 1.5625000000000036e-08A 59.94us 1.5625000000000036e-08A 63.27us 1.5625000000000036e-08A 66.6us 1.5625000000000036e-08A 69.93us 1.5625000000000036e-08A 73.26us 1.5625000000000036e-08A 76.59us 1.5625000000000036e-08A 79.92us 1.5625000000000036e-08A 83.25us 1.5625000000000036e-08A 86.58us 1.5625000000000036e-08A 89.91us 1.5625000000000036e-08A 93.24000000000001us 1.5625000000000036e-08A 96.57000000000001us 1.5625000000000036e-08A 99.9us 1.5625000000000036e-08A)
R_10_6_7_1 Node10_6_7 Node10_6_8 38499.999999999905
R_10_6_7_2 Node10_6_7 Node10_7_7 19250.000000499953
R_10_6_7_3 Node10_6_7 Node11_6_7 2.4639999999999938
C_10_6_7 Node10_6_7 GND 4.511718750000011e-10
I_10_6_8 GND Node10_6_8 PWL(0s 0A 3.33us 1.5625000000000036e-08A 6.66us 1.5625000000000036e-08A 9.99us 1.5625000000000036e-08A 13.32us 1.5625000000000036e-08A 16.65us 1.5625000000000036e-08A 19.98us 1.5625000000000036e-08A 23.310000000000002us 1.5625000000000036e-08A 26.64us 1.5625000000000036e-08A 29.97us 1.5625000000000036e-08A 33.3us 1.5625000000000036e-08A 36.63us 1.5625000000000036e-08A 39.96us 1.5625000000000036e-08A 43.29us 1.5625000000000036e-08A 46.620000000000005us 1.5625000000000036e-08A 49.95us 1.5625000000000036e-08A 53.28us 1.5625000000000036e-08A 56.61us 1.5625000000000036e-08A 59.94us 1.5625000000000036e-08A 63.27us 1.5625000000000036e-08A 66.6us 1.5625000000000036e-08A 69.93us 1.5625000000000036e-08A 73.26us 1.5625000000000036e-08A 76.59us 1.5625000000000036e-08A 79.92us 1.5625000000000036e-08A 83.25us 1.5625000000000036e-08A 86.58us 1.5625000000000036e-08A 89.91us 1.5625000000000036e-08A 93.24000000000001us 1.5625000000000036e-08A 96.57000000000001us 1.5625000000000036e-08A 99.9us 1.5625000000000036e-08A)
R_10_6_8_1 Node10_6_8 Node10_6_9 38499.999999999905
R_10_6_8_2 Node10_6_8 Node10_7_8 19250.000000499953
R_10_6_8_3 Node10_6_8 Node11_6_8 2.4639999999999938
C_10_6_8 Node10_6_8 GND 4.511718750000011e-10
I_10_6_9 GND Node10_6_9 PWL(0s 0A 3.33us 1.5625000000000036e-08A 6.66us 1.5625000000000036e-08A 9.99us 1.5625000000000036e-08A 13.32us 1.5625000000000036e-08A 16.65us 1.5625000000000036e-08A 19.98us 1.5625000000000036e-08A 23.310000000000002us 1.5625000000000036e-08A 26.64us 1.5625000000000036e-08A 29.97us 1.5625000000000036e-08A 33.3us 1.5625000000000036e-08A 36.63us 1.5625000000000036e-08A 39.96us 1.5625000000000036e-08A 43.29us 1.5625000000000036e-08A 46.620000000000005us 1.5625000000000036e-08A 49.95us 1.5625000000000036e-08A 53.28us 1.5625000000000036e-08A 56.61us 1.5625000000000036e-08A 59.94us 1.5625000000000036e-08A 63.27us 1.5625000000000036e-08A 66.6us 1.5625000000000036e-08A 69.93us 1.5625000000000036e-08A 73.26us 1.5625000000000036e-08A 76.59us 1.5625000000000036e-08A 79.92us 1.5625000000000036e-08A 83.25us 1.5625000000000036e-08A 86.58us 1.5625000000000036e-08A 89.91us 1.5625000000000036e-08A 93.24000000000001us 1.5625000000000036e-08A 96.57000000000001us 1.5625000000000036e-08A 99.9us 1.5625000000000036e-08A)
R_10_6_9_1 Node10_6_9 Node10_6_10 38499.999999999905
R_10_6_9_2 Node10_6_9 Node10_7_9 19250.000000499953
R_10_6_9_3 Node10_6_9 Node11_6_9 2.4639999999999938
C_10_6_9 Node10_6_9 GND 4.511718750000011e-10
I_10_6_10 GND Node10_6_10 PWL(0s 0A 3.33us 1.5625000000000036e-08A 6.66us 1.5625000000000036e-08A 9.99us 1.5625000000000036e-08A 13.32us 1.5625000000000036e-08A 16.65us 1.5625000000000036e-08A 19.98us 1.5625000000000036e-08A 23.310000000000002us 1.5625000000000036e-08A 26.64us 1.5625000000000036e-08A 29.97us 1.5625000000000036e-08A 33.3us 1.5625000000000036e-08A 36.63us 1.5625000000000036e-08A 39.96us 1.5625000000000036e-08A 43.29us 1.5625000000000036e-08A 46.620000000000005us 1.5625000000000036e-08A 49.95us 1.5625000000000036e-08A 53.28us 1.5625000000000036e-08A 56.61us 1.5625000000000036e-08A 59.94us 1.5625000000000036e-08A 63.27us 1.5625000000000036e-08A 66.6us 1.5625000000000036e-08A 69.93us 1.5625000000000036e-08A 73.26us 1.5625000000000036e-08A 76.59us 1.5625000000000036e-08A 79.92us 1.5625000000000036e-08A 83.25us 1.5625000000000036e-08A 86.58us 1.5625000000000036e-08A 89.91us 1.5625000000000036e-08A 93.24000000000001us 1.5625000000000036e-08A 96.57000000000001us 1.5625000000000036e-08A 99.9us 1.5625000000000036e-08A)
R_10_6_10_1 Node10_6_10 Node10_6_11 38499.999999999905
R_10_6_10_2 Node10_6_10 Node10_7_10 19250.000000499953
R_10_6_10_3 Node10_6_10 Node11_6_10 2.4639999999999938
C_10_6_10 Node10_6_10 GND 4.511718750000011e-10
I_10_6_11 GND Node10_6_11 PWL(0s 0A 3.33us 1.5625000000000036e-08A 6.66us 1.5625000000000036e-08A 9.99us 1.5625000000000036e-08A 13.32us 1.5625000000000036e-08A 16.65us 1.5625000000000036e-08A 19.98us 1.5625000000000036e-08A 23.310000000000002us 1.5625000000000036e-08A 26.64us 1.5625000000000036e-08A 29.97us 1.5625000000000036e-08A 33.3us 1.5625000000000036e-08A 36.63us 1.5625000000000036e-08A 39.96us 1.5625000000000036e-08A 43.29us 1.5625000000000036e-08A 46.620000000000005us 1.5625000000000036e-08A 49.95us 1.5625000000000036e-08A 53.28us 1.5625000000000036e-08A 56.61us 1.5625000000000036e-08A 59.94us 1.5625000000000036e-08A 63.27us 1.5625000000000036e-08A 66.6us 1.5625000000000036e-08A 69.93us 1.5625000000000036e-08A 73.26us 1.5625000000000036e-08A 76.59us 1.5625000000000036e-08A 79.92us 1.5625000000000036e-08A 83.25us 1.5625000000000036e-08A 86.58us 1.5625000000000036e-08A 89.91us 1.5625000000000036e-08A 93.24000000000001us 1.5625000000000036e-08A 96.57000000000001us 1.5625000000000036e-08A 99.9us 1.5625000000000036e-08A)
R_10_6_11_1 Node10_6_11 Node10_6_12 38499.999999999905
R_10_6_11_2 Node10_6_11 Node10_7_11 19250.000000499953
R_10_6_11_3 Node10_6_11 Node11_6_11 2.4639999999999938
C_10_6_11 Node10_6_11 GND 4.511718750000011e-10
I_10_6_12 GND Node10_6_12 PWL(0s 0A 3.33us 1.5625000000000036e-08A 6.66us 1.5625000000000036e-08A 9.99us 1.5625000000000036e-08A 13.32us 1.5625000000000036e-08A 16.65us 1.5625000000000036e-08A 19.98us 1.5625000000000036e-08A 23.310000000000002us 1.5625000000000036e-08A 26.64us 1.5625000000000036e-08A 29.97us 1.5625000000000036e-08A 33.3us 1.5625000000000036e-08A 36.63us 1.5625000000000036e-08A 39.96us 1.5625000000000036e-08A 43.29us 1.5625000000000036e-08A 46.620000000000005us 1.5625000000000036e-08A 49.95us 1.5625000000000036e-08A 53.28us 1.5625000000000036e-08A 56.61us 1.5625000000000036e-08A 59.94us 1.5625000000000036e-08A 63.27us 1.5625000000000036e-08A 66.6us 1.5625000000000036e-08A 69.93us 1.5625000000000036e-08A 73.26us 1.5625000000000036e-08A 76.59us 1.5625000000000036e-08A 79.92us 1.5625000000000036e-08A 83.25us 1.5625000000000036e-08A 86.58us 1.5625000000000036e-08A 89.91us 1.5625000000000036e-08A 93.24000000000001us 1.5625000000000036e-08A 96.57000000000001us 1.5625000000000036e-08A 99.9us 1.5625000000000036e-08A)
R_10_6_12_1 Node10_6_12 Node10_6_13 38499.999999999905
R_10_6_12_2 Node10_6_12 Node10_7_12 19250.000000499953
R_10_6_12_3 Node10_6_12 Node11_6_12 2.4639999999999938
C_10_6_12 Node10_6_12 GND 4.511718750000011e-10
I_10_6_13 GND Node10_6_13 PWL(0s 0A 3.33us 1.5625000000000036e-08A 6.66us 1.5625000000000036e-08A 9.99us 1.5625000000000036e-08A 13.32us 1.5625000000000036e-08A 16.65us 1.5625000000000036e-08A 19.98us 1.5625000000000036e-08A 23.310000000000002us 1.5625000000000036e-08A 26.64us 1.5625000000000036e-08A 29.97us 1.5625000000000036e-08A 33.3us 1.5625000000000036e-08A 36.63us 1.5625000000000036e-08A 39.96us 1.5625000000000036e-08A 43.29us 1.5625000000000036e-08A 46.620000000000005us 1.5625000000000036e-08A 49.95us 1.5625000000000036e-08A 53.28us 1.5625000000000036e-08A 56.61us 1.5625000000000036e-08A 59.94us 1.5625000000000036e-08A 63.27us 1.5625000000000036e-08A 66.6us 1.5625000000000036e-08A 69.93us 1.5625000000000036e-08A 73.26us 1.5625000000000036e-08A 76.59us 1.5625000000000036e-08A 79.92us 1.5625000000000036e-08A 83.25us 1.5625000000000036e-08A 86.58us 1.5625000000000036e-08A 89.91us 1.5625000000000036e-08A 93.24000000000001us 1.5625000000000036e-08A 96.57000000000001us 1.5625000000000036e-08A 99.9us 1.5625000000000036e-08A)
R_10_6_13_1 Node10_6_13 Node10_6_14 38499.999999999905
R_10_6_13_2 Node10_6_13 Node10_7_13 19250.000000499953
R_10_6_13_3 Node10_6_13 Node11_6_13 2.4639999999999938
C_10_6_13 Node10_6_13 GND 4.511718750000011e-10
I_10_6_14 GND Node10_6_14 PWL(0s 0A 3.33us 1.5625000000000036e-08A 6.66us 1.5625000000000036e-08A 9.99us 1.5625000000000036e-08A 13.32us 1.5625000000000036e-08A 16.65us 1.5625000000000036e-08A 19.98us 1.5625000000000036e-08A 23.310000000000002us 1.5625000000000036e-08A 26.64us 1.5625000000000036e-08A 29.97us 1.5625000000000036e-08A 33.3us 1.5625000000000036e-08A 36.63us 1.5625000000000036e-08A 39.96us 1.5625000000000036e-08A 43.29us 1.5625000000000036e-08A 46.620000000000005us 1.5625000000000036e-08A 49.95us 1.5625000000000036e-08A 53.28us 1.5625000000000036e-08A 56.61us 1.5625000000000036e-08A 59.94us 1.5625000000000036e-08A 63.27us 1.5625000000000036e-08A 66.6us 1.5625000000000036e-08A 69.93us 1.5625000000000036e-08A 73.26us 1.5625000000000036e-08A 76.59us 1.5625000000000036e-08A 79.92us 1.5625000000000036e-08A 83.25us 1.5625000000000036e-08A 86.58us 1.5625000000000036e-08A 89.91us 1.5625000000000036e-08A 93.24000000000001us 1.5625000000000036e-08A 96.57000000000001us 1.5625000000000036e-08A 99.9us 1.5625000000000036e-08A)
R_10_6_14_1 Node10_6_14 Node10_6_15 38499.99999999988
R_10_6_14_2 Node10_6_14 Node10_7_14 19250.000000499953
R_10_6_14_3 Node10_6_14 Node11_6_14 2.4639999999999938
C_10_6_14 Node10_6_14 GND 4.511718750000011e-10
I_10_6_15 GND Node10_6_15 PWL(0s 0A 3.33us 1.5625000000000052e-08A 6.66us 1.5625000000000052e-08A 9.99us 1.5625000000000052e-08A 13.32us 1.5625000000000052e-08A 16.65us 1.5625000000000052e-08A 19.98us 1.5625000000000052e-08A 23.310000000000002us 1.5625000000000052e-08A 26.64us 1.5625000000000052e-08A 29.97us 1.5625000000000052e-08A 33.3us 1.5625000000000052e-08A 36.63us 1.5625000000000052e-08A 39.96us 1.5625000000000052e-08A 43.29us 1.5625000000000052e-08A 46.620000000000005us 1.5625000000000052e-08A 49.95us 1.5625000000000052e-08A 53.28us 1.5625000000000052e-08A 56.61us 1.5625000000000052e-08A 59.94us 1.5625000000000052e-08A 63.27us 1.5625000000000052e-08A 66.6us 1.5625000000000052e-08A 69.93us 1.5625000000000052e-08A 73.26us 1.5625000000000052e-08A 76.59us 1.5625000000000052e-08A 79.92us 1.5625000000000052e-08A 83.25us 1.5625000000000052e-08A 86.58us 1.5625000000000052e-08A 89.91us 1.5625000000000052e-08A 93.24000000000001us 1.5625000000000052e-08A 96.57000000000001us 1.5625000000000052e-08A 99.9us 1.5625000000000052e-08A)
R_10_6_15_2 Node10_6_15 Node10_7_15 19250.00000049993
R_10_6_15_3 Node10_6_15 Node11_6_15 2.4639999999999915
C_10_6_15 Node10_6_15 GND 4.511718750000016e-10
I_10_7_0 GND Node10_7_0 PWL(0s 0A 3.33us 1.1718749999999999e-07A 6.66us 1.1718749999999999e-07A 9.99us 1.1718749999999999e-07A 13.32us 1.1718749999999999e-07A 16.65us 1.1718749999999999e-07A 19.98us 1.1718749999999999e-07A 23.310000000000002us 1.1718749999999999e-07A 26.64us 1.1718749999999999e-07A 29.97us 1.1718749999999999e-07A 33.3us 1.1718749999999999e-07A 36.63us 1.1718749999999999e-07A 39.96us 1.1718749999999999e-07A 43.29us 1.1718749999999999e-07A 46.620000000000005us 1.1718749999999999e-07A 49.95us 1.1718749999999999e-07A 53.28us 1.1718749999999999e-07A 56.61us 1.1718749999999999e-07A 59.94us 1.1718749999999999e-07A 63.27us 1.1718749999999999e-07A 66.6us 1.1718749999999999e-07A 69.93us 1.1718749999999999e-07A 73.26us 1.1718749999999999e-07A 76.59us 1.1718749999999999e-07A 79.92us 1.1718749999999999e-07A 83.25us 1.1718749999999999e-07A 86.58us 1.1718749999999999e-07A 89.91us 1.1718749999999999e-07A 93.24000000000001us 1.1718749999999999e-07A 96.57000000000001us 1.1718749999999999e-07A 99.9us 1.1718749999999999e-07A)
R_10_7_0_1 Node10_7_0 Node10_7_1 5133.333333333333
R_10_7_0_2 Node10_7_0 Node10_8_0 5133.333333333333
R_10_7_0_3 Node10_7_0 Node11_7_0 0.32853333333333334
C_10_7_0 Node10_7_0 GND 3.3837890625e-09
I_10_7_1 GND Node10_7_1 PWL(0s 0A 3.33us 1.1718749999999999e-07A 6.66us 1.1718749999999999e-07A 9.99us 1.1718749999999999e-07A 13.32us 1.1718749999999999e-07A 16.65us 1.1718749999999999e-07A 19.98us 1.1718749999999999e-07A 23.310000000000002us 1.1718749999999999e-07A 26.64us 1.1718749999999999e-07A 29.97us 1.1718749999999999e-07A 33.3us 1.1718749999999999e-07A 36.63us 1.1718749999999999e-07A 39.96us 1.1718749999999999e-07A 43.29us 1.1718749999999999e-07A 46.620000000000005us 1.1718749999999999e-07A 49.95us 1.1718749999999999e-07A 53.28us 1.1718749999999999e-07A 56.61us 1.1718749999999999e-07A 59.94us 1.1718749999999999e-07A 63.27us 1.1718749999999999e-07A 66.6us 1.1718749999999999e-07A 69.93us 1.1718749999999999e-07A 73.26us 1.1718749999999999e-07A 76.59us 1.1718749999999999e-07A 79.92us 1.1718749999999999e-07A 83.25us 1.1718749999999999e-07A 86.58us 1.1718749999999999e-07A 89.91us 1.1718749999999999e-07A 93.24000000000001us 1.1718749999999999e-07A 96.57000000000001us 1.1718749999999999e-07A 99.9us 1.1718749999999999e-07A)
R_10_7_1_1 Node10_7_1 Node10_7_2 5133.333333333333
R_10_7_1_2 Node10_7_1 Node10_8_1 5133.333333333333
R_10_7_1_3 Node10_7_1 Node11_7_1 0.32853333333333334
C_10_7_1 Node10_7_1 GND 3.3837890625e-09
I_10_7_2 GND Node10_7_2 PWL(0s 0A 3.33us 1.1718749999999999e-07A 6.66us 1.1718749999999999e-07A 9.99us 1.1718749999999999e-07A 13.32us 1.1718749999999999e-07A 16.65us 1.1718749999999999e-07A 19.98us 1.1718749999999999e-07A 23.310000000000002us 1.1718749999999999e-07A 26.64us 1.1718749999999999e-07A 29.97us 1.1718749999999999e-07A 33.3us 1.1718749999999999e-07A 36.63us 1.1718749999999999e-07A 39.96us 1.1718749999999999e-07A 43.29us 1.1718749999999999e-07A 46.620000000000005us 1.1718749999999999e-07A 49.95us 1.1718749999999999e-07A 53.28us 1.1718749999999999e-07A 56.61us 1.1718749999999999e-07A 59.94us 1.1718749999999999e-07A 63.27us 1.1718749999999999e-07A 66.6us 1.1718749999999999e-07A 69.93us 1.1718749999999999e-07A 73.26us 1.1718749999999999e-07A 76.59us 1.1718749999999999e-07A 79.92us 1.1718749999999999e-07A 83.25us 1.1718749999999999e-07A 86.58us 1.1718749999999999e-07A 89.91us 1.1718749999999999e-07A 93.24000000000001us 1.1718749999999999e-07A 96.57000000000001us 1.1718749999999999e-07A 99.9us 1.1718749999999999e-07A)
R_10_7_2_1 Node10_7_2 Node10_7_3 6066.666666666666
R_10_7_2_2 Node10_7_2 Node10_8_2 5133.333333333333
R_10_7_2_3 Node10_7_2 Node11_7_2 0.32853333333333334
C_10_7_2 Node10_7_2 GND 3.3837890625e-09
I_10_7_3 GND Node10_7_3 PWL(0s 0A 3.33us 8.59375e-08A 6.66us 8.59375e-08A 9.99us 8.59375e-08A 13.32us 8.59375e-08A 16.65us 8.59375e-08A 19.98us 8.59375e-08A 23.310000000000002us 8.59375e-08A 26.64us 8.59375e-08A 29.97us 8.59375e-08A 33.3us 8.59375e-08A 36.63us 8.59375e-08A 39.96us 8.59375e-08A 43.29us 8.59375e-08A 46.620000000000005us 8.59375e-08A 49.95us 8.59375e-08A 53.28us 8.59375e-08A 56.61us 8.59375e-08A 59.94us 8.59375e-08A 63.27us 8.59375e-08A 66.6us 8.59375e-08A 69.93us 8.59375e-08A 73.26us 8.59375e-08A 76.59us 8.59375e-08A 79.92us 8.59375e-08A 83.25us 8.59375e-08A 86.58us 8.59375e-08A 89.91us 8.59375e-08A 93.24000000000001us 8.59375e-08A 96.57000000000001us 8.59375e-08A 99.9us 8.59375e-08A)
R_10_7_3_1 Node10_7_3 Node10_7_4 7350.0
R_10_7_3_2 Node10_7_3 Node10_8_3 6999.999999999999
R_10_7_3_3 Node10_7_3 Node11_7_3 0.44800000000000006
C_10_7_3 Node10_7_3 GND 2.4814453125e-09
I_10_7_4 GND Node10_7_4 PWL(0s 0A 3.33us 7.812499999999999e-08A 6.66us 7.812499999999999e-08A 9.99us 7.812499999999999e-08A 13.32us 7.812499999999999e-08A 16.65us 7.812499999999999e-08A 19.98us 7.812499999999999e-08A 23.310000000000002us 7.812499999999999e-08A 26.64us 7.812499999999999e-08A 29.97us 7.812499999999999e-08A 33.3us 7.812499999999999e-08A 36.63us 7.812499999999999e-08A 39.96us 7.812499999999999e-08A 43.29us 7.812499999999999e-08A 46.620000000000005us 7.812499999999999e-08A 49.95us 7.812499999999999e-08A 53.28us 7.812499999999999e-08A 56.61us 7.812499999999999e-08A 59.94us 7.812499999999999e-08A 63.27us 7.812499999999999e-08A 66.6us 7.812499999999999e-08A 69.93us 7.812499999999999e-08A 73.26us 7.812499999999999e-08A 76.59us 7.812499999999999e-08A 79.92us 7.812499999999999e-08A 83.25us 7.812499999999999e-08A 86.58us 7.812499999999999e-08A 89.91us 7.812499999999999e-08A 93.24000000000001us 7.812499999999999e-08A 96.57000000000001us 7.812499999999999e-08A 99.9us 7.812499999999999e-08A)
R_10_7_4_1 Node10_7_4 Node10_7_5 7700.0
R_10_7_4_2 Node10_7_4 Node10_8_4 7700.0
R_10_7_4_3 Node10_7_4 Node11_7_4 0.49280000000000007
C_10_7_4 Node10_7_4 GND 2.255859375e-09
I_10_7_5 GND Node10_7_5 PWL(0s 0A 3.33us 7.812499999999999e-08A 6.66us 7.812499999999999e-08A 9.99us 7.812499999999999e-08A 13.32us 7.812499999999999e-08A 16.65us 7.812499999999999e-08A 19.98us 7.812499999999999e-08A 23.310000000000002us 7.812499999999999e-08A 26.64us 7.812499999999999e-08A 29.97us 7.812499999999999e-08A 33.3us 7.812499999999999e-08A 36.63us 7.812499999999999e-08A 39.96us 7.812499999999999e-08A 43.29us 7.812499999999999e-08A 46.620000000000005us 7.812499999999999e-08A 49.95us 7.812499999999999e-08A 53.28us 7.812499999999999e-08A 56.61us 7.812499999999999e-08A 59.94us 7.812499999999999e-08A 63.27us 7.812499999999999e-08A 66.6us 7.812499999999999e-08A 69.93us 7.812499999999999e-08A 73.26us 7.812499999999999e-08A 76.59us 7.812499999999999e-08A 79.92us 7.812499999999999e-08A 83.25us 7.812499999999999e-08A 86.58us 7.812499999999999e-08A 89.91us 7.812499999999999e-08A 93.24000000000001us 7.812499999999999e-08A 96.57000000000001us 7.812499999999999e-08A 99.9us 7.812499999999999e-08A)
R_10_7_5_1 Node10_7_5 Node10_7_6 13474.999999999996
R_10_7_5_2 Node10_7_5 Node10_8_5 7700.0
R_10_7_5_3 Node10_7_5 Node11_7_5 0.49280000000000007
C_10_7_5 Node10_7_5 GND 2.255859375e-09
I_10_7_6 GND Node10_7_6 PWL(0s 0A 3.33us 3.125000000000001e-08A 6.66us 3.125000000000001e-08A 9.99us 3.125000000000001e-08A 13.32us 3.125000000000001e-08A 16.65us 3.125000000000001e-08A 19.98us 3.125000000000001e-08A 23.310000000000002us 3.125000000000001e-08A 26.64us 3.125000000000001e-08A 29.97us 3.125000000000001e-08A 33.3us 3.125000000000001e-08A 36.63us 3.125000000000001e-08A 39.96us 3.125000000000001e-08A 43.29us 3.125000000000001e-08A 46.620000000000005us 3.125000000000001e-08A 49.95us 3.125000000000001e-08A 53.28us 3.125000000000001e-08A 56.61us 3.125000000000001e-08A 59.94us 3.125000000000001e-08A 63.27us 3.125000000000001e-08A 66.6us 3.125000000000001e-08A 69.93us 3.125000000000001e-08A 73.26us 3.125000000000001e-08A 76.59us 3.125000000000001e-08A 79.92us 3.125000000000001e-08A 83.25us 3.125000000000001e-08A 86.58us 3.125000000000001e-08A 89.91us 3.125000000000001e-08A 93.24000000000001us 3.125000000000001e-08A 96.57000000000001us 3.125000000000001e-08A 99.9us 3.125000000000001e-08A)
R_10_7_6_1 Node10_7_6 Node10_7_7 9625.000000499997
R_10_7_6_2 Node10_7_6 Node10_8_6 19249.999999999993
R_10_7_6_3 Node10_7_6 Node11_7_6 1.2319999999999995
C_10_7_6 Node10_7_6 GND 9.023437500000004e-10
R_10_7_7_1 Node10_7_7 Node10_7_8 1e-06
R_10_7_7_2 Node10_7_7 Node10_8_7 1e-06
R_10_7_7_3 Node10_7_7 Node11_7_7 1e-06
C_10_7_7 Node10_7_7 GND 0.0
R_10_7_8_1 Node10_7_8 Node10_7_9 1e-06
R_10_7_8_2 Node10_7_8 Node10_8_8 1e-06
R_10_7_8_3 Node10_7_8 Node11_7_8 1e-06
C_10_7_8 Node10_7_8 GND 0.0
R_10_7_9_1 Node10_7_9 Node10_7_10 1e-06
R_10_7_9_2 Node10_7_9 Node10_8_9 1e-06
R_10_7_9_3 Node10_7_9 Node11_7_9 1e-06
C_10_7_9 Node10_7_9 GND 0.0
R_10_7_10_1 Node10_7_10 Node10_7_11 1e-06
R_10_7_10_2 Node10_7_10 Node10_8_10 1e-06
R_10_7_10_3 Node10_7_10 Node11_7_10 1e-06
C_10_7_10 Node10_7_10 GND 0.0
R_10_7_11_1 Node10_7_11 Node10_7_12 1e-06
R_10_7_11_2 Node10_7_11 Node10_8_11 1e-06
R_10_7_11_3 Node10_7_11 Node11_7_11 1e-06
C_10_7_11 Node10_7_11 GND 0.0
R_10_7_12_1 Node10_7_12 Node10_7_13 1e-06
R_10_7_12_2 Node10_7_12 Node10_8_12 1e-06
R_10_7_12_3 Node10_7_12 Node11_7_12 1e-06
C_10_7_12 Node10_7_12 GND 0.0
R_10_7_13_1 Node10_7_13 Node10_7_14 1e-06
R_10_7_13_2 Node10_7_13 Node10_8_13 1e-06
R_10_7_13_3 Node10_7_13 Node11_7_13 1e-06
C_10_7_13 Node10_7_13 GND 0.0
R_10_7_14_1 Node10_7_14 Node10_7_15 1e-06
R_10_7_14_2 Node10_7_14 Node10_8_14 1e-06
R_10_7_14_3 Node10_7_14 Node11_7_14 1e-06
C_10_7_14 Node10_7_14 GND 0.0
R_10_7_15_2 Node10_7_15 Node10_8_15 1e-06
R_10_7_15_3 Node10_7_15 Node11_7_15 1e-06
C_10_7_15 Node10_7_15 GND 0.0
I_10_8_0 GND Node10_8_0 PWL(0s 0A 3.33us 1.1718749999999999e-07A 6.66us 1.1718749999999999e-07A 9.99us 1.1718749999999999e-07A 13.32us 1.1718749999999999e-07A 16.65us 1.1718749999999999e-07A 19.98us 1.1718749999999999e-07A 23.310000000000002us 1.1718749999999999e-07A 26.64us 1.1718749999999999e-07A 29.97us 1.1718749999999999e-07A 33.3us 1.1718749999999999e-07A 36.63us 1.1718749999999999e-07A 39.96us 1.1718749999999999e-07A 43.29us 1.1718749999999999e-07A 46.620000000000005us 1.1718749999999999e-07A 49.95us 1.1718749999999999e-07A 53.28us 1.1718749999999999e-07A 56.61us 1.1718749999999999e-07A 59.94us 1.1718749999999999e-07A 63.27us 1.1718749999999999e-07A 66.6us 1.1718749999999999e-07A 69.93us 1.1718749999999999e-07A 73.26us 1.1718749999999999e-07A 76.59us 1.1718749999999999e-07A 79.92us 1.1718749999999999e-07A 83.25us 1.1718749999999999e-07A 86.58us 1.1718749999999999e-07A 89.91us 1.1718749999999999e-07A 93.24000000000001us 1.1718749999999999e-07A 96.57000000000001us 1.1718749999999999e-07A 99.9us 1.1718749999999999e-07A)
R_10_8_0_1 Node10_8_0 Node10_8_1 5133.333333333333
R_10_8_0_2 Node10_8_0 Node10_9_0 6066.666666666668
R_10_8_0_3 Node10_8_0 Node11_8_0 0.32853333333333334
C_10_8_0 Node10_8_0 GND 3.3837890625e-09
I_10_8_1 GND Node10_8_1 PWL(0s 0A 3.33us 1.1718749999999999e-07A 6.66us 1.1718749999999999e-07A 9.99us 1.1718749999999999e-07A 13.32us 1.1718749999999999e-07A 16.65us 1.1718749999999999e-07A 19.98us 1.1718749999999999e-07A 23.310000000000002us 1.1718749999999999e-07A 26.64us 1.1718749999999999e-07A 29.97us 1.1718749999999999e-07A 33.3us 1.1718749999999999e-07A 36.63us 1.1718749999999999e-07A 39.96us 1.1718749999999999e-07A 43.29us 1.1718749999999999e-07A 46.620000000000005us 1.1718749999999999e-07A 49.95us 1.1718749999999999e-07A 53.28us 1.1718749999999999e-07A 56.61us 1.1718749999999999e-07A 59.94us 1.1718749999999999e-07A 63.27us 1.1718749999999999e-07A 66.6us 1.1718749999999999e-07A 69.93us 1.1718749999999999e-07A 73.26us 1.1718749999999999e-07A 76.59us 1.1718749999999999e-07A 79.92us 1.1718749999999999e-07A 83.25us 1.1718749999999999e-07A 86.58us 1.1718749999999999e-07A 89.91us 1.1718749999999999e-07A 93.24000000000001us 1.1718749999999999e-07A 96.57000000000001us 1.1718749999999999e-07A 99.9us 1.1718749999999999e-07A)
R_10_8_1_1 Node10_8_1 Node10_8_2 5133.333333333333
R_10_8_1_2 Node10_8_1 Node10_9_1 6066.666666666668
R_10_8_1_3 Node10_8_1 Node11_8_1 0.32853333333333334
C_10_8_1 Node10_8_1 GND 3.3837890625e-09
I_10_8_2 GND Node10_8_2 PWL(0s 0A 3.33us 1.1718749999999999e-07A 6.66us 1.1718749999999999e-07A 9.99us 1.1718749999999999e-07A 13.32us 1.1718749999999999e-07A 16.65us 1.1718749999999999e-07A 19.98us 1.1718749999999999e-07A 23.310000000000002us 1.1718749999999999e-07A 26.64us 1.1718749999999999e-07A 29.97us 1.1718749999999999e-07A 33.3us 1.1718749999999999e-07A 36.63us 1.1718749999999999e-07A 39.96us 1.1718749999999999e-07A 43.29us 1.1718749999999999e-07A 46.620000000000005us 1.1718749999999999e-07A 49.95us 1.1718749999999999e-07A 53.28us 1.1718749999999999e-07A 56.61us 1.1718749999999999e-07A 59.94us 1.1718749999999999e-07A 63.27us 1.1718749999999999e-07A 66.6us 1.1718749999999999e-07A 69.93us 1.1718749999999999e-07A 73.26us 1.1718749999999999e-07A 76.59us 1.1718749999999999e-07A 79.92us 1.1718749999999999e-07A 83.25us 1.1718749999999999e-07A 86.58us 1.1718749999999999e-07A 89.91us 1.1718749999999999e-07A 93.24000000000001us 1.1718749999999999e-07A 96.57000000000001us 1.1718749999999999e-07A 99.9us 1.1718749999999999e-07A)
R_10_8_2_1 Node10_8_2 Node10_8_3 6066.666666666666
R_10_8_2_2 Node10_8_2 Node10_9_2 6066.666666666668
R_10_8_2_3 Node10_8_2 Node11_8_2 0.32853333333333334
C_10_8_2 Node10_8_2 GND 3.3837890625e-09
I_10_8_3 GND Node10_8_3 PWL(0s 0A 3.33us 8.59375e-08A 6.66us 8.59375e-08A 9.99us 8.59375e-08A 13.32us 8.59375e-08A 16.65us 8.59375e-08A 19.98us 8.59375e-08A 23.310000000000002us 8.59375e-08A 26.64us 8.59375e-08A 29.97us 8.59375e-08A 33.3us 8.59375e-08A 36.63us 8.59375e-08A 39.96us 8.59375e-08A 43.29us 8.59375e-08A 46.620000000000005us 8.59375e-08A 49.95us 8.59375e-08A 53.28us 8.59375e-08A 56.61us 8.59375e-08A 59.94us 8.59375e-08A 63.27us 8.59375e-08A 66.6us 8.59375e-08A 69.93us 8.59375e-08A 73.26us 8.59375e-08A 76.59us 8.59375e-08A 79.92us 8.59375e-08A 83.25us 8.59375e-08A 86.58us 8.59375e-08A 89.91us 8.59375e-08A 93.24000000000001us 8.59375e-08A 96.57000000000001us 8.59375e-08A 99.9us 8.59375e-08A)
R_10_8_3_1 Node10_8_3 Node10_8_4 7350.0
R_10_8_3_2 Node10_8_3 Node10_9_3 7976.744186046513
R_10_8_3_3 Node10_8_3 Node11_8_3 0.44800000000000006
C_10_8_3 Node10_8_3 GND 2.4814453125e-09
I_10_8_4 GND Node10_8_4 PWL(0s 0A 3.33us 7.812499999999999e-08A 6.66us 7.812499999999999e-08A 9.99us 7.812499999999999e-08A 13.32us 7.812499999999999e-08A 16.65us 7.812499999999999e-08A 19.98us 7.812499999999999e-08A 23.310000000000002us 7.812499999999999e-08A 26.64us 7.812499999999999e-08A 29.97us 7.812499999999999e-08A 33.3us 7.812499999999999e-08A 36.63us 7.812499999999999e-08A 39.96us 7.812499999999999e-08A 43.29us 7.812499999999999e-08A 46.620000000000005us 7.812499999999999e-08A 49.95us 7.812499999999999e-08A 53.28us 7.812499999999999e-08A 56.61us 7.812499999999999e-08A 59.94us 7.812499999999999e-08A 63.27us 7.812499999999999e-08A 66.6us 7.812499999999999e-08A 69.93us 7.812499999999999e-08A 73.26us 7.812499999999999e-08A 76.59us 7.812499999999999e-08A 79.92us 7.812499999999999e-08A 83.25us 7.812499999999999e-08A 86.58us 7.812499999999999e-08A 89.91us 7.812499999999999e-08A 93.24000000000001us 7.812499999999999e-08A 96.57000000000001us 7.812499999999999e-08A 99.9us 7.812499999999999e-08A)
R_10_8_4_1 Node10_8_4 Node10_8_5 7700.0
R_10_8_4_2 Node10_8_4 Node10_9_4 8662.500000000004
R_10_8_4_3 Node10_8_4 Node11_8_4 0.49280000000000007
C_10_8_4 Node10_8_4 GND 2.255859375e-09
I_10_8_5 GND Node10_8_5 PWL(0s 0A 3.33us 7.812499999999999e-08A 6.66us 7.812499999999999e-08A 9.99us 7.812499999999999e-08A 13.32us 7.812499999999999e-08A 16.65us 7.812499999999999e-08A 19.98us 7.812499999999999e-08A 23.310000000000002us 7.812499999999999e-08A 26.64us 7.812499999999999e-08A 29.97us 7.812499999999999e-08A 33.3us 7.812499999999999e-08A 36.63us 7.812499999999999e-08A 39.96us 7.812499999999999e-08A 43.29us 7.812499999999999e-08A 46.620000000000005us 7.812499999999999e-08A 49.95us 7.812499999999999e-08A 53.28us 7.812499999999999e-08A 56.61us 7.812499999999999e-08A 59.94us 7.812499999999999e-08A 63.27us 7.812499999999999e-08A 66.6us 7.812499999999999e-08A 69.93us 7.812499999999999e-08A 73.26us 7.812499999999999e-08A 76.59us 7.812499999999999e-08A 79.92us 7.812499999999999e-08A 83.25us 7.812499999999999e-08A 86.58us 7.812499999999999e-08A 89.91us 7.812499999999999e-08A 93.24000000000001us 7.812499999999999e-08A 96.57000000000001us 7.812499999999999e-08A 99.9us 7.812499999999999e-08A)
R_10_8_5_1 Node10_8_5 Node10_8_6 13474.999999999996
R_10_8_5_2 Node10_8_5 Node10_9_5 8662.500000000004
R_10_8_5_3 Node10_8_5 Node11_8_5 0.49280000000000007
C_10_8_5 Node10_8_5 GND 2.255859375e-09
I_10_8_6 GND Node10_8_6 PWL(0s 0A 3.33us 3.125000000000001e-08A 6.66us 3.125000000000001e-08A 9.99us 3.125000000000001e-08A 13.32us 3.125000000000001e-08A 16.65us 3.125000000000001e-08A 19.98us 3.125000000000001e-08A 23.310000000000002us 3.125000000000001e-08A 26.64us 3.125000000000001e-08A 29.97us 3.125000000000001e-08A 33.3us 3.125000000000001e-08A 36.63us 3.125000000000001e-08A 39.96us 3.125000000000001e-08A 43.29us 3.125000000000001e-08A 46.620000000000005us 3.125000000000001e-08A 49.95us 3.125000000000001e-08A 53.28us 3.125000000000001e-08A 56.61us 3.125000000000001e-08A 59.94us 3.125000000000001e-08A 63.27us 3.125000000000001e-08A 66.6us 3.125000000000001e-08A 69.93us 3.125000000000001e-08A 73.26us 3.125000000000001e-08A 76.59us 3.125000000000001e-08A 79.92us 3.125000000000001e-08A 83.25us 3.125000000000001e-08A 86.58us 3.125000000000001e-08A 89.91us 3.125000000000001e-08A 93.24000000000001us 3.125000000000001e-08A 96.57000000000001us 3.125000000000001e-08A 99.9us 3.125000000000001e-08A)
R_10_8_6_1 Node10_8_6 Node10_8_7 9625.000000499997
R_10_8_6_2 Node10_8_6 Node10_9_6 18375.000000000004
R_10_8_6_3 Node10_8_6 Node11_8_6 1.2319999999999995
C_10_8_6 Node10_8_6 GND 9.023437500000004e-10
R_10_8_7_1 Node10_8_7 Node10_8_8 1e-06
R_10_8_7_2 Node10_8_7 Node10_9_7 19250.000000500033
R_10_8_7_3 Node10_8_7 Node11_8_7 1e-06
C_10_8_7 Node10_8_7 GND 0.0
R_10_8_8_1 Node10_8_8 Node10_8_9 1e-06
R_10_8_8_2 Node10_8_8 Node10_9_8 19250.000000500033
R_10_8_8_3 Node10_8_8 Node11_8_8 1e-06
C_10_8_8 Node10_8_8 GND 0.0
R_10_8_9_1 Node10_8_9 Node10_8_10 1e-06
R_10_8_9_2 Node10_8_9 Node10_9_9 19250.000000500033
R_10_8_9_3 Node10_8_9 Node11_8_9 1e-06
C_10_8_9 Node10_8_9 GND 0.0
R_10_8_10_1 Node10_8_10 Node10_8_11 1e-06
R_10_8_10_2 Node10_8_10 Node10_9_10 19250.000000500033
R_10_8_10_3 Node10_8_10 Node11_8_10 1e-06
C_10_8_10 Node10_8_10 GND 0.0
R_10_8_11_1 Node10_8_11 Node10_8_12 1e-06
R_10_8_11_2 Node10_8_11 Node10_9_11 19250.000000500033
R_10_8_11_3 Node10_8_11 Node11_8_11 1e-06
C_10_8_11 Node10_8_11 GND 0.0
R_10_8_12_1 Node10_8_12 Node10_8_13 1e-06
R_10_8_12_2 Node10_8_12 Node10_9_12 19250.000000500033
R_10_8_12_3 Node10_8_12 Node11_8_12 1e-06
C_10_8_12 Node10_8_12 GND 0.0
R_10_8_13_1 Node10_8_13 Node10_8_14 1e-06
R_10_8_13_2 Node10_8_13 Node10_9_13 19250.000000500033
R_10_8_13_3 Node10_8_13 Node11_8_13 1e-06
C_10_8_13 Node10_8_13 GND 0.0
R_10_8_14_1 Node10_8_14 Node10_8_15 1e-06
R_10_8_14_2 Node10_8_14 Node10_9_14 19250.000000500033
R_10_8_14_3 Node10_8_14 Node11_8_14 1e-06
C_10_8_14 Node10_8_14 GND 0.0
R_10_8_15_2 Node10_8_15 Node10_9_15 19250.000000500015
R_10_8_15_3 Node10_8_15 Node11_8_15 1e-06
C_10_8_15 Node10_8_15 GND 0.0
I_10_9_0 GND Node10_9_0 PWL(0s 0A 3.33us 8.593749999999994e-08A 6.66us 8.593749999999994e-08A 9.99us 8.593749999999994e-08A 13.32us 8.593749999999994e-08A 16.65us 8.593749999999994e-08A 19.98us 8.593749999999994e-08A 23.310000000000002us 8.593749999999994e-08A 26.64us 8.593749999999994e-08A 29.97us 8.593749999999994e-08A 33.3us 8.593749999999994e-08A 36.63us 8.593749999999994e-08A 39.96us 8.593749999999994e-08A 43.29us 8.593749999999994e-08A 46.620000000000005us 8.593749999999994e-08A 49.95us 8.593749999999994e-08A 53.28us 8.593749999999994e-08A 56.61us 8.593749999999994e-08A 59.94us 8.593749999999994e-08A 63.27us 8.593749999999994e-08A 66.6us 8.593749999999994e-08A 69.93us 8.593749999999994e-08A 73.26us 8.593749999999994e-08A 76.59us 8.593749999999994e-08A 79.92us 8.593749999999994e-08A 83.25us 8.593749999999994e-08A 86.58us 8.593749999999994e-08A 89.91us 8.593749999999994e-08A 93.24000000000001us 8.593749999999994e-08A 96.57000000000001us 8.593749999999994e-08A 99.9us 8.593749999999994e-08A)
R_10_9_0_1 Node10_9_0 Node10_9_1 7000.000000000004
R_10_9_0_2 Node10_9_0 Node10_10_0 11200.000000000002
R_10_9_0_3 Node10_9_0 Node11_9_0 0.44800000000000023
C_10_9_0 Node10_9_0 GND 2.481445312499999e-09
I_10_9_1 GND Node10_9_1 PWL(0s 0A 3.33us 8.593749999999994e-08A 6.66us 8.593749999999994e-08A 9.99us 8.593749999999994e-08A 13.32us 8.593749999999994e-08A 16.65us 8.593749999999994e-08A 19.98us 8.593749999999994e-08A 23.310000000000002us 8.593749999999994e-08A 26.64us 8.593749999999994e-08A 29.97us 8.593749999999994e-08A 33.3us 8.593749999999994e-08A 36.63us 8.593749999999994e-08A 39.96us 8.593749999999994e-08A 43.29us 8.593749999999994e-08A 46.620000000000005us 8.593749999999994e-08A 49.95us 8.593749999999994e-08A 53.28us 8.593749999999994e-08A 56.61us 8.593749999999994e-08A 59.94us 8.593749999999994e-08A 63.27us 8.593749999999994e-08A 66.6us 8.593749999999994e-08A 69.93us 8.593749999999994e-08A 73.26us 8.593749999999994e-08A 76.59us 8.593749999999994e-08A 79.92us 8.593749999999994e-08A 83.25us 8.593749999999994e-08A 86.58us 8.593749999999994e-08A 89.91us 8.593749999999994e-08A 93.24000000000001us 8.593749999999994e-08A 96.57000000000001us 8.593749999999994e-08A 99.9us 8.593749999999994e-08A)
R_10_9_1_1 Node10_9_1 Node10_9_2 7000.000000000004
R_10_9_1_2 Node10_9_1 Node10_10_1 11200.000000000002
R_10_9_1_3 Node10_9_1 Node11_9_1 0.44800000000000023
C_10_9_1 Node10_9_1 GND 2.481445312499999e-09
I_10_9_2 GND Node10_9_2 PWL(0s 0A 3.33us 8.593749999999994e-08A 6.66us 8.593749999999994e-08A 9.99us 8.593749999999994e-08A 13.32us 8.593749999999994e-08A 16.65us 8.593749999999994e-08A 19.98us 8.593749999999994e-08A 23.310000000000002us 8.593749999999994e-08A 26.64us 8.593749999999994e-08A 29.97us 8.593749999999994e-08A 33.3us 8.593749999999994e-08A 36.63us 8.593749999999994e-08A 39.96us 8.593749999999994e-08A 43.29us 8.593749999999994e-08A 46.620000000000005us 8.593749999999994e-08A 49.95us 8.593749999999994e-08A 53.28us 8.593749999999994e-08A 56.61us 8.593749999999994e-08A 59.94us 8.593749999999994e-08A 63.27us 8.593749999999994e-08A 66.6us 8.593749999999994e-08A 69.93us 8.593749999999994e-08A 73.26us 8.593749999999994e-08A 76.59us 8.593749999999994e-08A 79.92us 8.593749999999994e-08A 83.25us 8.593749999999994e-08A 86.58us 8.593749999999994e-08A 89.91us 8.593749999999994e-08A 93.24000000000001us 8.593749999999994e-08A 96.57000000000001us 8.593749999999994e-08A 99.9us 8.593749999999994e-08A)
R_10_9_2_1 Node10_9_2 Node10_9_3 7976.744186046516
R_10_9_2_2 Node10_9_2 Node10_10_2 11200.000000000002
R_10_9_2_3 Node10_9_2 Node11_9_2 0.44800000000000023
C_10_9_2 Node10_9_2 GND 2.481445312499999e-09
I_10_9_3 GND Node10_9_3 PWL(0s 0A 3.33us 6.718749999999997e-08A 6.66us 6.718749999999997e-08A 9.99us 6.718749999999997e-08A 13.32us 6.718749999999997e-08A 16.65us 6.718749999999997e-08A 19.98us 6.718749999999997e-08A 23.310000000000002us 6.718749999999997e-08A 26.64us 6.718749999999997e-08A 29.97us 6.718749999999997e-08A 33.3us 6.718749999999997e-08A 36.63us 6.718749999999997e-08A 39.96us 6.718749999999997e-08A 43.29us 6.718749999999997e-08A 46.620000000000005us 6.718749999999997e-08A 49.95us 6.718749999999997e-08A 53.28us 6.718749999999997e-08A 56.61us 6.718749999999997e-08A 59.94us 6.718749999999997e-08A 63.27us 6.718749999999997e-08A 66.6us 6.718749999999997e-08A 69.93us 6.718749999999997e-08A 73.26us 6.718749999999997e-08A 76.59us 6.718749999999997e-08A 79.92us 6.718749999999997e-08A 83.25us 6.718749999999997e-08A 86.58us 6.718749999999997e-08A 89.91us 6.718749999999997e-08A 93.24000000000001us 6.718749999999997e-08A 96.57000000000001us 6.718749999999997e-08A 99.9us 6.718749999999997e-08A)
R_10_9_3_1 Node10_9_3 Node10_9_4 9289.244186046517
R_10_9_3_2 Node10_9_3 Node10_10_3 12176.744186046515
R_10_9_3_3 Node10_9_3 Node11_9_3 0.5730232558139539
C_10_9_3 Node10_9_3 GND 1.940039062499999e-09
I_10_9_4 GND Node10_9_4 PWL(0s 0A 3.33us 6.249999999999996e-08A 6.66us 6.249999999999996e-08A 9.99us 6.249999999999996e-08A 13.32us 6.249999999999996e-08A 16.65us 6.249999999999996e-08A 19.98us 6.249999999999996e-08A 23.310000000000002us 6.249999999999996e-08A 26.64us 6.249999999999996e-08A 29.97us 6.249999999999996e-08A 33.3us 6.249999999999996e-08A 36.63us 6.249999999999996e-08A 39.96us 6.249999999999996e-08A 43.29us 6.249999999999996e-08A 46.620000000000005us 6.249999999999996e-08A 49.95us 6.249999999999996e-08A 53.28us 6.249999999999996e-08A 56.61us 6.249999999999996e-08A 59.94us 6.249999999999996e-08A 63.27us 6.249999999999996e-08A 66.6us 6.249999999999996e-08A 69.93us 6.249999999999996e-08A 73.26us 6.249999999999996e-08A 76.59us 6.249999999999996e-08A 79.92us 6.249999999999996e-08A 83.25us 6.249999999999996e-08A 86.58us 6.249999999999996e-08A 89.91us 6.249999999999996e-08A 93.24000000000001us 6.249999999999996e-08A 96.57000000000001us 6.249999999999996e-08A 99.9us 6.249999999999996e-08A)
R_10_9_4_1 Node10_9_4 Node10_9_5 9625.000000000005
R_10_9_4_2 Node10_9_4 Node10_10_4 12512.500000000004
R_10_9_4_3 Node10_9_4 Node11_9_4 0.6160000000000004
C_10_9_4 Node10_9_4 GND 1.804687499999999e-09
I_10_9_5 GND Node10_9_5 PWL(0s 0A 3.33us 6.249999999999996e-08A 6.66us 6.249999999999996e-08A 9.99us 6.249999999999996e-08A 13.32us 6.249999999999996e-08A 16.65us 6.249999999999996e-08A 19.98us 6.249999999999996e-08A 23.310000000000002us 6.249999999999996e-08A 26.64us 6.249999999999996e-08A 29.97us 6.249999999999996e-08A 33.3us 6.249999999999996e-08A 36.63us 6.249999999999996e-08A 39.96us 6.249999999999996e-08A 43.29us 6.249999999999996e-08A 46.620000000000005us 6.249999999999996e-08A 49.95us 6.249999999999996e-08A 53.28us 6.249999999999996e-08A 56.61us 6.249999999999996e-08A 59.94us 6.249999999999996e-08A 63.27us 6.249999999999996e-08A 66.6us 6.249999999999996e-08A 69.93us 6.249999999999996e-08A 73.26us 6.249999999999996e-08A 76.59us 6.249999999999996e-08A 79.92us 6.249999999999996e-08A 83.25us 6.249999999999996e-08A 86.58us 6.249999999999996e-08A 89.91us 6.249999999999996e-08A 93.24000000000001us 6.249999999999996e-08A 96.57000000000001us 6.249999999999996e-08A 99.9us 6.249999999999996e-08A)
R_10_9_5_1 Node10_9_5 Node10_9_6 13562.500000000011
R_10_9_5_2 Node10_9_5 Node10_10_5 12512.500000000004
R_10_9_5_3 Node10_9_5 Node11_9_5 0.6160000000000004
C_10_9_5 Node10_9_5 GND 1.804687499999999e-09
I_10_9_6 GND Node10_9_6 PWL(0s 0A 3.33us 3.4374999999999975e-08A 6.66us 3.4374999999999975e-08A 9.99us 3.4374999999999975e-08A 13.32us 3.4374999999999975e-08A 16.65us 3.4374999999999975e-08A 19.98us 3.4374999999999975e-08A 23.310000000000002us 3.4374999999999975e-08A 26.64us 3.4374999999999975e-08A 29.97us 3.4374999999999975e-08A 33.3us 3.4374999999999975e-08A 36.63us 3.4374999999999975e-08A 39.96us 3.4374999999999975e-08A 43.29us 3.4374999999999975e-08A 46.620000000000005us 3.4374999999999975e-08A 49.95us 3.4374999999999975e-08A 53.28us 3.4374999999999975e-08A 56.61us 3.4374999999999975e-08A 59.94us 3.4374999999999975e-08A 63.27us 3.4374999999999975e-08A 66.6us 3.4374999999999975e-08A 69.93us 3.4374999999999975e-08A 73.26us 3.4374999999999975e-08A 76.59us 3.4374999999999975e-08A 79.92us 3.4374999999999975e-08A 83.25us 3.4374999999999975e-08A 86.58us 3.4374999999999975e-08A 89.91us 3.4374999999999975e-08A 93.24000000000001us 3.4374999999999975e-08A 96.57000000000001us 3.4374999999999975e-08A 99.9us 3.4374999999999975e-08A)
R_10_9_6_1 Node10_9_6 Node10_9_7 28000.00000000004
R_10_9_6_2 Node10_9_6 Node10_10_6 16450.000000000007
R_10_9_6_3 Node10_9_6 Node11_9_6 1.1200000000000008
C_10_9_6 Node10_9_6 GND 9.925781249999993e-10
I_10_9_7 GND Node10_9_7 PWL(0s 0A 3.33us 1.562499999999997e-08A 6.66us 1.562499999999997e-08A 9.99us 1.562499999999997e-08A 13.32us 1.562499999999997e-08A 16.65us 1.562499999999997e-08A 19.98us 1.562499999999997e-08A 23.310000000000002us 1.562499999999997e-08A 26.64us 1.562499999999997e-08A 29.97us 1.562499999999997e-08A 33.3us 1.562499999999997e-08A 36.63us 1.562499999999997e-08A 39.96us 1.562499999999997e-08A 43.29us 1.562499999999997e-08A 46.620000000000005us 1.562499999999997e-08A 49.95us 1.562499999999997e-08A 53.28us 1.562499999999997e-08A 56.61us 1.562499999999997e-08A 59.94us 1.562499999999997e-08A 63.27us 1.562499999999997e-08A 66.6us 1.562499999999997e-08A 69.93us 1.562499999999997e-08A 73.26us 1.562499999999997e-08A 76.59us 1.562499999999997e-08A 79.92us 1.562499999999997e-08A 83.25us 1.562499999999997e-08A 86.58us 1.562499999999997e-08A 89.91us 1.562499999999997e-08A 93.24000000000001us 1.562499999999997e-08A 96.57000000000001us 1.562499999999997e-08A 99.9us 1.562499999999997e-08A)
R_10_9_7_1 Node10_9_7 Node10_9_8 38500.000000000065
R_10_9_7_2 Node10_9_7 Node10_10_7 26950.000000000033
R_10_9_7_3 Node10_9_7 Node11_9_7 2.4640000000000044
C_10_9_7 Node10_9_7 GND 4.511718749999992e-10
I_10_9_8 GND Node10_9_8 PWL(0s 0A 3.33us 1.562499999999997e-08A 6.66us 1.562499999999997e-08A 9.99us 1.562499999999997e-08A 13.32us 1.562499999999997e-08A 16.65us 1.562499999999997e-08A 19.98us 1.562499999999997e-08A 23.310000000000002us 1.562499999999997e-08A 26.64us 1.562499999999997e-08A 29.97us 1.562499999999997e-08A 33.3us 1.562499999999997e-08A 36.63us 1.562499999999997e-08A 39.96us 1.562499999999997e-08A 43.29us 1.562499999999997e-08A 46.620000000000005us 1.562499999999997e-08A 49.95us 1.562499999999997e-08A 53.28us 1.562499999999997e-08A 56.61us 1.562499999999997e-08A 59.94us 1.562499999999997e-08A 63.27us 1.562499999999997e-08A 66.6us 1.562499999999997e-08A 69.93us 1.562499999999997e-08A 73.26us 1.562499999999997e-08A 76.59us 1.562499999999997e-08A 79.92us 1.562499999999997e-08A 83.25us 1.562499999999997e-08A 86.58us 1.562499999999997e-08A 89.91us 1.562499999999997e-08A 93.24000000000001us 1.562499999999997e-08A 96.57000000000001us 1.562499999999997e-08A 99.9us 1.562499999999997e-08A)
R_10_9_8_1 Node10_9_8 Node10_9_9 38500.000000000065
R_10_9_8_2 Node10_9_8 Node10_10_8 26950.000000000033
R_10_9_8_3 Node10_9_8 Node11_9_8 2.4640000000000044
C_10_9_8 Node10_9_8 GND 4.511718749999992e-10
I_10_9_9 GND Node10_9_9 PWL(0s 0A 3.33us 1.562499999999997e-08A 6.66us 1.562499999999997e-08A 9.99us 1.562499999999997e-08A 13.32us 1.562499999999997e-08A 16.65us 1.562499999999997e-08A 19.98us 1.562499999999997e-08A 23.310000000000002us 1.562499999999997e-08A 26.64us 1.562499999999997e-08A 29.97us 1.562499999999997e-08A 33.3us 1.562499999999997e-08A 36.63us 1.562499999999997e-08A 39.96us 1.562499999999997e-08A 43.29us 1.562499999999997e-08A 46.620000000000005us 1.562499999999997e-08A 49.95us 1.562499999999997e-08A 53.28us 1.562499999999997e-08A 56.61us 1.562499999999997e-08A 59.94us 1.562499999999997e-08A 63.27us 1.562499999999997e-08A 66.6us 1.562499999999997e-08A 69.93us 1.562499999999997e-08A 73.26us 1.562499999999997e-08A 76.59us 1.562499999999997e-08A 79.92us 1.562499999999997e-08A 83.25us 1.562499999999997e-08A 86.58us 1.562499999999997e-08A 89.91us 1.562499999999997e-08A 93.24000000000001us 1.562499999999997e-08A 96.57000000000001us 1.562499999999997e-08A 99.9us 1.562499999999997e-08A)
R_10_9_9_1 Node10_9_9 Node10_9_10 38500.000000000065
R_10_9_9_2 Node10_9_9 Node10_10_9 26950.000000000033
R_10_9_9_3 Node10_9_9 Node11_9_9 2.4640000000000044
C_10_9_9 Node10_9_9 GND 4.511718749999992e-10
I_10_9_10 GND Node10_9_10 PWL(0s 0A 3.33us 1.562499999999997e-08A 6.66us 1.562499999999997e-08A 9.99us 1.562499999999997e-08A 13.32us 1.562499999999997e-08A 16.65us 1.562499999999997e-08A 19.98us 1.562499999999997e-08A 23.310000000000002us 1.562499999999997e-08A 26.64us 1.562499999999997e-08A 29.97us 1.562499999999997e-08A 33.3us 1.562499999999997e-08A 36.63us 1.562499999999997e-08A 39.96us 1.562499999999997e-08A 43.29us 1.562499999999997e-08A 46.620000000000005us 1.562499999999997e-08A 49.95us 1.562499999999997e-08A 53.28us 1.562499999999997e-08A 56.61us 1.562499999999997e-08A 59.94us 1.562499999999997e-08A 63.27us 1.562499999999997e-08A 66.6us 1.562499999999997e-08A 69.93us 1.562499999999997e-08A 73.26us 1.562499999999997e-08A 76.59us 1.562499999999997e-08A 79.92us 1.562499999999997e-08A 83.25us 1.562499999999997e-08A 86.58us 1.562499999999997e-08A 89.91us 1.562499999999997e-08A 93.24000000000001us 1.562499999999997e-08A 96.57000000000001us 1.562499999999997e-08A 99.9us 1.562499999999997e-08A)
R_10_9_10_1 Node10_9_10 Node10_9_11 38500.000000000065
R_10_9_10_2 Node10_9_10 Node10_10_10 26950.000000000033
R_10_9_10_3 Node10_9_10 Node11_9_10 2.4640000000000044
C_10_9_10 Node10_9_10 GND 4.511718749999992e-10
I_10_9_11 GND Node10_9_11 PWL(0s 0A 3.33us 1.562499999999997e-08A 6.66us 1.562499999999997e-08A 9.99us 1.562499999999997e-08A 13.32us 1.562499999999997e-08A 16.65us 1.562499999999997e-08A 19.98us 1.562499999999997e-08A 23.310000000000002us 1.562499999999997e-08A 26.64us 1.562499999999997e-08A 29.97us 1.562499999999997e-08A 33.3us 1.562499999999997e-08A 36.63us 1.562499999999997e-08A 39.96us 1.562499999999997e-08A 43.29us 1.562499999999997e-08A 46.620000000000005us 1.562499999999997e-08A 49.95us 1.562499999999997e-08A 53.28us 1.562499999999997e-08A 56.61us 1.562499999999997e-08A 59.94us 1.562499999999997e-08A 63.27us 1.562499999999997e-08A 66.6us 1.562499999999997e-08A 69.93us 1.562499999999997e-08A 73.26us 1.562499999999997e-08A 76.59us 1.562499999999997e-08A 79.92us 1.562499999999997e-08A 83.25us 1.562499999999997e-08A 86.58us 1.562499999999997e-08A 89.91us 1.562499999999997e-08A 93.24000000000001us 1.562499999999997e-08A 96.57000000000001us 1.562499999999997e-08A 99.9us 1.562499999999997e-08A)
R_10_9_11_1 Node10_9_11 Node10_9_12 38500.000000000065
R_10_9_11_2 Node10_9_11 Node10_10_11 26950.000000000033
R_10_9_11_3 Node10_9_11 Node11_9_11 2.4640000000000044
C_10_9_11 Node10_9_11 GND 4.511718749999992e-10
I_10_9_12 GND Node10_9_12 PWL(0s 0A 3.33us 1.562499999999997e-08A 6.66us 1.562499999999997e-08A 9.99us 1.562499999999997e-08A 13.32us 1.562499999999997e-08A 16.65us 1.562499999999997e-08A 19.98us 1.562499999999997e-08A 23.310000000000002us 1.562499999999997e-08A 26.64us 1.562499999999997e-08A 29.97us 1.562499999999997e-08A 33.3us 1.562499999999997e-08A 36.63us 1.562499999999997e-08A 39.96us 1.562499999999997e-08A 43.29us 1.562499999999997e-08A 46.620000000000005us 1.562499999999997e-08A 49.95us 1.562499999999997e-08A 53.28us 1.562499999999997e-08A 56.61us 1.562499999999997e-08A 59.94us 1.562499999999997e-08A 63.27us 1.562499999999997e-08A 66.6us 1.562499999999997e-08A 69.93us 1.562499999999997e-08A 73.26us 1.562499999999997e-08A 76.59us 1.562499999999997e-08A 79.92us 1.562499999999997e-08A 83.25us 1.562499999999997e-08A 86.58us 1.562499999999997e-08A 89.91us 1.562499999999997e-08A 93.24000000000001us 1.562499999999997e-08A 96.57000000000001us 1.562499999999997e-08A 99.9us 1.562499999999997e-08A)
R_10_9_12_1 Node10_9_12 Node10_9_13 38500.000000000065
R_10_9_12_2 Node10_9_12 Node10_10_12 26950.000000000033
R_10_9_12_3 Node10_9_12 Node11_9_12 2.4640000000000044
C_10_9_12 Node10_9_12 GND 4.511718749999992e-10
I_10_9_13 GND Node10_9_13 PWL(0s 0A 3.33us 1.562499999999997e-08A 6.66us 1.562499999999997e-08A 9.99us 1.562499999999997e-08A 13.32us 1.562499999999997e-08A 16.65us 1.562499999999997e-08A 19.98us 1.562499999999997e-08A 23.310000000000002us 1.562499999999997e-08A 26.64us 1.562499999999997e-08A 29.97us 1.562499999999997e-08A 33.3us 1.562499999999997e-08A 36.63us 1.562499999999997e-08A 39.96us 1.562499999999997e-08A 43.29us 1.562499999999997e-08A 46.620000000000005us 1.562499999999997e-08A 49.95us 1.562499999999997e-08A 53.28us 1.562499999999997e-08A 56.61us 1.562499999999997e-08A 59.94us 1.562499999999997e-08A 63.27us 1.562499999999997e-08A 66.6us 1.562499999999997e-08A 69.93us 1.562499999999997e-08A 73.26us 1.562499999999997e-08A 76.59us 1.562499999999997e-08A 79.92us 1.562499999999997e-08A 83.25us 1.562499999999997e-08A 86.58us 1.562499999999997e-08A 89.91us 1.562499999999997e-08A 93.24000000000001us 1.562499999999997e-08A 96.57000000000001us 1.562499999999997e-08A 99.9us 1.562499999999997e-08A)
R_10_9_13_1 Node10_9_13 Node10_9_14 38500.000000000065
R_10_9_13_2 Node10_9_13 Node10_10_13 26950.000000000033
R_10_9_13_3 Node10_9_13 Node11_9_13 2.4640000000000044
C_10_9_13 Node10_9_13 GND 4.511718749999992e-10
I_10_9_14 GND Node10_9_14 PWL(0s 0A 3.33us 1.562499999999997e-08A 6.66us 1.562499999999997e-08A 9.99us 1.562499999999997e-08A 13.32us 1.562499999999997e-08A 16.65us 1.562499999999997e-08A 19.98us 1.562499999999997e-08A 23.310000000000002us 1.562499999999997e-08A 26.64us 1.562499999999997e-08A 29.97us 1.562499999999997e-08A 33.3us 1.562499999999997e-08A 36.63us 1.562499999999997e-08A 39.96us 1.562499999999997e-08A 43.29us 1.562499999999997e-08A 46.620000000000005us 1.562499999999997e-08A 49.95us 1.562499999999997e-08A 53.28us 1.562499999999997e-08A 56.61us 1.562499999999997e-08A 59.94us 1.562499999999997e-08A 63.27us 1.562499999999997e-08A 66.6us 1.562499999999997e-08A 69.93us 1.562499999999997e-08A 73.26us 1.562499999999997e-08A 76.59us 1.562499999999997e-08A 79.92us 1.562499999999997e-08A 83.25us 1.562499999999997e-08A 86.58us 1.562499999999997e-08A 89.91us 1.562499999999997e-08A 93.24000000000001us 1.562499999999997e-08A 96.57000000000001us 1.562499999999997e-08A 99.9us 1.562499999999997e-08A)
R_10_9_14_1 Node10_9_14 Node10_9_15 38500.000000000044
R_10_9_14_2 Node10_9_14 Node10_10_14 26950.000000000033
R_10_9_14_3 Node10_9_14 Node11_9_14 2.4640000000000044
C_10_9_14 Node10_9_14 GND 4.511718749999992e-10
I_10_9_15 GND Node10_9_15 PWL(0s 0A 3.33us 1.5624999999999983e-08A 6.66us 1.5624999999999983e-08A 9.99us 1.5624999999999983e-08A 13.32us 1.5624999999999983e-08A 16.65us 1.5624999999999983e-08A 19.98us 1.5624999999999983e-08A 23.310000000000002us 1.5624999999999983e-08A 26.64us 1.5624999999999983e-08A 29.97us 1.5624999999999983e-08A 33.3us 1.5624999999999983e-08A 36.63us 1.5624999999999983e-08A 39.96us 1.5624999999999983e-08A 43.29us 1.5624999999999983e-08A 46.620000000000005us 1.5624999999999983e-08A 49.95us 1.5624999999999983e-08A 53.28us 1.5624999999999983e-08A 56.61us 1.5624999999999983e-08A 59.94us 1.5624999999999983e-08A 63.27us 1.5624999999999983e-08A 66.6us 1.5624999999999983e-08A 69.93us 1.5624999999999983e-08A 73.26us 1.5624999999999983e-08A 76.59us 1.5624999999999983e-08A 79.92us 1.5624999999999983e-08A 83.25us 1.5624999999999983e-08A 86.58us 1.5624999999999983e-08A 89.91us 1.5624999999999983e-08A 93.24000000000001us 1.5624999999999983e-08A 96.57000000000001us 1.5624999999999983e-08A 99.9us 1.5624999999999983e-08A)
R_10_9_15_2 Node10_9_15 Node10_10_15 26950.000000000007
R_10_9_15_3 Node10_9_15 Node11_9_15 2.464000000000002
C_10_9_15 Node10_9_15 GND 4.511718749999996e-10
I_10_10_0 GND Node10_10_0 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 3.906249999999999e-08A 39.96us 3.906249999999999e-08A 43.29us 3.906249999999999e-08A 46.620000000000005us 3.906249999999999e-08A 49.95us 3.906249999999999e-08A 53.28us 3.906249999999999e-08A 56.61us 3.906249999999999e-08A 59.94us 3.906249999999999e-08A 63.27us 3.906249999999999e-08A 66.6us 3.906249999999999e-08A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_10_10_0_1 Node10_10_0 Node10_10_1 15400.0
R_10_10_0_2 Node10_10_0 Node10_11_0 15400.0
R_10_10_0_3 Node10_10_0 Node11_10_0 0.9856000000000001
C_10_10_0 Node10_10_0 GND 1.1279296875e-09
I_10_10_1 GND Node10_10_1 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 3.906249999999999e-08A 39.96us 3.906249999999999e-08A 43.29us 3.906249999999999e-08A 46.620000000000005us 3.906249999999999e-08A 49.95us 3.906249999999999e-08A 53.28us 3.906249999999999e-08A 56.61us 3.906249999999999e-08A 59.94us 3.906249999999999e-08A 63.27us 3.906249999999999e-08A 66.6us 3.906249999999999e-08A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_10_10_1_1 Node10_10_1 Node10_10_2 15400.0
R_10_10_1_2 Node10_10_1 Node10_11_1 15400.0
R_10_10_1_3 Node10_10_1 Node11_10_1 0.9856000000000001
C_10_10_1 Node10_10_1 GND 1.1279296875e-09
I_10_10_2 GND Node10_10_2 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 3.906249999999999e-08A 39.96us 3.906249999999999e-08A 43.29us 3.906249999999999e-08A 46.620000000000005us 3.906249999999999e-08A 49.95us 3.906249999999999e-08A 53.28us 3.906249999999999e-08A 56.61us 3.906249999999999e-08A 59.94us 3.906249999999999e-08A 63.27us 3.906249999999999e-08A 66.6us 3.906249999999999e-08A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_10_10_2_1 Node10_10_2 Node10_10_3 15400.0
R_10_10_2_2 Node10_10_2 Node10_11_2 15400.0
R_10_10_2_3 Node10_10_2 Node11_10_2 0.9856000000000001
C_10_10_2 Node10_10_2 GND 1.1279296875e-09
I_10_10_3 GND Node10_10_3 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 3.906249999999999e-08A 39.96us 3.906249999999999e-08A 43.29us 3.906249999999999e-08A 46.620000000000005us 3.906249999999999e-08A 49.95us 3.906249999999999e-08A 53.28us 3.906249999999999e-08A 56.61us 3.906249999999999e-08A 59.94us 3.906249999999999e-08A 63.27us 3.906249999999999e-08A 66.6us 3.906249999999999e-08A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_10_10_3_1 Node10_10_3 Node10_10_4 15400.0
R_10_10_3_2 Node10_10_3 Node10_11_3 15400.0
R_10_10_3_3 Node10_10_3 Node11_10_3 0.9856000000000001
C_10_10_3 Node10_10_3 GND 1.1279296875e-09
I_10_10_4 GND Node10_10_4 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 3.906249999999999e-08A 39.96us 3.906249999999999e-08A 43.29us 3.906249999999999e-08A 46.620000000000005us 3.906249999999999e-08A 49.95us 3.906249999999999e-08A 53.28us 3.906249999999999e-08A 56.61us 3.906249999999999e-08A 59.94us 3.906249999999999e-08A 63.27us 3.906249999999999e-08A 66.6us 3.906249999999999e-08A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_10_10_4_1 Node10_10_4 Node10_10_5 15400.0
R_10_10_4_2 Node10_10_4 Node10_11_4 15400.0
R_10_10_4_3 Node10_10_4 Node11_10_4 0.9856000000000001
C_10_10_4 Node10_10_4 GND 1.1279296875e-09
I_10_10_5 GND Node10_10_5 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 3.906249999999999e-08A 39.96us 3.906249999999999e-08A 43.29us 3.906249999999999e-08A 46.620000000000005us 3.906249999999999e-08A 49.95us 3.906249999999999e-08A 53.28us 3.906249999999999e-08A 56.61us 3.906249999999999e-08A 59.94us 3.906249999999999e-08A 63.27us 3.906249999999999e-08A 66.6us 3.906249999999999e-08A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_10_10_5_1 Node10_10_5 Node10_10_6 15400.0
R_10_10_5_2 Node10_10_5 Node10_11_5 15400.0
R_10_10_5_3 Node10_10_5 Node11_10_5 0.9856000000000001
C_10_10_5 Node10_10_5 GND 1.1279296875e-09
I_10_10_6 GND Node10_10_6 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 3.906249999999999e-08A 39.96us 3.906249999999999e-08A 43.29us 3.906249999999999e-08A 46.620000000000005us 3.906249999999999e-08A 49.95us 3.906249999999999e-08A 53.28us 3.906249999999999e-08A 56.61us 3.906249999999999e-08A 59.94us 3.906249999999999e-08A 63.27us 3.906249999999999e-08A 66.6us 3.906249999999999e-08A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_10_10_6_1 Node10_10_6 Node10_10_7 15400.0
R_10_10_6_2 Node10_10_6 Node10_11_6 15400.0
R_10_10_6_3 Node10_10_6 Node11_10_6 0.9856000000000001
C_10_10_6 Node10_10_6 GND 1.1279296875e-09
I_10_10_7 GND Node10_10_7 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 3.906249999999999e-08A 39.96us 3.906249999999999e-08A 43.29us 3.906249999999999e-08A 46.620000000000005us 3.906249999999999e-08A 49.95us 3.906249999999999e-08A 53.28us 3.906249999999999e-08A 56.61us 3.906249999999999e-08A 59.94us 3.906249999999999e-08A 63.27us 3.906249999999999e-08A 66.6us 3.906249999999999e-08A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_10_10_7_1 Node10_10_7 Node10_10_8 15400.0
R_10_10_7_2 Node10_10_7 Node10_11_7 15400.0
R_10_10_7_3 Node10_10_7 Node11_10_7 0.9856000000000001
C_10_10_7 Node10_10_7 GND 1.1279296875e-09
I_10_10_8 GND Node10_10_8 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 3.906249999999999e-08A 39.96us 3.906249999999999e-08A 43.29us 3.906249999999999e-08A 46.620000000000005us 3.906249999999999e-08A 49.95us 3.906249999999999e-08A 53.28us 3.906249999999999e-08A 56.61us 3.906249999999999e-08A 59.94us 3.906249999999999e-08A 63.27us 3.906249999999999e-08A 66.6us 3.906249999999999e-08A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_10_10_8_1 Node10_10_8 Node10_10_9 15400.0
R_10_10_8_2 Node10_10_8 Node10_11_8 15400.0
R_10_10_8_3 Node10_10_8 Node11_10_8 0.9856000000000001
C_10_10_8 Node10_10_8 GND 1.1279296875e-09
I_10_10_9 GND Node10_10_9 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 3.906249999999999e-08A 39.96us 3.906249999999999e-08A 43.29us 3.906249999999999e-08A 46.620000000000005us 3.906249999999999e-08A 49.95us 3.906249999999999e-08A 53.28us 3.906249999999999e-08A 56.61us 3.906249999999999e-08A 59.94us 3.906249999999999e-08A 63.27us 3.906249999999999e-08A 66.6us 3.906249999999999e-08A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_10_10_9_1 Node10_10_9 Node10_10_10 15400.0
R_10_10_9_2 Node10_10_9 Node10_11_9 15400.0
R_10_10_9_3 Node10_10_9 Node11_10_9 0.9856000000000001
C_10_10_9 Node10_10_9 GND 1.1279296875e-09
I_10_10_10 GND Node10_10_10 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 3.906249999999999e-08A 39.96us 3.906249999999999e-08A 43.29us 3.906249999999999e-08A 46.620000000000005us 3.906249999999999e-08A 49.95us 3.906249999999999e-08A 53.28us 3.906249999999999e-08A 56.61us 3.906249999999999e-08A 59.94us 3.906249999999999e-08A 63.27us 3.906249999999999e-08A 66.6us 3.906249999999999e-08A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_10_10_10_1 Node10_10_10 Node10_10_11 15400.0
R_10_10_10_2 Node10_10_10 Node10_11_10 15400.0
R_10_10_10_3 Node10_10_10 Node11_10_10 0.9856000000000001
C_10_10_10 Node10_10_10 GND 1.1279296875e-09
I_10_10_11 GND Node10_10_11 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 3.906249999999999e-08A 39.96us 3.906249999999999e-08A 43.29us 3.906249999999999e-08A 46.620000000000005us 3.906249999999999e-08A 49.95us 3.906249999999999e-08A 53.28us 3.906249999999999e-08A 56.61us 3.906249999999999e-08A 59.94us 3.906249999999999e-08A 63.27us 3.906249999999999e-08A 66.6us 3.906249999999999e-08A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_10_10_11_1 Node10_10_11 Node10_10_12 15400.0
R_10_10_11_2 Node10_10_11 Node10_11_11 15400.0
R_10_10_11_3 Node10_10_11 Node11_10_11 0.9856000000000001
C_10_10_11 Node10_10_11 GND 1.1279296875e-09
I_10_10_12 GND Node10_10_12 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 3.906249999999999e-08A 39.96us 3.906249999999999e-08A 43.29us 3.906249999999999e-08A 46.620000000000005us 3.906249999999999e-08A 49.95us 3.906249999999999e-08A 53.28us 3.906249999999999e-08A 56.61us 3.906249999999999e-08A 59.94us 3.906249999999999e-08A 63.27us 3.906249999999999e-08A 66.6us 3.906249999999999e-08A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_10_10_12_1 Node10_10_12 Node10_10_13 15400.0
R_10_10_12_2 Node10_10_12 Node10_11_12 15400.0
R_10_10_12_3 Node10_10_12 Node11_10_12 0.9856000000000001
C_10_10_12 Node10_10_12 GND 1.1279296875e-09
I_10_10_13 GND Node10_10_13 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 3.906249999999999e-08A 39.96us 3.906249999999999e-08A 43.29us 3.906249999999999e-08A 46.620000000000005us 3.906249999999999e-08A 49.95us 3.906249999999999e-08A 53.28us 3.906249999999999e-08A 56.61us 3.906249999999999e-08A 59.94us 3.906249999999999e-08A 63.27us 3.906249999999999e-08A 66.6us 3.906249999999999e-08A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_10_10_13_1 Node10_10_13 Node10_10_14 15400.0
R_10_10_13_2 Node10_10_13 Node10_11_13 15400.0
R_10_10_13_3 Node10_10_13 Node11_10_13 0.9856000000000001
C_10_10_13 Node10_10_13 GND 1.1279296875e-09
I_10_10_14 GND Node10_10_14 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 3.906249999999999e-08A 39.96us 3.906249999999999e-08A 43.29us 3.906249999999999e-08A 46.620000000000005us 3.906249999999999e-08A 49.95us 3.906249999999999e-08A 53.28us 3.906249999999999e-08A 56.61us 3.906249999999999e-08A 59.94us 3.906249999999999e-08A 63.27us 3.906249999999999e-08A 66.6us 3.906249999999999e-08A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_10_10_14_1 Node10_10_14 Node10_10_15 15399.999999999993
R_10_10_14_2 Node10_10_14 Node10_11_14 15400.0
R_10_10_14_3 Node10_10_14 Node11_10_14 0.9856000000000001
C_10_10_14 Node10_10_14 GND 1.1279296875e-09
I_10_10_15 GND Node10_10_15 PWL(0s 0A 3.33us 3.906250000000002e-08A 6.66us 3.906250000000002e-08A 9.99us 3.906250000000002e-08A 13.32us 3.906250000000002e-08A 16.65us 3.906250000000002e-08A 19.98us 3.906250000000002e-08A 23.310000000000002us 3.906250000000002e-08A 26.64us 3.906250000000002e-08A 29.97us 3.906250000000002e-08A 33.3us 3.906250000000002e-08A 36.63us 3.906250000000002e-08A 39.96us 3.906250000000002e-08A 43.29us 3.906250000000002e-08A 46.620000000000005us 3.906250000000002e-08A 49.95us 3.906250000000002e-08A 53.28us 3.906250000000002e-08A 56.61us 3.906250000000002e-08A 59.94us 3.906250000000002e-08A 63.27us 3.906250000000002e-08A 66.6us 3.906250000000002e-08A 69.93us 3.906250000000002e-08A 73.26us 3.906250000000002e-08A 76.59us 3.906250000000002e-08A 79.92us 3.906250000000002e-08A 83.25us 3.906250000000002e-08A 86.58us 3.906250000000002e-08A 89.91us 3.906250000000002e-08A 93.24000000000001us 3.906250000000002e-08A 96.57000000000001us 3.906250000000002e-08A 99.9us 3.906250000000002e-08A)
R_10_10_15_2 Node10_10_15 Node10_11_15 15399.999999999987
R_10_10_15_3 Node10_10_15 Node11_10_15 0.9855999999999993
C_10_10_15 Node10_10_15 GND 1.127929687500001e-09
I_10_11_0 GND Node10_11_0 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 3.906249999999999e-08A 39.96us 3.906249999999999e-08A 43.29us 3.906249999999999e-08A 46.620000000000005us 3.906249999999999e-08A 49.95us 3.906249999999999e-08A 53.28us 3.906249999999999e-08A 56.61us 3.906249999999999e-08A 59.94us 3.906249999999999e-08A 63.27us 3.906249999999999e-08A 66.6us 3.906249999999999e-08A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_10_11_0_1 Node10_11_0 Node10_11_1 15400.0
R_10_11_0_2 Node10_11_0 Node10_12_0 15400.0
R_10_11_0_3 Node10_11_0 Node11_11_0 0.9856000000000001
C_10_11_0 Node10_11_0 GND 1.1279296875e-09
I_10_11_1 GND Node10_11_1 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 3.906249999999999e-08A 39.96us 3.906249999999999e-08A 43.29us 3.906249999999999e-08A 46.620000000000005us 3.906249999999999e-08A 49.95us 3.906249999999999e-08A 53.28us 3.906249999999999e-08A 56.61us 3.906249999999999e-08A 59.94us 3.906249999999999e-08A 63.27us 3.906249999999999e-08A 66.6us 3.906249999999999e-08A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_10_11_1_1 Node10_11_1 Node10_11_2 15400.0
R_10_11_1_2 Node10_11_1 Node10_12_1 15400.0
R_10_11_1_3 Node10_11_1 Node11_11_1 0.9856000000000001
C_10_11_1 Node10_11_1 GND 1.1279296875e-09
I_10_11_2 GND Node10_11_2 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 3.906249999999999e-08A 39.96us 3.906249999999999e-08A 43.29us 3.906249999999999e-08A 46.620000000000005us 3.906249999999999e-08A 49.95us 3.906249999999999e-08A 53.28us 3.906249999999999e-08A 56.61us 3.906249999999999e-08A 59.94us 3.906249999999999e-08A 63.27us 3.906249999999999e-08A 66.6us 3.906249999999999e-08A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_10_11_2_1 Node10_11_2 Node10_11_3 15400.0
R_10_11_2_2 Node10_11_2 Node10_12_2 15400.0
R_10_11_2_3 Node10_11_2 Node11_11_2 0.9856000000000001
C_10_11_2 Node10_11_2 GND 1.1279296875e-09
I_10_11_3 GND Node10_11_3 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 3.906249999999999e-08A 39.96us 3.906249999999999e-08A 43.29us 3.906249999999999e-08A 46.620000000000005us 3.906249999999999e-08A 49.95us 3.906249999999999e-08A 53.28us 3.906249999999999e-08A 56.61us 3.906249999999999e-08A 59.94us 3.906249999999999e-08A 63.27us 3.906249999999999e-08A 66.6us 3.906249999999999e-08A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_10_11_3_1 Node10_11_3 Node10_11_4 15400.0
R_10_11_3_2 Node10_11_3 Node10_12_3 15400.0
R_10_11_3_3 Node10_11_3 Node11_11_3 0.9856000000000001
C_10_11_3 Node10_11_3 GND 1.1279296875e-09
I_10_11_4 GND Node10_11_4 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 3.906249999999999e-08A 39.96us 3.906249999999999e-08A 43.29us 3.906249999999999e-08A 46.620000000000005us 3.906249999999999e-08A 49.95us 3.906249999999999e-08A 53.28us 3.906249999999999e-08A 56.61us 3.906249999999999e-08A 59.94us 3.906249999999999e-08A 63.27us 3.906249999999999e-08A 66.6us 3.906249999999999e-08A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_10_11_4_1 Node10_11_4 Node10_11_5 15400.0
R_10_11_4_2 Node10_11_4 Node10_12_4 15400.0
R_10_11_4_3 Node10_11_4 Node11_11_4 0.9856000000000001
C_10_11_4 Node10_11_4 GND 1.1279296875e-09
I_10_11_5 GND Node10_11_5 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 3.906249999999999e-08A 39.96us 3.906249999999999e-08A 43.29us 3.906249999999999e-08A 46.620000000000005us 3.906249999999999e-08A 49.95us 3.906249999999999e-08A 53.28us 3.906249999999999e-08A 56.61us 3.906249999999999e-08A 59.94us 3.906249999999999e-08A 63.27us 3.906249999999999e-08A 66.6us 3.906249999999999e-08A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_10_11_5_1 Node10_11_5 Node10_11_6 15400.0
R_10_11_5_2 Node10_11_5 Node10_12_5 15400.0
R_10_11_5_3 Node10_11_5 Node11_11_5 0.9856000000000001
C_10_11_5 Node10_11_5 GND 1.1279296875e-09
I_10_11_6 GND Node10_11_6 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 3.906249999999999e-08A 39.96us 3.906249999999999e-08A 43.29us 3.906249999999999e-08A 46.620000000000005us 3.906249999999999e-08A 49.95us 3.906249999999999e-08A 53.28us 3.906249999999999e-08A 56.61us 3.906249999999999e-08A 59.94us 3.906249999999999e-08A 63.27us 3.906249999999999e-08A 66.6us 3.906249999999999e-08A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_10_11_6_1 Node10_11_6 Node10_11_7 15400.0
R_10_11_6_2 Node10_11_6 Node10_12_6 15400.0
R_10_11_6_3 Node10_11_6 Node11_11_6 0.9856000000000001
C_10_11_6 Node10_11_6 GND 1.1279296875e-09
I_10_11_7 GND Node10_11_7 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 3.906249999999999e-08A 39.96us 3.906249999999999e-08A 43.29us 3.906249999999999e-08A 46.620000000000005us 3.906249999999999e-08A 49.95us 3.906249999999999e-08A 53.28us 3.906249999999999e-08A 56.61us 3.906249999999999e-08A 59.94us 3.906249999999999e-08A 63.27us 3.906249999999999e-08A 66.6us 3.906249999999999e-08A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_10_11_7_1 Node10_11_7 Node10_11_8 15400.0
R_10_11_7_2 Node10_11_7 Node10_12_7 15400.0
R_10_11_7_3 Node10_11_7 Node11_11_7 0.9856000000000001
C_10_11_7 Node10_11_7 GND 1.1279296875e-09
I_10_11_8 GND Node10_11_8 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 3.906249999999999e-08A 39.96us 3.906249999999999e-08A 43.29us 3.906249999999999e-08A 46.620000000000005us 3.906249999999999e-08A 49.95us 3.906249999999999e-08A 53.28us 3.906249999999999e-08A 56.61us 3.906249999999999e-08A 59.94us 3.906249999999999e-08A 63.27us 3.906249999999999e-08A 66.6us 3.906249999999999e-08A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_10_11_8_1 Node10_11_8 Node10_11_9 15400.0
R_10_11_8_2 Node10_11_8 Node10_12_8 15400.0
R_10_11_8_3 Node10_11_8 Node11_11_8 0.9856000000000001
C_10_11_8 Node10_11_8 GND 1.1279296875e-09
I_10_11_9 GND Node10_11_9 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 3.906249999999999e-08A 39.96us 3.906249999999999e-08A 43.29us 3.906249999999999e-08A 46.620000000000005us 3.906249999999999e-08A 49.95us 3.906249999999999e-08A 53.28us 3.906249999999999e-08A 56.61us 3.906249999999999e-08A 59.94us 3.906249999999999e-08A 63.27us 3.906249999999999e-08A 66.6us 3.906249999999999e-08A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_10_11_9_1 Node10_11_9 Node10_11_10 15400.0
R_10_11_9_2 Node10_11_9 Node10_12_9 15400.0
R_10_11_9_3 Node10_11_9 Node11_11_9 0.9856000000000001
C_10_11_9 Node10_11_9 GND 1.1279296875e-09
I_10_11_10 GND Node10_11_10 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 3.906249999999999e-08A 39.96us 3.906249999999999e-08A 43.29us 3.906249999999999e-08A 46.620000000000005us 3.906249999999999e-08A 49.95us 3.906249999999999e-08A 53.28us 3.906249999999999e-08A 56.61us 3.906249999999999e-08A 59.94us 3.906249999999999e-08A 63.27us 3.906249999999999e-08A 66.6us 3.906249999999999e-08A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_10_11_10_1 Node10_11_10 Node10_11_11 15400.0
R_10_11_10_2 Node10_11_10 Node10_12_10 15400.0
R_10_11_10_3 Node10_11_10 Node11_11_10 0.9856000000000001
C_10_11_10 Node10_11_10 GND 1.1279296875e-09
I_10_11_11 GND Node10_11_11 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 3.906249999999999e-08A 39.96us 3.906249999999999e-08A 43.29us 3.906249999999999e-08A 46.620000000000005us 3.906249999999999e-08A 49.95us 3.906249999999999e-08A 53.28us 3.906249999999999e-08A 56.61us 3.906249999999999e-08A 59.94us 3.906249999999999e-08A 63.27us 3.906249999999999e-08A 66.6us 3.906249999999999e-08A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_10_11_11_1 Node10_11_11 Node10_11_12 15400.0
R_10_11_11_2 Node10_11_11 Node10_12_11 15400.0
R_10_11_11_3 Node10_11_11 Node11_11_11 0.9856000000000001
C_10_11_11 Node10_11_11 GND 1.1279296875e-09
I_10_11_12 GND Node10_11_12 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 3.906249999999999e-08A 39.96us 3.906249999999999e-08A 43.29us 3.906249999999999e-08A 46.620000000000005us 3.906249999999999e-08A 49.95us 3.906249999999999e-08A 53.28us 3.906249999999999e-08A 56.61us 3.906249999999999e-08A 59.94us 3.906249999999999e-08A 63.27us 3.906249999999999e-08A 66.6us 3.906249999999999e-08A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_10_11_12_1 Node10_11_12 Node10_11_13 15400.0
R_10_11_12_2 Node10_11_12 Node10_12_12 15400.0
R_10_11_12_3 Node10_11_12 Node11_11_12 0.9856000000000001
C_10_11_12 Node10_11_12 GND 1.1279296875e-09
I_10_11_13 GND Node10_11_13 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 3.906249999999999e-08A 39.96us 3.906249999999999e-08A 43.29us 3.906249999999999e-08A 46.620000000000005us 3.906249999999999e-08A 49.95us 3.906249999999999e-08A 53.28us 3.906249999999999e-08A 56.61us 3.906249999999999e-08A 59.94us 3.906249999999999e-08A 63.27us 3.906249999999999e-08A 66.6us 3.906249999999999e-08A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_10_11_13_1 Node10_11_13 Node10_11_14 15400.0
R_10_11_13_2 Node10_11_13 Node10_12_13 15400.0
R_10_11_13_3 Node10_11_13 Node11_11_13 0.9856000000000001
C_10_11_13 Node10_11_13 GND 1.1279296875e-09
I_10_11_14 GND Node10_11_14 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 3.906249999999999e-08A 39.96us 3.906249999999999e-08A 43.29us 3.906249999999999e-08A 46.620000000000005us 3.906249999999999e-08A 49.95us 3.906249999999999e-08A 53.28us 3.906249999999999e-08A 56.61us 3.906249999999999e-08A 59.94us 3.906249999999999e-08A 63.27us 3.906249999999999e-08A 66.6us 3.906249999999999e-08A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_10_11_14_1 Node10_11_14 Node10_11_15 15399.999999999993
R_10_11_14_2 Node10_11_14 Node10_12_14 15400.0
R_10_11_14_3 Node10_11_14 Node11_11_14 0.9856000000000001
C_10_11_14 Node10_11_14 GND 1.1279296875e-09
I_10_11_15 GND Node10_11_15 PWL(0s 0A 3.33us 3.906250000000002e-08A 6.66us 3.906250000000002e-08A 9.99us 3.906250000000002e-08A 13.32us 3.906250000000002e-08A 16.65us 3.906250000000002e-08A 19.98us 3.906250000000002e-08A 23.310000000000002us 3.906250000000002e-08A 26.64us 3.906250000000002e-08A 29.97us 3.906250000000002e-08A 33.3us 3.906250000000002e-08A 36.63us 3.906250000000002e-08A 39.96us 3.906250000000002e-08A 43.29us 3.906250000000002e-08A 46.620000000000005us 3.906250000000002e-08A 49.95us 3.906250000000002e-08A 53.28us 3.906250000000002e-08A 56.61us 3.906250000000002e-08A 59.94us 3.906250000000002e-08A 63.27us 3.906250000000002e-08A 66.6us 3.906250000000002e-08A 69.93us 3.906250000000002e-08A 73.26us 3.906250000000002e-08A 76.59us 3.906250000000002e-08A 79.92us 3.906250000000002e-08A 83.25us 3.906250000000002e-08A 86.58us 3.906250000000002e-08A 89.91us 3.906250000000002e-08A 93.24000000000001us 3.906250000000002e-08A 96.57000000000001us 3.906250000000002e-08A 99.9us 3.906250000000002e-08A)
R_10_11_15_2 Node10_11_15 Node10_12_15 15399.999999999987
R_10_11_15_3 Node10_11_15 Node11_11_15 0.9855999999999993
C_10_11_15 Node10_11_15 GND 1.127929687500001e-09
I_10_12_0 GND Node10_12_0 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 3.906249999999999e-08A 39.96us 3.906249999999999e-08A 43.29us 3.906249999999999e-08A 46.620000000000005us 3.906249999999999e-08A 49.95us 3.906249999999999e-08A 53.28us 3.906249999999999e-08A 56.61us 3.906249999999999e-08A 59.94us 3.906249999999999e-08A 63.27us 3.906249999999999e-08A 66.6us 3.906249999999999e-08A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_10_12_0_1 Node10_12_0 Node10_12_1 15400.0
R_10_12_0_2 Node10_12_0 Node10_13_0 15400.0
R_10_12_0_3 Node10_12_0 Node11_12_0 0.9856000000000001
C_10_12_0 Node10_12_0 GND 1.1279296875e-09
I_10_12_1 GND Node10_12_1 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 3.906249999999999e-08A 39.96us 3.906249999999999e-08A 43.29us 3.906249999999999e-08A 46.620000000000005us 3.906249999999999e-08A 49.95us 3.906249999999999e-08A 53.28us 3.906249999999999e-08A 56.61us 3.906249999999999e-08A 59.94us 3.906249999999999e-08A 63.27us 3.906249999999999e-08A 66.6us 3.906249999999999e-08A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_10_12_1_1 Node10_12_1 Node10_12_2 15400.0
R_10_12_1_2 Node10_12_1 Node10_13_1 15400.0
R_10_12_1_3 Node10_12_1 Node11_12_1 0.9856000000000001
C_10_12_1 Node10_12_1 GND 1.1279296875e-09
I_10_12_2 GND Node10_12_2 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 3.906249999999999e-08A 39.96us 3.906249999999999e-08A 43.29us 3.906249999999999e-08A 46.620000000000005us 3.906249999999999e-08A 49.95us 3.906249999999999e-08A 53.28us 3.906249999999999e-08A 56.61us 3.906249999999999e-08A 59.94us 3.906249999999999e-08A 63.27us 3.906249999999999e-08A 66.6us 3.906249999999999e-08A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_10_12_2_1 Node10_12_2 Node10_12_3 15400.0
R_10_12_2_2 Node10_12_2 Node10_13_2 15400.0
R_10_12_2_3 Node10_12_2 Node11_12_2 0.9856000000000001
C_10_12_2 Node10_12_2 GND 1.1279296875e-09
I_10_12_3 GND Node10_12_3 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 3.906249999999999e-08A 39.96us 3.906249999999999e-08A 43.29us 3.906249999999999e-08A 46.620000000000005us 3.906249999999999e-08A 49.95us 3.906249999999999e-08A 53.28us 3.906249999999999e-08A 56.61us 3.906249999999999e-08A 59.94us 3.906249999999999e-08A 63.27us 3.906249999999999e-08A 66.6us 3.906249999999999e-08A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_10_12_3_1 Node10_12_3 Node10_12_4 15400.0
R_10_12_3_2 Node10_12_3 Node10_13_3 15400.0
R_10_12_3_3 Node10_12_3 Node11_12_3 0.9856000000000001
C_10_12_3 Node10_12_3 GND 1.1279296875e-09
I_10_12_4 GND Node10_12_4 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 3.906249999999999e-08A 39.96us 3.906249999999999e-08A 43.29us 3.906249999999999e-08A 46.620000000000005us 3.906249999999999e-08A 49.95us 3.906249999999999e-08A 53.28us 3.906249999999999e-08A 56.61us 3.906249999999999e-08A 59.94us 3.906249999999999e-08A 63.27us 3.906249999999999e-08A 66.6us 3.906249999999999e-08A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_10_12_4_1 Node10_12_4 Node10_12_5 15400.0
R_10_12_4_2 Node10_12_4 Node10_13_4 15400.0
R_10_12_4_3 Node10_12_4 Node11_12_4 0.9856000000000001
C_10_12_4 Node10_12_4 GND 1.1279296875e-09
I_10_12_5 GND Node10_12_5 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 3.906249999999999e-08A 39.96us 3.906249999999999e-08A 43.29us 3.906249999999999e-08A 46.620000000000005us 3.906249999999999e-08A 49.95us 3.906249999999999e-08A 53.28us 3.906249999999999e-08A 56.61us 3.906249999999999e-08A 59.94us 3.906249999999999e-08A 63.27us 3.906249999999999e-08A 66.6us 3.906249999999999e-08A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_10_12_5_1 Node10_12_5 Node10_12_6 15400.0
R_10_12_5_2 Node10_12_5 Node10_13_5 15400.0
R_10_12_5_3 Node10_12_5 Node11_12_5 0.9856000000000001
C_10_12_5 Node10_12_5 GND 1.1279296875e-09
I_10_12_6 GND Node10_12_6 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 3.906249999999999e-08A 39.96us 3.906249999999999e-08A 43.29us 3.906249999999999e-08A 46.620000000000005us 3.906249999999999e-08A 49.95us 3.906249999999999e-08A 53.28us 3.906249999999999e-08A 56.61us 3.906249999999999e-08A 59.94us 3.906249999999999e-08A 63.27us 3.906249999999999e-08A 66.6us 3.906249999999999e-08A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_10_12_6_1 Node10_12_6 Node10_12_7 15400.0
R_10_12_6_2 Node10_12_6 Node10_13_6 15400.0
R_10_12_6_3 Node10_12_6 Node11_12_6 0.9856000000000001
C_10_12_6 Node10_12_6 GND 1.1279296875e-09
I_10_12_7 GND Node10_12_7 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 3.906249999999999e-08A 39.96us 3.906249999999999e-08A 43.29us 3.906249999999999e-08A 46.620000000000005us 3.906249999999999e-08A 49.95us 3.906249999999999e-08A 53.28us 3.906249999999999e-08A 56.61us 3.906249999999999e-08A 59.94us 3.906249999999999e-08A 63.27us 3.906249999999999e-08A 66.6us 3.906249999999999e-08A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_10_12_7_1 Node10_12_7 Node10_12_8 15400.0
R_10_12_7_2 Node10_12_7 Node10_13_7 15400.0
R_10_12_7_3 Node10_12_7 Node11_12_7 0.9856000000000001
C_10_12_7 Node10_12_7 GND 1.1279296875e-09
I_10_12_8 GND Node10_12_8 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 3.906249999999999e-08A 39.96us 3.906249999999999e-08A 43.29us 3.906249999999999e-08A 46.620000000000005us 3.906249999999999e-08A 49.95us 3.906249999999999e-08A 53.28us 3.906249999999999e-08A 56.61us 3.906249999999999e-08A 59.94us 3.906249999999999e-08A 63.27us 3.906249999999999e-08A 66.6us 3.906249999999999e-08A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_10_12_8_1 Node10_12_8 Node10_12_9 15400.0
R_10_12_8_2 Node10_12_8 Node10_13_8 15400.0
R_10_12_8_3 Node10_12_8 Node11_12_8 0.9856000000000001
C_10_12_8 Node10_12_8 GND 1.1279296875e-09
I_10_12_9 GND Node10_12_9 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 3.906249999999999e-08A 39.96us 3.906249999999999e-08A 43.29us 3.906249999999999e-08A 46.620000000000005us 3.906249999999999e-08A 49.95us 3.906249999999999e-08A 53.28us 3.906249999999999e-08A 56.61us 3.906249999999999e-08A 59.94us 3.906249999999999e-08A 63.27us 3.906249999999999e-08A 66.6us 3.906249999999999e-08A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_10_12_9_1 Node10_12_9 Node10_12_10 15400.0
R_10_12_9_2 Node10_12_9 Node10_13_9 15400.0
R_10_12_9_3 Node10_12_9 Node11_12_9 0.9856000000000001
C_10_12_9 Node10_12_9 GND 1.1279296875e-09
I_10_12_10 GND Node10_12_10 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 3.906249999999999e-08A 39.96us 3.906249999999999e-08A 43.29us 3.906249999999999e-08A 46.620000000000005us 3.906249999999999e-08A 49.95us 3.906249999999999e-08A 53.28us 3.906249999999999e-08A 56.61us 3.906249999999999e-08A 59.94us 3.906249999999999e-08A 63.27us 3.906249999999999e-08A 66.6us 3.906249999999999e-08A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_10_12_10_1 Node10_12_10 Node10_12_11 15400.0
R_10_12_10_2 Node10_12_10 Node10_13_10 15400.0
R_10_12_10_3 Node10_12_10 Node11_12_10 0.9856000000000001
C_10_12_10 Node10_12_10 GND 1.1279296875e-09
I_10_12_11 GND Node10_12_11 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 3.906249999999999e-08A 39.96us 3.906249999999999e-08A 43.29us 3.906249999999999e-08A 46.620000000000005us 3.906249999999999e-08A 49.95us 3.906249999999999e-08A 53.28us 3.906249999999999e-08A 56.61us 3.906249999999999e-08A 59.94us 3.906249999999999e-08A 63.27us 3.906249999999999e-08A 66.6us 3.906249999999999e-08A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_10_12_11_1 Node10_12_11 Node10_12_12 15400.0
R_10_12_11_2 Node10_12_11 Node10_13_11 15400.0
R_10_12_11_3 Node10_12_11 Node11_12_11 0.9856000000000001
C_10_12_11 Node10_12_11 GND 1.1279296875e-09
I_10_12_12 GND Node10_12_12 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 3.906249999999999e-08A 39.96us 3.906249999999999e-08A 43.29us 3.906249999999999e-08A 46.620000000000005us 3.906249999999999e-08A 49.95us 3.906249999999999e-08A 53.28us 3.906249999999999e-08A 56.61us 3.906249999999999e-08A 59.94us 3.906249999999999e-08A 63.27us 3.906249999999999e-08A 66.6us 3.906249999999999e-08A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_10_12_12_1 Node10_12_12 Node10_12_13 15400.0
R_10_12_12_2 Node10_12_12 Node10_13_12 15400.0
R_10_12_12_3 Node10_12_12 Node11_12_12 0.9856000000000001
C_10_12_12 Node10_12_12 GND 1.1279296875e-09
I_10_12_13 GND Node10_12_13 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 3.906249999999999e-08A 39.96us 3.906249999999999e-08A 43.29us 3.906249999999999e-08A 46.620000000000005us 3.906249999999999e-08A 49.95us 3.906249999999999e-08A 53.28us 3.906249999999999e-08A 56.61us 3.906249999999999e-08A 59.94us 3.906249999999999e-08A 63.27us 3.906249999999999e-08A 66.6us 3.906249999999999e-08A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_10_12_13_1 Node10_12_13 Node10_12_14 15400.0
R_10_12_13_2 Node10_12_13 Node10_13_13 15400.0
R_10_12_13_3 Node10_12_13 Node11_12_13 0.9856000000000001
C_10_12_13 Node10_12_13 GND 1.1279296875e-09
I_10_12_14 GND Node10_12_14 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 3.906249999999999e-08A 39.96us 3.906249999999999e-08A 43.29us 3.906249999999999e-08A 46.620000000000005us 3.906249999999999e-08A 49.95us 3.906249999999999e-08A 53.28us 3.906249999999999e-08A 56.61us 3.906249999999999e-08A 59.94us 3.906249999999999e-08A 63.27us 3.906249999999999e-08A 66.6us 3.906249999999999e-08A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_10_12_14_1 Node10_12_14 Node10_12_15 15399.999999999993
R_10_12_14_2 Node10_12_14 Node10_13_14 15400.0
R_10_12_14_3 Node10_12_14 Node11_12_14 0.9856000000000001
C_10_12_14 Node10_12_14 GND 1.1279296875e-09
I_10_12_15 GND Node10_12_15 PWL(0s 0A 3.33us 3.906250000000002e-08A 6.66us 3.906250000000002e-08A 9.99us 3.906250000000002e-08A 13.32us 3.906250000000002e-08A 16.65us 3.906250000000002e-08A 19.98us 3.906250000000002e-08A 23.310000000000002us 3.906250000000002e-08A 26.64us 3.906250000000002e-08A 29.97us 3.906250000000002e-08A 33.3us 3.906250000000002e-08A 36.63us 3.906250000000002e-08A 39.96us 3.906250000000002e-08A 43.29us 3.906250000000002e-08A 46.620000000000005us 3.906250000000002e-08A 49.95us 3.906250000000002e-08A 53.28us 3.906250000000002e-08A 56.61us 3.906250000000002e-08A 59.94us 3.906250000000002e-08A 63.27us 3.906250000000002e-08A 66.6us 3.906250000000002e-08A 69.93us 3.906250000000002e-08A 73.26us 3.906250000000002e-08A 76.59us 3.906250000000002e-08A 79.92us 3.906250000000002e-08A 83.25us 3.906250000000002e-08A 86.58us 3.906250000000002e-08A 89.91us 3.906250000000002e-08A 93.24000000000001us 3.906250000000002e-08A 96.57000000000001us 3.906250000000002e-08A 99.9us 3.906250000000002e-08A)
R_10_12_15_2 Node10_12_15 Node10_13_15 15399.999999999987
R_10_12_15_3 Node10_12_15 Node11_12_15 0.9855999999999993
C_10_12_15 Node10_12_15 GND 1.127929687500001e-09
I_10_13_0 GND Node10_13_0 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 3.906249999999999e-08A 39.96us 3.906249999999999e-08A 43.29us 3.906249999999999e-08A 46.620000000000005us 3.906249999999999e-08A 49.95us 3.906249999999999e-08A 53.28us 3.906249999999999e-08A 56.61us 3.906249999999999e-08A 59.94us 3.906249999999999e-08A 63.27us 3.906249999999999e-08A 66.6us 3.906249999999999e-08A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_10_13_0_1 Node10_13_0 Node10_13_1 15400.0
R_10_13_0_2 Node10_13_0 Node10_14_0 15400.0
R_10_13_0_3 Node10_13_0 Node11_13_0 0.9856000000000001
C_10_13_0 Node10_13_0 GND 1.1279296875e-09
I_10_13_1 GND Node10_13_1 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 3.906249999999999e-08A 39.96us 3.906249999999999e-08A 43.29us 3.906249999999999e-08A 46.620000000000005us 3.906249999999999e-08A 49.95us 3.906249999999999e-08A 53.28us 3.906249999999999e-08A 56.61us 3.906249999999999e-08A 59.94us 3.906249999999999e-08A 63.27us 3.906249999999999e-08A 66.6us 3.906249999999999e-08A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_10_13_1_1 Node10_13_1 Node10_13_2 15400.0
R_10_13_1_2 Node10_13_1 Node10_14_1 15400.0
R_10_13_1_3 Node10_13_1 Node11_13_1 0.9856000000000001
C_10_13_1 Node10_13_1 GND 1.1279296875e-09
I_10_13_2 GND Node10_13_2 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 3.906249999999999e-08A 39.96us 3.906249999999999e-08A 43.29us 3.906249999999999e-08A 46.620000000000005us 3.906249999999999e-08A 49.95us 3.906249999999999e-08A 53.28us 3.906249999999999e-08A 56.61us 3.906249999999999e-08A 59.94us 3.906249999999999e-08A 63.27us 3.906249999999999e-08A 66.6us 3.906249999999999e-08A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_10_13_2_1 Node10_13_2 Node10_13_3 15400.0
R_10_13_2_2 Node10_13_2 Node10_14_2 15400.0
R_10_13_2_3 Node10_13_2 Node11_13_2 0.9856000000000001
C_10_13_2 Node10_13_2 GND 1.1279296875e-09
I_10_13_3 GND Node10_13_3 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 3.906249999999999e-08A 39.96us 3.906249999999999e-08A 43.29us 3.906249999999999e-08A 46.620000000000005us 3.906249999999999e-08A 49.95us 3.906249999999999e-08A 53.28us 3.906249999999999e-08A 56.61us 3.906249999999999e-08A 59.94us 3.906249999999999e-08A 63.27us 3.906249999999999e-08A 66.6us 3.906249999999999e-08A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_10_13_3_1 Node10_13_3 Node10_13_4 15400.0
R_10_13_3_2 Node10_13_3 Node10_14_3 15400.0
R_10_13_3_3 Node10_13_3 Node11_13_3 0.9856000000000001
C_10_13_3 Node10_13_3 GND 1.1279296875e-09
I_10_13_4 GND Node10_13_4 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 3.906249999999999e-08A 39.96us 3.906249999999999e-08A 43.29us 3.906249999999999e-08A 46.620000000000005us 3.906249999999999e-08A 49.95us 3.906249999999999e-08A 53.28us 3.906249999999999e-08A 56.61us 3.906249999999999e-08A 59.94us 3.906249999999999e-08A 63.27us 3.906249999999999e-08A 66.6us 3.906249999999999e-08A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_10_13_4_1 Node10_13_4 Node10_13_5 15400.0
R_10_13_4_2 Node10_13_4 Node10_14_4 15400.0
R_10_13_4_3 Node10_13_4 Node11_13_4 0.9856000000000001
C_10_13_4 Node10_13_4 GND 1.1279296875e-09
I_10_13_5 GND Node10_13_5 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 3.906249999999999e-08A 39.96us 3.906249999999999e-08A 43.29us 3.906249999999999e-08A 46.620000000000005us 3.906249999999999e-08A 49.95us 3.906249999999999e-08A 53.28us 3.906249999999999e-08A 56.61us 3.906249999999999e-08A 59.94us 3.906249999999999e-08A 63.27us 3.906249999999999e-08A 66.6us 3.906249999999999e-08A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_10_13_5_1 Node10_13_5 Node10_13_6 15400.0
R_10_13_5_2 Node10_13_5 Node10_14_5 15400.0
R_10_13_5_3 Node10_13_5 Node11_13_5 0.9856000000000001
C_10_13_5 Node10_13_5 GND 1.1279296875e-09
I_10_13_6 GND Node10_13_6 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 3.906249999999999e-08A 39.96us 3.906249999999999e-08A 43.29us 3.906249999999999e-08A 46.620000000000005us 3.906249999999999e-08A 49.95us 3.906249999999999e-08A 53.28us 3.906249999999999e-08A 56.61us 3.906249999999999e-08A 59.94us 3.906249999999999e-08A 63.27us 3.906249999999999e-08A 66.6us 3.906249999999999e-08A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_10_13_6_1 Node10_13_6 Node10_13_7 15400.0
R_10_13_6_2 Node10_13_6 Node10_14_6 15400.0
R_10_13_6_3 Node10_13_6 Node11_13_6 0.9856000000000001
C_10_13_6 Node10_13_6 GND 1.1279296875e-09
I_10_13_7 GND Node10_13_7 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 3.906249999999999e-08A 39.96us 3.906249999999999e-08A 43.29us 3.906249999999999e-08A 46.620000000000005us 3.906249999999999e-08A 49.95us 3.906249999999999e-08A 53.28us 3.906249999999999e-08A 56.61us 3.906249999999999e-08A 59.94us 3.906249999999999e-08A 63.27us 3.906249999999999e-08A 66.6us 3.906249999999999e-08A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_10_13_7_1 Node10_13_7 Node10_13_8 15400.0
R_10_13_7_2 Node10_13_7 Node10_14_7 15400.0
R_10_13_7_3 Node10_13_7 Node11_13_7 0.9856000000000001
C_10_13_7 Node10_13_7 GND 1.1279296875e-09
I_10_13_8 GND Node10_13_8 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 3.906249999999999e-08A 39.96us 3.906249999999999e-08A 43.29us 3.906249999999999e-08A 46.620000000000005us 3.906249999999999e-08A 49.95us 3.906249999999999e-08A 53.28us 3.906249999999999e-08A 56.61us 3.906249999999999e-08A 59.94us 3.906249999999999e-08A 63.27us 3.906249999999999e-08A 66.6us 3.906249999999999e-08A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_10_13_8_1 Node10_13_8 Node10_13_9 15400.0
R_10_13_8_2 Node10_13_8 Node10_14_8 15400.0
R_10_13_8_3 Node10_13_8 Node11_13_8 0.9856000000000001
C_10_13_8 Node10_13_8 GND 1.1279296875e-09
I_10_13_9 GND Node10_13_9 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 3.906249999999999e-08A 39.96us 3.906249999999999e-08A 43.29us 3.906249999999999e-08A 46.620000000000005us 3.906249999999999e-08A 49.95us 3.906249999999999e-08A 53.28us 3.906249999999999e-08A 56.61us 3.906249999999999e-08A 59.94us 3.906249999999999e-08A 63.27us 3.906249999999999e-08A 66.6us 3.906249999999999e-08A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_10_13_9_1 Node10_13_9 Node10_13_10 15400.0
R_10_13_9_2 Node10_13_9 Node10_14_9 15400.0
R_10_13_9_3 Node10_13_9 Node11_13_9 0.9856000000000001
C_10_13_9 Node10_13_9 GND 1.1279296875e-09
I_10_13_10 GND Node10_13_10 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 3.906249999999999e-08A 39.96us 3.906249999999999e-08A 43.29us 3.906249999999999e-08A 46.620000000000005us 3.906249999999999e-08A 49.95us 3.906249999999999e-08A 53.28us 3.906249999999999e-08A 56.61us 3.906249999999999e-08A 59.94us 3.906249999999999e-08A 63.27us 3.906249999999999e-08A 66.6us 3.906249999999999e-08A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_10_13_10_1 Node10_13_10 Node10_13_11 15400.0
R_10_13_10_2 Node10_13_10 Node10_14_10 15400.0
R_10_13_10_3 Node10_13_10 Node11_13_10 0.9856000000000001
C_10_13_10 Node10_13_10 GND 1.1279296875e-09
I_10_13_11 GND Node10_13_11 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 3.906249999999999e-08A 39.96us 3.906249999999999e-08A 43.29us 3.906249999999999e-08A 46.620000000000005us 3.906249999999999e-08A 49.95us 3.906249999999999e-08A 53.28us 3.906249999999999e-08A 56.61us 3.906249999999999e-08A 59.94us 3.906249999999999e-08A 63.27us 3.906249999999999e-08A 66.6us 3.906249999999999e-08A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_10_13_11_1 Node10_13_11 Node10_13_12 15400.0
R_10_13_11_2 Node10_13_11 Node10_14_11 15400.0
R_10_13_11_3 Node10_13_11 Node11_13_11 0.9856000000000001
C_10_13_11 Node10_13_11 GND 1.1279296875e-09
I_10_13_12 GND Node10_13_12 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 3.906249999999999e-08A 39.96us 3.906249999999999e-08A 43.29us 3.906249999999999e-08A 46.620000000000005us 3.906249999999999e-08A 49.95us 3.906249999999999e-08A 53.28us 3.906249999999999e-08A 56.61us 3.906249999999999e-08A 59.94us 3.906249999999999e-08A 63.27us 3.906249999999999e-08A 66.6us 3.906249999999999e-08A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_10_13_12_1 Node10_13_12 Node10_13_13 15400.0
R_10_13_12_2 Node10_13_12 Node10_14_12 15400.0
R_10_13_12_3 Node10_13_12 Node11_13_12 0.9856000000000001
C_10_13_12 Node10_13_12 GND 1.1279296875e-09
I_10_13_13 GND Node10_13_13 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 3.906249999999999e-08A 39.96us 3.906249999999999e-08A 43.29us 3.906249999999999e-08A 46.620000000000005us 3.906249999999999e-08A 49.95us 3.906249999999999e-08A 53.28us 3.906249999999999e-08A 56.61us 3.906249999999999e-08A 59.94us 3.906249999999999e-08A 63.27us 3.906249999999999e-08A 66.6us 3.906249999999999e-08A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_10_13_13_1 Node10_13_13 Node10_13_14 15400.0
R_10_13_13_2 Node10_13_13 Node10_14_13 15400.0
R_10_13_13_3 Node10_13_13 Node11_13_13 0.9856000000000001
C_10_13_13 Node10_13_13 GND 1.1279296875e-09
I_10_13_14 GND Node10_13_14 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 3.906249999999999e-08A 39.96us 3.906249999999999e-08A 43.29us 3.906249999999999e-08A 46.620000000000005us 3.906249999999999e-08A 49.95us 3.906249999999999e-08A 53.28us 3.906249999999999e-08A 56.61us 3.906249999999999e-08A 59.94us 3.906249999999999e-08A 63.27us 3.906249999999999e-08A 66.6us 3.906249999999999e-08A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_10_13_14_1 Node10_13_14 Node10_13_15 15399.999999999993
R_10_13_14_2 Node10_13_14 Node10_14_14 15400.0
R_10_13_14_3 Node10_13_14 Node11_13_14 0.9856000000000001
C_10_13_14 Node10_13_14 GND 1.1279296875e-09
I_10_13_15 GND Node10_13_15 PWL(0s 0A 3.33us 3.906250000000002e-08A 6.66us 3.906250000000002e-08A 9.99us 3.906250000000002e-08A 13.32us 3.906250000000002e-08A 16.65us 3.906250000000002e-08A 19.98us 3.906250000000002e-08A 23.310000000000002us 3.906250000000002e-08A 26.64us 3.906250000000002e-08A 29.97us 3.906250000000002e-08A 33.3us 3.906250000000002e-08A 36.63us 3.906250000000002e-08A 39.96us 3.906250000000002e-08A 43.29us 3.906250000000002e-08A 46.620000000000005us 3.906250000000002e-08A 49.95us 3.906250000000002e-08A 53.28us 3.906250000000002e-08A 56.61us 3.906250000000002e-08A 59.94us 3.906250000000002e-08A 63.27us 3.906250000000002e-08A 66.6us 3.906250000000002e-08A 69.93us 3.906250000000002e-08A 73.26us 3.906250000000002e-08A 76.59us 3.906250000000002e-08A 79.92us 3.906250000000002e-08A 83.25us 3.906250000000002e-08A 86.58us 3.906250000000002e-08A 89.91us 3.906250000000002e-08A 93.24000000000001us 3.906250000000002e-08A 96.57000000000001us 3.906250000000002e-08A 99.9us 3.906250000000002e-08A)
R_10_13_15_2 Node10_13_15 Node10_14_15 15399.999999999987
R_10_13_15_3 Node10_13_15 Node11_13_15 0.9855999999999993
C_10_13_15 Node10_13_15 GND 1.127929687500001e-09
I_10_14_0 GND Node10_14_0 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 3.906249999999999e-08A 39.96us 3.906249999999999e-08A 43.29us 3.906249999999999e-08A 46.620000000000005us 3.906249999999999e-08A 49.95us 3.906249999999999e-08A 53.28us 3.906249999999999e-08A 56.61us 3.906249999999999e-08A 59.94us 3.906249999999999e-08A 63.27us 3.906249999999999e-08A 66.6us 3.906249999999999e-08A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_10_14_0_1 Node10_14_0 Node10_14_1 15400.0
R_10_14_0_2 Node10_14_0 Node10_15_0 15400.0
R_10_14_0_3 Node10_14_0 Node11_14_0 0.9856000000000001
C_10_14_0 Node10_14_0 GND 1.1279296875e-09
I_10_14_1 GND Node10_14_1 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 3.906249999999999e-08A 39.96us 3.906249999999999e-08A 43.29us 3.906249999999999e-08A 46.620000000000005us 3.906249999999999e-08A 49.95us 3.906249999999999e-08A 53.28us 3.906249999999999e-08A 56.61us 3.906249999999999e-08A 59.94us 3.906249999999999e-08A 63.27us 3.906249999999999e-08A 66.6us 3.906249999999999e-08A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_10_14_1_1 Node10_14_1 Node10_14_2 15400.0
R_10_14_1_2 Node10_14_1 Node10_15_1 15400.0
R_10_14_1_3 Node10_14_1 Node11_14_1 0.9856000000000001
C_10_14_1 Node10_14_1 GND 1.1279296875e-09
I_10_14_2 GND Node10_14_2 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 3.906249999999999e-08A 39.96us 3.906249999999999e-08A 43.29us 3.906249999999999e-08A 46.620000000000005us 3.906249999999999e-08A 49.95us 3.906249999999999e-08A 53.28us 3.906249999999999e-08A 56.61us 3.906249999999999e-08A 59.94us 3.906249999999999e-08A 63.27us 3.906249999999999e-08A 66.6us 3.906249999999999e-08A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_10_14_2_1 Node10_14_2 Node10_14_3 15400.0
R_10_14_2_2 Node10_14_2 Node10_15_2 15400.0
R_10_14_2_3 Node10_14_2 Node11_14_2 0.9856000000000001
C_10_14_2 Node10_14_2 GND 1.1279296875e-09
I_10_14_3 GND Node10_14_3 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 3.906249999999999e-08A 39.96us 3.906249999999999e-08A 43.29us 3.906249999999999e-08A 46.620000000000005us 3.906249999999999e-08A 49.95us 3.906249999999999e-08A 53.28us 3.906249999999999e-08A 56.61us 3.906249999999999e-08A 59.94us 3.906249999999999e-08A 63.27us 3.906249999999999e-08A 66.6us 3.906249999999999e-08A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_10_14_3_1 Node10_14_3 Node10_14_4 15400.0
R_10_14_3_2 Node10_14_3 Node10_15_3 15400.0
R_10_14_3_3 Node10_14_3 Node11_14_3 0.9856000000000001
C_10_14_3 Node10_14_3 GND 1.1279296875e-09
I_10_14_4 GND Node10_14_4 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 3.906249999999999e-08A 39.96us 3.906249999999999e-08A 43.29us 3.906249999999999e-08A 46.620000000000005us 3.906249999999999e-08A 49.95us 3.906249999999999e-08A 53.28us 3.906249999999999e-08A 56.61us 3.906249999999999e-08A 59.94us 3.906249999999999e-08A 63.27us 3.906249999999999e-08A 66.6us 3.906249999999999e-08A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_10_14_4_1 Node10_14_4 Node10_14_5 15400.0
R_10_14_4_2 Node10_14_4 Node10_15_4 15400.0
R_10_14_4_3 Node10_14_4 Node11_14_4 0.9856000000000001
C_10_14_4 Node10_14_4 GND 1.1279296875e-09
I_10_14_5 GND Node10_14_5 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 3.906249999999999e-08A 39.96us 3.906249999999999e-08A 43.29us 3.906249999999999e-08A 46.620000000000005us 3.906249999999999e-08A 49.95us 3.906249999999999e-08A 53.28us 3.906249999999999e-08A 56.61us 3.906249999999999e-08A 59.94us 3.906249999999999e-08A 63.27us 3.906249999999999e-08A 66.6us 3.906249999999999e-08A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_10_14_5_1 Node10_14_5 Node10_14_6 15400.0
R_10_14_5_2 Node10_14_5 Node10_15_5 15400.0
R_10_14_5_3 Node10_14_5 Node11_14_5 0.9856000000000001
C_10_14_5 Node10_14_5 GND 1.1279296875e-09
I_10_14_6 GND Node10_14_6 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 3.906249999999999e-08A 39.96us 3.906249999999999e-08A 43.29us 3.906249999999999e-08A 46.620000000000005us 3.906249999999999e-08A 49.95us 3.906249999999999e-08A 53.28us 3.906249999999999e-08A 56.61us 3.906249999999999e-08A 59.94us 3.906249999999999e-08A 63.27us 3.906249999999999e-08A 66.6us 3.906249999999999e-08A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_10_14_6_1 Node10_14_6 Node10_14_7 15400.0
R_10_14_6_2 Node10_14_6 Node10_15_6 15400.0
R_10_14_6_3 Node10_14_6 Node11_14_6 0.9856000000000001
C_10_14_6 Node10_14_6 GND 1.1279296875e-09
I_10_14_7 GND Node10_14_7 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 3.906249999999999e-08A 39.96us 3.906249999999999e-08A 43.29us 3.906249999999999e-08A 46.620000000000005us 3.906249999999999e-08A 49.95us 3.906249999999999e-08A 53.28us 3.906249999999999e-08A 56.61us 3.906249999999999e-08A 59.94us 3.906249999999999e-08A 63.27us 3.906249999999999e-08A 66.6us 3.906249999999999e-08A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_10_14_7_1 Node10_14_7 Node10_14_8 15400.0
R_10_14_7_2 Node10_14_7 Node10_15_7 15400.0
R_10_14_7_3 Node10_14_7 Node11_14_7 0.9856000000000001
C_10_14_7 Node10_14_7 GND 1.1279296875e-09
I_10_14_8 GND Node10_14_8 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 3.906249999999999e-08A 39.96us 3.906249999999999e-08A 43.29us 3.906249999999999e-08A 46.620000000000005us 3.906249999999999e-08A 49.95us 3.906249999999999e-08A 53.28us 3.906249999999999e-08A 56.61us 3.906249999999999e-08A 59.94us 3.906249999999999e-08A 63.27us 3.906249999999999e-08A 66.6us 3.906249999999999e-08A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_10_14_8_1 Node10_14_8 Node10_14_9 15400.0
R_10_14_8_2 Node10_14_8 Node10_15_8 15400.0
R_10_14_8_3 Node10_14_8 Node11_14_8 0.9856000000000001
C_10_14_8 Node10_14_8 GND 1.1279296875e-09
I_10_14_9 GND Node10_14_9 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 3.906249999999999e-08A 39.96us 3.906249999999999e-08A 43.29us 3.906249999999999e-08A 46.620000000000005us 3.906249999999999e-08A 49.95us 3.906249999999999e-08A 53.28us 3.906249999999999e-08A 56.61us 3.906249999999999e-08A 59.94us 3.906249999999999e-08A 63.27us 3.906249999999999e-08A 66.6us 3.906249999999999e-08A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_10_14_9_1 Node10_14_9 Node10_14_10 15400.0
R_10_14_9_2 Node10_14_9 Node10_15_9 15400.0
R_10_14_9_3 Node10_14_9 Node11_14_9 0.9856000000000001
C_10_14_9 Node10_14_9 GND 1.1279296875e-09
I_10_14_10 GND Node10_14_10 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 3.906249999999999e-08A 39.96us 3.906249999999999e-08A 43.29us 3.906249999999999e-08A 46.620000000000005us 3.906249999999999e-08A 49.95us 3.906249999999999e-08A 53.28us 3.906249999999999e-08A 56.61us 3.906249999999999e-08A 59.94us 3.906249999999999e-08A 63.27us 3.906249999999999e-08A 66.6us 3.906249999999999e-08A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_10_14_10_1 Node10_14_10 Node10_14_11 15400.0
R_10_14_10_2 Node10_14_10 Node10_15_10 15400.0
R_10_14_10_3 Node10_14_10 Node11_14_10 0.9856000000000001
C_10_14_10 Node10_14_10 GND 1.1279296875e-09
I_10_14_11 GND Node10_14_11 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 3.906249999999999e-08A 39.96us 3.906249999999999e-08A 43.29us 3.906249999999999e-08A 46.620000000000005us 3.906249999999999e-08A 49.95us 3.906249999999999e-08A 53.28us 3.906249999999999e-08A 56.61us 3.906249999999999e-08A 59.94us 3.906249999999999e-08A 63.27us 3.906249999999999e-08A 66.6us 3.906249999999999e-08A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_10_14_11_1 Node10_14_11 Node10_14_12 15400.0
R_10_14_11_2 Node10_14_11 Node10_15_11 15400.0
R_10_14_11_3 Node10_14_11 Node11_14_11 0.9856000000000001
C_10_14_11 Node10_14_11 GND 1.1279296875e-09
I_10_14_12 GND Node10_14_12 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 3.906249999999999e-08A 39.96us 3.906249999999999e-08A 43.29us 3.906249999999999e-08A 46.620000000000005us 3.906249999999999e-08A 49.95us 3.906249999999999e-08A 53.28us 3.906249999999999e-08A 56.61us 3.906249999999999e-08A 59.94us 3.906249999999999e-08A 63.27us 3.906249999999999e-08A 66.6us 3.906249999999999e-08A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_10_14_12_1 Node10_14_12 Node10_14_13 15400.0
R_10_14_12_2 Node10_14_12 Node10_15_12 15400.0
R_10_14_12_3 Node10_14_12 Node11_14_12 0.9856000000000001
C_10_14_12 Node10_14_12 GND 1.1279296875e-09
I_10_14_13 GND Node10_14_13 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 3.906249999999999e-08A 39.96us 3.906249999999999e-08A 43.29us 3.906249999999999e-08A 46.620000000000005us 3.906249999999999e-08A 49.95us 3.906249999999999e-08A 53.28us 3.906249999999999e-08A 56.61us 3.906249999999999e-08A 59.94us 3.906249999999999e-08A 63.27us 3.906249999999999e-08A 66.6us 3.906249999999999e-08A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_10_14_13_1 Node10_14_13 Node10_14_14 15400.0
R_10_14_13_2 Node10_14_13 Node10_15_13 15400.0
R_10_14_13_3 Node10_14_13 Node11_14_13 0.9856000000000001
C_10_14_13 Node10_14_13 GND 1.1279296875e-09
I_10_14_14 GND Node10_14_14 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 3.906249999999999e-08A 39.96us 3.906249999999999e-08A 43.29us 3.906249999999999e-08A 46.620000000000005us 3.906249999999999e-08A 49.95us 3.906249999999999e-08A 53.28us 3.906249999999999e-08A 56.61us 3.906249999999999e-08A 59.94us 3.906249999999999e-08A 63.27us 3.906249999999999e-08A 66.6us 3.906249999999999e-08A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_10_14_14_1 Node10_14_14 Node10_14_15 15399.999999999993
R_10_14_14_2 Node10_14_14 Node10_15_14 15400.0
R_10_14_14_3 Node10_14_14 Node11_14_14 0.9856000000000001
C_10_14_14 Node10_14_14 GND 1.1279296875e-09
I_10_14_15 GND Node10_14_15 PWL(0s 0A 3.33us 3.906250000000002e-08A 6.66us 3.906250000000002e-08A 9.99us 3.906250000000002e-08A 13.32us 3.906250000000002e-08A 16.65us 3.906250000000002e-08A 19.98us 3.906250000000002e-08A 23.310000000000002us 3.906250000000002e-08A 26.64us 3.906250000000002e-08A 29.97us 3.906250000000002e-08A 33.3us 3.906250000000002e-08A 36.63us 3.906250000000002e-08A 39.96us 3.906250000000002e-08A 43.29us 3.906250000000002e-08A 46.620000000000005us 3.906250000000002e-08A 49.95us 3.906250000000002e-08A 53.28us 3.906250000000002e-08A 56.61us 3.906250000000002e-08A 59.94us 3.906250000000002e-08A 63.27us 3.906250000000002e-08A 66.6us 3.906250000000002e-08A 69.93us 3.906250000000002e-08A 73.26us 3.906250000000002e-08A 76.59us 3.906250000000002e-08A 79.92us 3.906250000000002e-08A 83.25us 3.906250000000002e-08A 86.58us 3.906250000000002e-08A 89.91us 3.906250000000002e-08A 93.24000000000001us 3.906250000000002e-08A 96.57000000000001us 3.906250000000002e-08A 99.9us 3.906250000000002e-08A)
R_10_14_15_2 Node10_14_15 Node10_15_15 15399.999999999985
R_10_14_15_3 Node10_14_15 Node11_14_15 0.9855999999999993
C_10_14_15 Node10_14_15 GND 1.127929687500001e-09
I_10_15_0 GND Node10_15_0 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 3.906249999999999e-08A 39.96us 3.906249999999999e-08A 43.29us 3.906249999999999e-08A 46.620000000000005us 3.906249999999999e-08A 49.95us 3.906249999999999e-08A 53.28us 3.906249999999999e-08A 56.61us 3.906249999999999e-08A 59.94us 3.906249999999999e-08A 63.27us 3.906249999999999e-08A 66.6us 3.906249999999999e-08A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_10_15_0_1 Node10_15_0 Node10_15_1 15400.0
R_10_15_0_3 Node10_15_0 Node11_15_0 0.9856000000000001
C_10_15_0 Node10_15_0 GND 1.1279296875e-09
I_10_15_1 GND Node10_15_1 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 3.906249999999999e-08A 39.96us 3.906249999999999e-08A 43.29us 3.906249999999999e-08A 46.620000000000005us 3.906249999999999e-08A 49.95us 3.906249999999999e-08A 53.28us 3.906249999999999e-08A 56.61us 3.906249999999999e-08A 59.94us 3.906249999999999e-08A 63.27us 3.906249999999999e-08A 66.6us 3.906249999999999e-08A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_10_15_1_1 Node10_15_1 Node10_15_2 15400.0
R_10_15_1_3 Node10_15_1 Node11_15_1 0.9856000000000001
C_10_15_1 Node10_15_1 GND 1.1279296875e-09
I_10_15_2 GND Node10_15_2 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 3.906249999999999e-08A 39.96us 3.906249999999999e-08A 43.29us 3.906249999999999e-08A 46.620000000000005us 3.906249999999999e-08A 49.95us 3.906249999999999e-08A 53.28us 3.906249999999999e-08A 56.61us 3.906249999999999e-08A 59.94us 3.906249999999999e-08A 63.27us 3.906249999999999e-08A 66.6us 3.906249999999999e-08A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_10_15_2_1 Node10_15_2 Node10_15_3 15400.0
R_10_15_2_3 Node10_15_2 Node11_15_2 0.9856000000000001
C_10_15_2 Node10_15_2 GND 1.1279296875e-09
I_10_15_3 GND Node10_15_3 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 3.906249999999999e-08A 39.96us 3.906249999999999e-08A 43.29us 3.906249999999999e-08A 46.620000000000005us 3.906249999999999e-08A 49.95us 3.906249999999999e-08A 53.28us 3.906249999999999e-08A 56.61us 3.906249999999999e-08A 59.94us 3.906249999999999e-08A 63.27us 3.906249999999999e-08A 66.6us 3.906249999999999e-08A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_10_15_3_1 Node10_15_3 Node10_15_4 15400.0
R_10_15_3_3 Node10_15_3 Node11_15_3 0.9856000000000001
C_10_15_3 Node10_15_3 GND 1.1279296875e-09
I_10_15_4 GND Node10_15_4 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 3.906249999999999e-08A 39.96us 3.906249999999999e-08A 43.29us 3.906249999999999e-08A 46.620000000000005us 3.906249999999999e-08A 49.95us 3.906249999999999e-08A 53.28us 3.906249999999999e-08A 56.61us 3.906249999999999e-08A 59.94us 3.906249999999999e-08A 63.27us 3.906249999999999e-08A 66.6us 3.906249999999999e-08A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_10_15_4_1 Node10_15_4 Node10_15_5 15400.0
R_10_15_4_3 Node10_15_4 Node11_15_4 0.9856000000000001
C_10_15_4 Node10_15_4 GND 1.1279296875e-09
I_10_15_5 GND Node10_15_5 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 3.906249999999999e-08A 39.96us 3.906249999999999e-08A 43.29us 3.906249999999999e-08A 46.620000000000005us 3.906249999999999e-08A 49.95us 3.906249999999999e-08A 53.28us 3.906249999999999e-08A 56.61us 3.906249999999999e-08A 59.94us 3.906249999999999e-08A 63.27us 3.906249999999999e-08A 66.6us 3.906249999999999e-08A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_10_15_5_1 Node10_15_5 Node10_15_6 15400.0
R_10_15_5_3 Node10_15_5 Node11_15_5 0.9856000000000001
C_10_15_5 Node10_15_5 GND 1.1279296875e-09
I_10_15_6 GND Node10_15_6 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 3.906249999999999e-08A 39.96us 3.906249999999999e-08A 43.29us 3.906249999999999e-08A 46.620000000000005us 3.906249999999999e-08A 49.95us 3.906249999999999e-08A 53.28us 3.906249999999999e-08A 56.61us 3.906249999999999e-08A 59.94us 3.906249999999999e-08A 63.27us 3.906249999999999e-08A 66.6us 3.906249999999999e-08A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_10_15_6_1 Node10_15_6 Node10_15_7 15400.0
R_10_15_6_3 Node10_15_6 Node11_15_6 0.9856000000000001
C_10_15_6 Node10_15_6 GND 1.1279296875e-09
I_10_15_7 GND Node10_15_7 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 3.906249999999999e-08A 39.96us 3.906249999999999e-08A 43.29us 3.906249999999999e-08A 46.620000000000005us 3.906249999999999e-08A 49.95us 3.906249999999999e-08A 53.28us 3.906249999999999e-08A 56.61us 3.906249999999999e-08A 59.94us 3.906249999999999e-08A 63.27us 3.906249999999999e-08A 66.6us 3.906249999999999e-08A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_10_15_7_1 Node10_15_7 Node10_15_8 15400.0
R_10_15_7_3 Node10_15_7 Node11_15_7 0.9856000000000001
C_10_15_7 Node10_15_7 GND 1.1279296875e-09
I_10_15_8 GND Node10_15_8 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 3.906249999999999e-08A 39.96us 3.906249999999999e-08A 43.29us 3.906249999999999e-08A 46.620000000000005us 3.906249999999999e-08A 49.95us 3.906249999999999e-08A 53.28us 3.906249999999999e-08A 56.61us 3.906249999999999e-08A 59.94us 3.906249999999999e-08A 63.27us 3.906249999999999e-08A 66.6us 3.906249999999999e-08A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_10_15_8_1 Node10_15_8 Node10_15_9 15400.0
R_10_15_8_3 Node10_15_8 Node11_15_8 0.9856000000000001
C_10_15_8 Node10_15_8 GND 1.1279296875e-09
I_10_15_9 GND Node10_15_9 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 3.906249999999999e-08A 39.96us 3.906249999999999e-08A 43.29us 3.906249999999999e-08A 46.620000000000005us 3.906249999999999e-08A 49.95us 3.906249999999999e-08A 53.28us 3.906249999999999e-08A 56.61us 3.906249999999999e-08A 59.94us 3.906249999999999e-08A 63.27us 3.906249999999999e-08A 66.6us 3.906249999999999e-08A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_10_15_9_1 Node10_15_9 Node10_15_10 15400.0
R_10_15_9_3 Node10_15_9 Node11_15_9 0.9856000000000001
C_10_15_9 Node10_15_9 GND 1.1279296875e-09
I_10_15_10 GND Node10_15_10 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 3.906249999999999e-08A 39.96us 3.906249999999999e-08A 43.29us 3.906249999999999e-08A 46.620000000000005us 3.906249999999999e-08A 49.95us 3.906249999999999e-08A 53.28us 3.906249999999999e-08A 56.61us 3.906249999999999e-08A 59.94us 3.906249999999999e-08A 63.27us 3.906249999999999e-08A 66.6us 3.906249999999999e-08A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_10_15_10_1 Node10_15_10 Node10_15_11 15400.0
R_10_15_10_3 Node10_15_10 Node11_15_10 0.9856000000000001
C_10_15_10 Node10_15_10 GND 1.1279296875e-09
I_10_15_11 GND Node10_15_11 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 3.906249999999999e-08A 39.96us 3.906249999999999e-08A 43.29us 3.906249999999999e-08A 46.620000000000005us 3.906249999999999e-08A 49.95us 3.906249999999999e-08A 53.28us 3.906249999999999e-08A 56.61us 3.906249999999999e-08A 59.94us 3.906249999999999e-08A 63.27us 3.906249999999999e-08A 66.6us 3.906249999999999e-08A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_10_15_11_1 Node10_15_11 Node10_15_12 15400.0
R_10_15_11_3 Node10_15_11 Node11_15_11 0.9856000000000001
C_10_15_11 Node10_15_11 GND 1.1279296875e-09
I_10_15_12 GND Node10_15_12 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 3.906249999999999e-08A 39.96us 3.906249999999999e-08A 43.29us 3.906249999999999e-08A 46.620000000000005us 3.906249999999999e-08A 49.95us 3.906249999999999e-08A 53.28us 3.906249999999999e-08A 56.61us 3.906249999999999e-08A 59.94us 3.906249999999999e-08A 63.27us 3.906249999999999e-08A 66.6us 3.906249999999999e-08A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_10_15_12_1 Node10_15_12 Node10_15_13 15400.0
R_10_15_12_3 Node10_15_12 Node11_15_12 0.9856000000000001
C_10_15_12 Node10_15_12 GND 1.1279296875e-09
I_10_15_13 GND Node10_15_13 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 3.906249999999999e-08A 39.96us 3.906249999999999e-08A 43.29us 3.906249999999999e-08A 46.620000000000005us 3.906249999999999e-08A 49.95us 3.906249999999999e-08A 53.28us 3.906249999999999e-08A 56.61us 3.906249999999999e-08A 59.94us 3.906249999999999e-08A 63.27us 3.906249999999999e-08A 66.6us 3.906249999999999e-08A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_10_15_13_1 Node10_15_13 Node10_15_14 15400.0
R_10_15_13_3 Node10_15_13 Node11_15_13 0.9856000000000001
C_10_15_13 Node10_15_13 GND 1.1279296875e-09
I_10_15_14 GND Node10_15_14 PWL(0s 0A 3.33us 3.906249999999999e-08A 6.66us 3.906249999999999e-08A 9.99us 3.906249999999999e-08A 13.32us 3.906249999999999e-08A 16.65us 3.906249999999999e-08A 19.98us 3.906249999999999e-08A 23.310000000000002us 3.906249999999999e-08A 26.64us 3.906249999999999e-08A 29.97us 3.906249999999999e-08A 33.3us 3.906249999999999e-08A 36.63us 3.906249999999999e-08A 39.96us 3.906249999999999e-08A 43.29us 3.906249999999999e-08A 46.620000000000005us 3.906249999999999e-08A 49.95us 3.906249999999999e-08A 53.28us 3.906249999999999e-08A 56.61us 3.906249999999999e-08A 59.94us 3.906249999999999e-08A 63.27us 3.906249999999999e-08A 66.6us 3.906249999999999e-08A 69.93us 3.906249999999999e-08A 73.26us 3.906249999999999e-08A 76.59us 3.906249999999999e-08A 79.92us 3.906249999999999e-08A 83.25us 3.906249999999999e-08A 86.58us 3.906249999999999e-08A 89.91us 3.906249999999999e-08A 93.24000000000001us 3.906249999999999e-08A 96.57000000000001us 3.906249999999999e-08A 99.9us 3.906249999999999e-08A)
R_10_15_14_1 Node10_15_14 Node10_15_15 15399.999999999993
R_10_15_14_3 Node10_15_14 Node11_15_14 0.9856000000000001
C_10_15_14 Node10_15_14 GND 1.1279296875e-09
I_10_15_15 GND Node10_15_15 PWL(0s 0A 3.33us 3.9062500000000036e-08A 6.66us 3.9062500000000036e-08A 9.99us 3.9062500000000036e-08A 13.32us 3.9062500000000036e-08A 16.65us 3.9062500000000036e-08A 19.98us 3.9062500000000036e-08A 23.310000000000002us 3.9062500000000036e-08A 26.64us 3.9062500000000036e-08A 29.97us 3.9062500000000036e-08A 33.3us 3.9062500000000036e-08A 36.63us 3.9062500000000036e-08A 39.96us 3.9062500000000036e-08A 43.29us 3.9062500000000036e-08A 46.620000000000005us 3.9062500000000036e-08A 49.95us 3.9062500000000036e-08A 53.28us 3.9062500000000036e-08A 56.61us 3.9062500000000036e-08A 59.94us 3.9062500000000036e-08A 63.27us 3.9062500000000036e-08A 66.6us 3.9062500000000036e-08A 69.93us 3.9062500000000036e-08A 73.26us 3.9062500000000036e-08A 76.59us 3.9062500000000036e-08A 79.92us 3.9062500000000036e-08A 83.25us 3.9062500000000036e-08A 86.58us 3.9062500000000036e-08A 89.91us 3.9062500000000036e-08A 93.24000000000001us 3.9062500000000036e-08A 96.57000000000001us 3.9062500000000036e-08A 99.9us 3.9062500000000036e-08A)
R_10_15_15_3 Node10_15_15 Node11_15_15 0.985599999999999
C_10_15_15 Node10_15_15 GND 1.1279296875000012e-09
R_11_0_0_1 Node11_0_0 Node11_0_1 101.3157894736843
R_11_0_0_2 Node11_0_0 Node11_1_0 101.31578947368426
R_11_0_0_3 Node11_0_0 Node12_0_0 149.81120000000016
C_11_0_0 Node11_0_0 GND 1.7144531249999985e-07
R_11_0_1_1 Node11_0_1 Node11_0_2 101.3157894736843
R_11_0_1_2 Node11_0_1 Node11_1_1 101.31578947368426
R_11_0_1_3 Node11_0_1 Node12_0_1 149.81120000000016
C_11_0_1 Node11_0_1 GND 1.7144531249999985e-07
R_11_0_2_1 Node11_0_2 Node11_0_3 101.3157894736843
R_11_0_2_2 Node11_0_2 Node11_1_2 101.31578947368426
R_11_0_2_3 Node11_0_2 Node12_0_2 149.81120000000016
C_11_0_2 Node11_0_2 GND 1.7144531249999985e-07
R_11_0_3_1 Node11_0_3 Node11_0_4 101.3157894736843
R_11_0_3_2 Node11_0_3 Node11_1_3 101.31578947368426
R_11_0_3_3 Node11_0_3 Node12_0_3 149.81120000000016
C_11_0_3 Node11_0_3 GND 1.7144531249999985e-07
R_11_0_4_1 Node11_0_4 Node11_0_5 101.3157894736843
R_11_0_4_2 Node11_0_4 Node11_1_4 101.31578947368426
R_11_0_4_3 Node11_0_4 Node12_0_4 149.81120000000016
C_11_0_4 Node11_0_4 GND 1.7144531249999985e-07
R_11_0_5_1 Node11_0_5 Node11_0_6 101.3157894736843
R_11_0_5_2 Node11_0_5 Node11_1_5 101.31578947368426
R_11_0_5_3 Node11_0_5 Node12_0_5 149.81120000000016
C_11_0_5 Node11_0_5 GND 1.7144531249999985e-07
R_11_0_6_1 Node11_0_6 Node11_0_7 101.3157894736843
R_11_0_6_2 Node11_0_6 Node11_1_6 101.31578947368426
R_11_0_6_3 Node11_0_6 Node12_0_6 149.81120000000016
C_11_0_6 Node11_0_6 GND 1.7144531249999985e-07
R_11_0_7_1 Node11_0_7 Node11_0_8 101.3157894736843
R_11_0_7_2 Node11_0_7 Node11_1_7 101.31578947368426
R_11_0_7_3 Node11_0_7 Node12_0_7 149.81120000000016
C_11_0_7 Node11_0_7 GND 1.7144531249999985e-07
R_11_0_8_1 Node11_0_8 Node11_0_9 101.3157894736843
R_11_0_8_2 Node11_0_8 Node11_1_8 101.31578947368426
R_11_0_8_3 Node11_0_8 Node12_0_8 149.81120000000016
C_11_0_8 Node11_0_8 GND 1.7144531249999985e-07
R_11_0_9_1 Node11_0_9 Node11_0_10 101.3157894736843
R_11_0_9_2 Node11_0_9 Node11_1_9 101.31578947368426
R_11_0_9_3 Node11_0_9 Node12_0_9 149.81120000000016
C_11_0_9 Node11_0_9 GND 1.7144531249999985e-07
R_11_0_10_1 Node11_0_10 Node11_0_11 101.3157894736843
R_11_0_10_2 Node11_0_10 Node11_1_10 101.31578947368426
R_11_0_10_3 Node11_0_10 Node12_0_10 149.81120000000016
C_11_0_10 Node11_0_10 GND 1.7144531249999985e-07
R_11_0_11_1 Node11_0_11 Node11_0_12 101.3157894736843
R_11_0_11_2 Node11_0_11 Node11_1_11 101.31578947368426
R_11_0_11_3 Node11_0_11 Node12_0_11 149.81120000000016
C_11_0_11 Node11_0_11 GND 1.7144531249999985e-07
R_11_0_12_1 Node11_0_12 Node11_0_13 101.3157894736843
R_11_0_12_2 Node11_0_12 Node11_1_12 101.31578947368426
R_11_0_12_3 Node11_0_12 Node12_0_12 149.81120000000016
C_11_0_12 Node11_0_12 GND 1.7144531249999985e-07
R_11_0_13_1 Node11_0_13 Node11_0_14 101.3157894736843
R_11_0_13_2 Node11_0_13 Node11_1_13 101.31578947368426
R_11_0_13_3 Node11_0_13 Node12_0_13 149.81120000000016
C_11_0_13 Node11_0_13 GND 1.7144531249999985e-07
R_11_0_14_1 Node11_0_14 Node11_0_15 101.31578947368426
R_11_0_14_2 Node11_0_14 Node11_1_14 101.31578947368426
R_11_0_14_3 Node11_0_14 Node12_0_14 149.81120000000016
C_11_0_14 Node11_0_14 GND 1.7144531249999985e-07
R_11_0_15_2 Node11_0_15 Node11_1_15 101.31578947368418
R_11_0_15_3 Node11_0_15 Node12_0_15 149.8112
C_11_0_15 Node11_0_15 GND 1.714453125e-07
R_11_1_0_1 Node11_1_0 Node11_1_1 101.31578947368422
R_11_1_0_2 Node11_1_0 Node11_2_0 101.31578947368422
R_11_1_0_3 Node11_1_0 Node12_1_0 149.8112
C_11_1_0 Node11_1_0 GND 1.714453125e-07
R_11_1_1_1 Node11_1_1 Node11_1_2 101.31578947368422
R_11_1_1_2 Node11_1_1 Node11_2_1 101.31578947368422
R_11_1_1_3 Node11_1_1 Node12_1_1 149.8112
C_11_1_1 Node11_1_1 GND 1.714453125e-07
R_11_1_2_1 Node11_1_2 Node11_1_3 101.31578947368422
R_11_1_2_2 Node11_1_2 Node11_2_2 101.31578947368422
R_11_1_2_3 Node11_1_2 Node12_1_2 149.8112
C_11_1_2 Node11_1_2 GND 1.714453125e-07
R_11_1_3_1 Node11_1_3 Node11_1_4 101.31578947368422
R_11_1_3_2 Node11_1_3 Node11_2_3 101.31578947368422
R_11_1_3_3 Node11_1_3 Node12_1_3 149.8112
C_11_1_3 Node11_1_3 GND 1.714453125e-07
R_11_1_4_1 Node11_1_4 Node11_1_5 101.31578947368422
R_11_1_4_2 Node11_1_4 Node11_2_4 101.31578947368422
R_11_1_4_3 Node11_1_4 Node12_1_4 149.8112
C_11_1_4 Node11_1_4 GND 1.714453125e-07
R_11_1_5_1 Node11_1_5 Node11_1_6 101.31578947368422
R_11_1_5_2 Node11_1_5 Node11_2_5 101.31578947368422
R_11_1_5_3 Node11_1_5 Node12_1_5 149.8112
C_11_1_5 Node11_1_5 GND 1.714453125e-07
R_11_1_6_1 Node11_1_6 Node11_1_7 101.31578947368422
R_11_1_6_2 Node11_1_6 Node11_2_6 101.31578947368422
R_11_1_6_3 Node11_1_6 Node12_1_6 149.8112
C_11_1_6 Node11_1_6 GND 1.714453125e-07
R_11_1_7_1 Node11_1_7 Node11_1_8 101.31578947368422
R_11_1_7_2 Node11_1_7 Node11_2_7 101.31578947368422
R_11_1_7_3 Node11_1_7 Node12_1_7 149.8112
C_11_1_7 Node11_1_7 GND 1.714453125e-07
R_11_1_8_1 Node11_1_8 Node11_1_9 101.31578947368422
R_11_1_8_2 Node11_1_8 Node11_2_8 101.31578947368422
R_11_1_8_3 Node11_1_8 Node12_1_8 149.8112
C_11_1_8 Node11_1_8 GND 1.714453125e-07
R_11_1_9_1 Node11_1_9 Node11_1_10 101.31578947368422
R_11_1_9_2 Node11_1_9 Node11_2_9 101.31578947368422
R_11_1_9_3 Node11_1_9 Node12_1_9 149.8112
C_11_1_9 Node11_1_9 GND 1.714453125e-07
R_11_1_10_1 Node11_1_10 Node11_1_11 101.31578947368422
R_11_1_10_2 Node11_1_10 Node11_2_10 101.31578947368422
R_11_1_10_3 Node11_1_10 Node12_1_10 149.8112
C_11_1_10 Node11_1_10 GND 1.714453125e-07
R_11_1_11_1 Node11_1_11 Node11_1_12 101.31578947368422
R_11_1_11_2 Node11_1_11 Node11_2_11 101.31578947368422
R_11_1_11_3 Node11_1_11 Node12_1_11 149.8112
C_11_1_11 Node11_1_11 GND 1.714453125e-07
R_11_1_12_1 Node11_1_12 Node11_1_13 101.31578947368422
R_11_1_12_2 Node11_1_12 Node11_2_12 101.31578947368422
R_11_1_12_3 Node11_1_12 Node12_1_12 149.8112
C_11_1_12 Node11_1_12 GND 1.714453125e-07
R_11_1_13_1 Node11_1_13 Node11_1_14 101.31578947368422
R_11_1_13_2 Node11_1_13 Node11_2_13 101.31578947368422
R_11_1_13_3 Node11_1_13 Node12_1_13 149.8112
C_11_1_13 Node11_1_13 GND 1.714453125e-07
R_11_1_14_1 Node11_1_14 Node11_1_15 101.31578947368418
R_11_1_14_2 Node11_1_14 Node11_2_14 101.31578947368422
R_11_1_14_3 Node11_1_14 Node12_1_14 149.8112
C_11_1_14 Node11_1_14 GND 1.714453125e-07
R_11_1_15_2 Node11_1_15 Node11_2_15 101.31578947368413
R_11_1_15_3 Node11_1_15 Node12_1_15 149.81119999999987
C_11_1_15 Node11_1_15 GND 1.7144531250000017e-07
R_11_2_0_1 Node11_2_0 Node11_2_1 101.31578947368422
R_11_2_0_2 Node11_2_0 Node11_3_0 101.31578947368422
R_11_2_0_3 Node11_2_0 Node12_2_0 149.8112
C_11_2_0 Node11_2_0 GND 1.714453125e-07
R_11_2_1_1 Node11_2_1 Node11_2_2 101.31578947368422
R_11_2_1_2 Node11_2_1 Node11_3_1 101.31578947368422
R_11_2_1_3 Node11_2_1 Node12_2_1 149.8112
C_11_2_1 Node11_2_1 GND 1.714453125e-07
R_11_2_2_1 Node11_2_2 Node11_2_3 101.31578947368422
R_11_2_2_2 Node11_2_2 Node11_3_2 101.31578947368422
R_11_2_2_3 Node11_2_2 Node12_2_2 149.8112
C_11_2_2 Node11_2_2 GND 1.714453125e-07
R_11_2_3_1 Node11_2_3 Node11_2_4 101.31578947368422
R_11_2_3_2 Node11_2_3 Node11_3_3 101.31578947368422
R_11_2_3_3 Node11_2_3 Node12_2_3 149.8112
C_11_2_3 Node11_2_3 GND 1.714453125e-07
R_11_2_4_1 Node11_2_4 Node11_2_5 101.31578947368422
R_11_2_4_2 Node11_2_4 Node11_3_4 101.31578947368422
R_11_2_4_3 Node11_2_4 Node12_2_4 149.8112
C_11_2_4 Node11_2_4 GND 1.714453125e-07
R_11_2_5_1 Node11_2_5 Node11_2_6 101.31578947368422
R_11_2_5_2 Node11_2_5 Node11_3_5 101.31578947368422
R_11_2_5_3 Node11_2_5 Node12_2_5 149.8112
C_11_2_5 Node11_2_5 GND 1.714453125e-07
R_11_2_6_1 Node11_2_6 Node11_2_7 101.31578947368422
R_11_2_6_2 Node11_2_6 Node11_3_6 101.31578947368422
R_11_2_6_3 Node11_2_6 Node12_2_6 149.8112
C_11_2_6 Node11_2_6 GND 1.714453125e-07
R_11_2_7_1 Node11_2_7 Node11_2_8 101.31578947368422
R_11_2_7_2 Node11_2_7 Node11_3_7 101.31578947368422
R_11_2_7_3 Node11_2_7 Node12_2_7 149.8112
C_11_2_7 Node11_2_7 GND 1.714453125e-07
R_11_2_8_1 Node11_2_8 Node11_2_9 101.31578947368422
R_11_2_8_2 Node11_2_8 Node11_3_8 101.31578947368422
R_11_2_8_3 Node11_2_8 Node12_2_8 149.8112
C_11_2_8 Node11_2_8 GND 1.714453125e-07
R_11_2_9_1 Node11_2_9 Node11_2_10 101.31578947368422
R_11_2_9_2 Node11_2_9 Node11_3_9 101.31578947368422
R_11_2_9_3 Node11_2_9 Node12_2_9 149.8112
C_11_2_9 Node11_2_9 GND 1.714453125e-07
R_11_2_10_1 Node11_2_10 Node11_2_11 101.31578947368422
R_11_2_10_2 Node11_2_10 Node11_3_10 101.31578947368422
R_11_2_10_3 Node11_2_10 Node12_2_10 149.8112
C_11_2_10 Node11_2_10 GND 1.714453125e-07
R_11_2_11_1 Node11_2_11 Node11_2_12 101.31578947368422
R_11_2_11_2 Node11_2_11 Node11_3_11 101.31578947368422
R_11_2_11_3 Node11_2_11 Node12_2_11 149.8112
C_11_2_11 Node11_2_11 GND 1.714453125e-07
R_11_2_12_1 Node11_2_12 Node11_2_13 101.31578947368422
R_11_2_12_2 Node11_2_12 Node11_3_12 101.31578947368422
R_11_2_12_3 Node11_2_12 Node12_2_12 149.8112
C_11_2_12 Node11_2_12 GND 1.714453125e-07
R_11_2_13_1 Node11_2_13 Node11_2_14 101.31578947368422
R_11_2_13_2 Node11_2_13 Node11_3_13 101.31578947368422
R_11_2_13_3 Node11_2_13 Node12_2_13 149.8112
C_11_2_13 Node11_2_13 GND 1.714453125e-07
R_11_2_14_1 Node11_2_14 Node11_2_15 101.31578947368418
R_11_2_14_2 Node11_2_14 Node11_3_14 101.31578947368422
R_11_2_14_3 Node11_2_14 Node12_2_14 149.8112
C_11_2_14 Node11_2_14 GND 1.714453125e-07
R_11_2_15_2 Node11_2_15 Node11_3_15 101.31578947368413
R_11_2_15_3 Node11_2_15 Node12_2_15 149.81119999999987
C_11_2_15 Node11_2_15 GND 1.7144531250000017e-07
R_11_3_0_1 Node11_3_0 Node11_3_1 101.31578947368422
R_11_3_0_2 Node11_3_0 Node11_4_0 101.31578947368422
R_11_3_0_3 Node11_3_0 Node12_3_0 149.8112
C_11_3_0 Node11_3_0 GND 1.714453125e-07
R_11_3_1_1 Node11_3_1 Node11_3_2 101.31578947368422
R_11_3_1_2 Node11_3_1 Node11_4_1 101.31578947368422
R_11_3_1_3 Node11_3_1 Node12_3_1 149.8112
C_11_3_1 Node11_3_1 GND 1.714453125e-07
R_11_3_2_1 Node11_3_2 Node11_3_3 101.31578947368422
R_11_3_2_2 Node11_3_2 Node11_4_2 101.31578947368422
R_11_3_2_3 Node11_3_2 Node12_3_2 149.8112
C_11_3_2 Node11_3_2 GND 1.714453125e-07
R_11_3_3_1 Node11_3_3 Node11_3_4 101.31578947368422
R_11_3_3_2 Node11_3_3 Node11_4_3 101.31578947368422
R_11_3_3_3 Node11_3_3 Node12_3_3 149.8112
C_11_3_3 Node11_3_3 GND 1.714453125e-07
R_11_3_4_1 Node11_3_4 Node11_3_5 101.31578947368422
R_11_3_4_2 Node11_3_4 Node11_4_4 101.31578947368422
R_11_3_4_3 Node11_3_4 Node12_3_4 149.8112
C_11_3_4 Node11_3_4 GND 1.714453125e-07
R_11_3_5_1 Node11_3_5 Node11_3_6 101.31578947368422
R_11_3_5_2 Node11_3_5 Node11_4_5 101.31578947368422
R_11_3_5_3 Node11_3_5 Node12_3_5 149.8112
C_11_3_5 Node11_3_5 GND 1.714453125e-07
R_11_3_6_1 Node11_3_6 Node11_3_7 101.31578947368422
R_11_3_6_2 Node11_3_6 Node11_4_6 101.31578947368422
R_11_3_6_3 Node11_3_6 Node12_3_6 149.8112
C_11_3_6 Node11_3_6 GND 1.714453125e-07
R_11_3_7_1 Node11_3_7 Node11_3_8 101.31578947368422
R_11_3_7_2 Node11_3_7 Node11_4_7 101.31578947368422
R_11_3_7_3 Node11_3_7 Node12_3_7 149.8112
C_11_3_7 Node11_3_7 GND 1.714453125e-07
R_11_3_8_1 Node11_3_8 Node11_3_9 101.31578947368422
R_11_3_8_2 Node11_3_8 Node11_4_8 101.31578947368422
R_11_3_8_3 Node11_3_8 Node12_3_8 149.8112
C_11_3_8 Node11_3_8 GND 1.714453125e-07
R_11_3_9_1 Node11_3_9 Node11_3_10 101.31578947368422
R_11_3_9_2 Node11_3_9 Node11_4_9 101.31578947368422
R_11_3_9_3 Node11_3_9 Node12_3_9 149.8112
C_11_3_9 Node11_3_9 GND 1.714453125e-07
R_11_3_10_1 Node11_3_10 Node11_3_11 101.31578947368422
R_11_3_10_2 Node11_3_10 Node11_4_10 101.31578947368422
R_11_3_10_3 Node11_3_10 Node12_3_10 149.8112
C_11_3_10 Node11_3_10 GND 1.714453125e-07
R_11_3_11_1 Node11_3_11 Node11_3_12 101.31578947368422
R_11_3_11_2 Node11_3_11 Node11_4_11 101.31578947368422
R_11_3_11_3 Node11_3_11 Node12_3_11 149.8112
C_11_3_11 Node11_3_11 GND 1.714453125e-07
R_11_3_12_1 Node11_3_12 Node11_3_13 101.31578947368422
R_11_3_12_2 Node11_3_12 Node11_4_12 101.31578947368422
R_11_3_12_3 Node11_3_12 Node12_3_12 149.8112
C_11_3_12 Node11_3_12 GND 1.714453125e-07
R_11_3_13_1 Node11_3_13 Node11_3_14 101.31578947368422
R_11_3_13_2 Node11_3_13 Node11_4_13 101.31578947368422
R_11_3_13_3 Node11_3_13 Node12_3_13 149.8112
C_11_3_13 Node11_3_13 GND 1.714453125e-07
R_11_3_14_1 Node11_3_14 Node11_3_15 101.31578947368418
R_11_3_14_2 Node11_3_14 Node11_4_14 101.31578947368422
R_11_3_14_3 Node11_3_14 Node12_3_14 149.8112
C_11_3_14 Node11_3_14 GND 1.714453125e-07
R_11_3_15_2 Node11_3_15 Node11_4_15 101.31578947368413
R_11_3_15_3 Node11_3_15 Node12_3_15 149.81119999999987
C_11_3_15 Node11_3_15 GND 1.7144531250000017e-07
R_11_4_0_1 Node11_4_0 Node11_4_1 101.31578947368422
R_11_4_0_2 Node11_4_0 Node11_5_0 101.31578947368422
R_11_4_0_3 Node11_4_0 Node12_4_0 149.8112
C_11_4_0 Node11_4_0 GND 1.714453125e-07
R_11_4_1_1 Node11_4_1 Node11_4_2 101.31578947368422
R_11_4_1_2 Node11_4_1 Node11_5_1 101.31578947368422
R_11_4_1_3 Node11_4_1 Node12_4_1 149.8112
C_11_4_1 Node11_4_1 GND 1.714453125e-07
R_11_4_2_1 Node11_4_2 Node11_4_3 101.31578947368422
R_11_4_2_2 Node11_4_2 Node11_5_2 101.31578947368422
R_11_4_2_3 Node11_4_2 Node12_4_2 149.8112
C_11_4_2 Node11_4_2 GND 1.714453125e-07
R_11_4_3_1 Node11_4_3 Node11_4_4 101.31578947368422
R_11_4_3_2 Node11_4_3 Node11_5_3 101.31578947368422
R_11_4_3_3 Node11_4_3 Node12_4_3 149.8112
C_11_4_3 Node11_4_3 GND 1.714453125e-07
R_11_4_4_1 Node11_4_4 Node11_4_5 101.31578947368422
R_11_4_4_2 Node11_4_4 Node11_5_4 101.31578947368422
R_11_4_4_3 Node11_4_4 Node12_4_4 149.8112
C_11_4_4 Node11_4_4 GND 1.714453125e-07
R_11_4_5_1 Node11_4_5 Node11_4_6 101.31578947368422
R_11_4_5_2 Node11_4_5 Node11_5_5 101.31578947368422
R_11_4_5_3 Node11_4_5 Node12_4_5 149.8112
C_11_4_5 Node11_4_5 GND 1.714453125e-07
R_11_4_6_1 Node11_4_6 Node11_4_7 101.31578947368422
R_11_4_6_2 Node11_4_6 Node11_5_6 101.31578947368422
R_11_4_6_3 Node11_4_6 Node12_4_6 149.8112
C_11_4_6 Node11_4_6 GND 1.714453125e-07
R_11_4_7_1 Node11_4_7 Node11_4_8 101.31578947368422
R_11_4_7_2 Node11_4_7 Node11_5_7 101.31578947368422
R_11_4_7_3 Node11_4_7 Node12_4_7 149.8112
C_11_4_7 Node11_4_7 GND 1.714453125e-07
R_11_4_8_1 Node11_4_8 Node11_4_9 101.31578947368422
R_11_4_8_2 Node11_4_8 Node11_5_8 101.31578947368422
R_11_4_8_3 Node11_4_8 Node12_4_8 149.8112
C_11_4_8 Node11_4_8 GND 1.714453125e-07
R_11_4_9_1 Node11_4_9 Node11_4_10 101.31578947368422
R_11_4_9_2 Node11_4_9 Node11_5_9 101.31578947368422
R_11_4_9_3 Node11_4_9 Node12_4_9 149.8112
C_11_4_9 Node11_4_9 GND 1.714453125e-07
R_11_4_10_1 Node11_4_10 Node11_4_11 101.31578947368422
R_11_4_10_2 Node11_4_10 Node11_5_10 101.31578947368422
R_11_4_10_3 Node11_4_10 Node12_4_10 149.8112
C_11_4_10 Node11_4_10 GND 1.714453125e-07
R_11_4_11_1 Node11_4_11 Node11_4_12 101.31578947368422
R_11_4_11_2 Node11_4_11 Node11_5_11 101.31578947368422
R_11_4_11_3 Node11_4_11 Node12_4_11 149.8112
C_11_4_11 Node11_4_11 GND 1.714453125e-07
R_11_4_12_1 Node11_4_12 Node11_4_13 101.31578947368422
R_11_4_12_2 Node11_4_12 Node11_5_12 101.31578947368422
R_11_4_12_3 Node11_4_12 Node12_4_12 149.8112
C_11_4_12 Node11_4_12 GND 1.714453125e-07
R_11_4_13_1 Node11_4_13 Node11_4_14 101.31578947368422
R_11_4_13_2 Node11_4_13 Node11_5_13 101.31578947368422
R_11_4_13_3 Node11_4_13 Node12_4_13 149.8112
C_11_4_13 Node11_4_13 GND 1.714453125e-07
R_11_4_14_1 Node11_4_14 Node11_4_15 101.31578947368418
R_11_4_14_2 Node11_4_14 Node11_5_14 101.31578947368422
R_11_4_14_3 Node11_4_14 Node12_4_14 149.8112
C_11_4_14 Node11_4_14 GND 1.714453125e-07
R_11_4_15_2 Node11_4_15 Node11_5_15 101.31578947368413
R_11_4_15_3 Node11_4_15 Node12_4_15 149.81119999999987
C_11_4_15 Node11_4_15 GND 1.7144531250000017e-07
R_11_5_0_1 Node11_5_0 Node11_5_1 101.31578947368422
R_11_5_0_2 Node11_5_0 Node11_6_0 101.31578947368422
R_11_5_0_3 Node11_5_0 Node12_5_0 149.8112
C_11_5_0 Node11_5_0 GND 1.714453125e-07
R_11_5_1_1 Node11_5_1 Node11_5_2 101.31578947368422
R_11_5_1_2 Node11_5_1 Node11_6_1 101.31578947368422
R_11_5_1_3 Node11_5_1 Node12_5_1 149.8112
C_11_5_1 Node11_5_1 GND 1.714453125e-07
R_11_5_2_1 Node11_5_2 Node11_5_3 101.31578947368422
R_11_5_2_2 Node11_5_2 Node11_6_2 101.31578947368422
R_11_5_2_3 Node11_5_2 Node12_5_2 149.8112
C_11_5_2 Node11_5_2 GND 1.714453125e-07
R_11_5_3_1 Node11_5_3 Node11_5_4 101.31578947368422
R_11_5_3_2 Node11_5_3 Node11_6_3 101.31578947368422
R_11_5_3_3 Node11_5_3 Node12_5_3 149.8112
C_11_5_3 Node11_5_3 GND 1.714453125e-07
R_11_5_4_1 Node11_5_4 Node11_5_5 101.31578947368422
R_11_5_4_2 Node11_5_4 Node11_6_4 101.31578947368422
R_11_5_4_3 Node11_5_4 Node12_5_4 149.8112
C_11_5_4 Node11_5_4 GND 1.714453125e-07
R_11_5_5_1 Node11_5_5 Node11_5_6 101.31578947368422
R_11_5_5_2 Node11_5_5 Node11_6_5 101.31578947368422
R_11_5_5_3 Node11_5_5 Node12_5_5 149.8112
C_11_5_5 Node11_5_5 GND 1.714453125e-07
R_11_5_6_1 Node11_5_6 Node11_5_7 101.31578947368422
R_11_5_6_2 Node11_5_6 Node11_6_6 101.31578947368422
R_11_5_6_3 Node11_5_6 Node12_5_6 149.8112
C_11_5_6 Node11_5_6 GND 1.714453125e-07
R_11_5_7_1 Node11_5_7 Node11_5_8 101.31578947368422
R_11_5_7_2 Node11_5_7 Node11_6_7 101.31578947368422
R_11_5_7_3 Node11_5_7 Node12_5_7 149.8112
C_11_5_7 Node11_5_7 GND 1.714453125e-07
R_11_5_8_1 Node11_5_8 Node11_5_9 101.31578947368422
R_11_5_8_2 Node11_5_8 Node11_6_8 101.31578947368422
R_11_5_8_3 Node11_5_8 Node12_5_8 149.8112
C_11_5_8 Node11_5_8 GND 1.714453125e-07
R_11_5_9_1 Node11_5_9 Node11_5_10 101.31578947368422
R_11_5_9_2 Node11_5_9 Node11_6_9 101.31578947368419
R_11_5_9_3 Node11_5_9 Node12_5_9 149.8112
C_11_5_9 Node11_5_9 GND 1.714453125e-07
R_11_5_10_1 Node11_5_10 Node11_5_11 101.31578947368422
R_11_5_10_2 Node11_5_10 Node11_6_10 101.31578947368422
R_11_5_10_3 Node11_5_10 Node12_5_10 149.8112
C_11_5_10 Node11_5_10 GND 1.714453125e-07
R_11_5_11_1 Node11_5_11 Node11_5_12 101.31578947368422
R_11_5_11_2 Node11_5_11 Node11_6_11 101.31578947368422
R_11_5_11_3 Node11_5_11 Node12_5_11 149.8112
C_11_5_11 Node11_5_11 GND 1.714453125e-07
R_11_5_12_1 Node11_5_12 Node11_5_13 101.31578947368422
R_11_5_12_2 Node11_5_12 Node11_6_12 101.31578947368422
R_11_5_12_3 Node11_5_12 Node12_5_12 149.8112
C_11_5_12 Node11_5_12 GND 1.714453125e-07
R_11_5_13_1 Node11_5_13 Node11_5_14 101.31578947368422
R_11_5_13_2 Node11_5_13 Node11_6_13 101.31578947368422
R_11_5_13_3 Node11_5_13 Node12_5_13 149.8112
C_11_5_13 Node11_5_13 GND 1.714453125e-07
R_11_5_14_1 Node11_5_14 Node11_5_15 101.31578947368418
R_11_5_14_2 Node11_5_14 Node11_6_14 101.31578947368422
R_11_5_14_3 Node11_5_14 Node12_5_14 149.8112
C_11_5_14 Node11_5_14 GND 1.714453125e-07
R_11_5_15_2 Node11_5_15 Node11_6_15 101.31578947368412
R_11_5_15_3 Node11_5_15 Node12_5_15 149.81119999999987
C_11_5_15 Node11_5_15 GND 1.7144531250000017e-07
R_11_6_0_1 Node11_6_0 Node11_6_1 101.31578947368422
R_11_6_0_2 Node11_6_0 Node11_7_0 101.31578947368422
R_11_6_0_3 Node11_6_0 Node12_6_0 149.8112
C_11_6_0 Node11_6_0 GND 1.714453125e-07
R_11_6_1_1 Node11_6_1 Node11_6_2 101.31578947368422
R_11_6_1_2 Node11_6_1 Node11_7_1 101.31578947368422
R_11_6_1_3 Node11_6_1 Node12_6_1 149.8112
C_11_6_1 Node11_6_1 GND 1.714453125e-07
R_11_6_2_1 Node11_6_2 Node11_6_3 101.31578947368422
R_11_6_2_2 Node11_6_2 Node11_7_2 101.31578947368422
R_11_6_2_3 Node11_6_2 Node12_6_2 149.8112
C_11_6_2 Node11_6_2 GND 1.714453125e-07
R_11_6_3_1 Node11_6_3 Node11_6_4 101.31578947368422
R_11_6_3_2 Node11_6_3 Node11_7_3 101.31578947368422
R_11_6_3_3 Node11_6_3 Node12_6_3 149.8112
C_11_6_3 Node11_6_3 GND 1.714453125e-07
R_11_6_4_1 Node11_6_4 Node11_6_5 101.31578947368422
R_11_6_4_2 Node11_6_4 Node11_7_4 101.31578947368422
R_11_6_4_3 Node11_6_4 Node12_6_4 149.8112
C_11_6_4 Node11_6_4 GND 1.714453125e-07
R_11_6_5_1 Node11_6_5 Node11_6_6 101.31578947368422
R_11_6_5_2 Node11_6_5 Node11_7_5 101.31578947368422
R_11_6_5_3 Node11_6_5 Node12_6_5 149.8112
C_11_6_5 Node11_6_5 GND 1.714453125e-07
R_11_6_6_1 Node11_6_6 Node11_6_7 101.31578947368422
R_11_6_6_2 Node11_6_6 Node11_7_6 101.31578947368422
R_11_6_6_3 Node11_6_6 Node12_6_6 149.8112
C_11_6_6 Node11_6_6 GND 1.7144531250000003e-07
R_11_6_7_1 Node11_6_7 Node11_6_8 101.31578947368422
R_11_6_7_2 Node11_6_7 Node11_7_7 101.31578947368422
R_11_6_7_3 Node11_6_7 Node12_6_7 149.8112
C_11_6_7 Node11_6_7 GND 1.714453125e-07
R_11_6_8_1 Node11_6_8 Node11_6_9 101.31578947368419
R_11_6_8_2 Node11_6_8 Node11_7_8 101.31578947368422
R_11_6_8_3 Node11_6_8 Node12_6_8 149.8112
C_11_6_8 Node11_6_8 GND 1.714453125e-07
R_11_6_9_1 Node11_6_9 Node11_6_10 101.31578947368419
R_11_6_9_2 Node11_6_9 Node11_7_9 101.31578947368415
R_11_6_9_3 Node11_6_9 Node12_6_9 149.81119999999993
C_11_6_9 Node11_6_9 GND 1.714453125000001e-07
R_11_6_10_1 Node11_6_10 Node11_6_11 101.31578947368422
R_11_6_10_2 Node11_6_10 Node11_7_10 101.31578947368422
R_11_6_10_3 Node11_6_10 Node12_6_10 149.8112
C_11_6_10 Node11_6_10 GND 1.714453125e-07
R_11_6_11_1 Node11_6_11 Node11_6_12 101.31578947368422
R_11_6_11_2 Node11_6_11 Node11_7_11 101.31578947368422
R_11_6_11_3 Node11_6_11 Node12_6_11 149.8112
C_11_6_11 Node11_6_11 GND 1.714453125e-07
R_11_6_12_1 Node11_6_12 Node11_6_13 101.31578947368422
R_11_6_12_2 Node11_6_12 Node11_7_12 101.31578947368422
R_11_6_12_3 Node11_6_12 Node12_6_12 149.8112
C_11_6_12 Node11_6_12 GND 1.714453125e-07
R_11_6_13_1 Node11_6_13 Node11_6_14 101.31578947368422
R_11_6_13_2 Node11_6_13 Node11_7_13 101.31578947368422
R_11_6_13_3 Node11_6_13 Node12_6_13 149.8112
C_11_6_13 Node11_6_13 GND 1.714453125e-07
R_11_6_14_1 Node11_6_14 Node11_6_15 101.31578947368416
R_11_6_14_2 Node11_6_14 Node11_7_14 101.31578947368422
R_11_6_14_3 Node11_6_14 Node12_6_14 149.8112
C_11_6_14 Node11_6_14 GND 1.714453125e-07
R_11_6_15_2 Node11_6_15 Node11_7_15 101.31578947368412
R_11_6_15_3 Node11_6_15 Node12_6_15 149.81119999999987
C_11_6_15 Node11_6_15 GND 1.7144531250000017e-07
R_11_7_0_1 Node11_7_0 Node11_7_1 101.31578947368422
R_11_7_0_2 Node11_7_0 Node11_8_0 101.31578947368422
R_11_7_0_3 Node11_7_0 Node12_7_0 149.8112
C_11_7_0 Node11_7_0 GND 1.714453125e-07
R_11_7_1_1 Node11_7_1 Node11_7_2 101.31578947368422
R_11_7_1_2 Node11_7_1 Node11_8_1 101.31578947368422
R_11_7_1_3 Node11_7_1 Node12_7_1 149.8112
C_11_7_1 Node11_7_1 GND 1.714453125e-07
R_11_7_2_1 Node11_7_2 Node11_7_3 101.31578947368422
R_11_7_2_2 Node11_7_2 Node11_8_2 101.31578947368422
R_11_7_2_3 Node11_7_2 Node12_7_2 149.8112
C_11_7_2 Node11_7_2 GND 1.714453125e-07
R_11_7_3_1 Node11_7_3 Node11_7_4 101.31578947368422
R_11_7_3_2 Node11_7_3 Node11_8_3 101.31578947368422
R_11_7_3_3 Node11_7_3 Node12_7_3 149.8112
C_11_7_3 Node11_7_3 GND 1.714453125e-07
R_11_7_4_1 Node11_7_4 Node11_7_5 101.31578947368422
R_11_7_4_2 Node11_7_4 Node11_8_4 101.31578947368422
R_11_7_4_3 Node11_7_4 Node12_7_4 149.8112
C_11_7_4 Node11_7_4 GND 1.714453125e-07
R_11_7_5_1 Node11_7_5 Node11_7_6 101.31578947368422
R_11_7_5_2 Node11_7_5 Node11_8_5 101.31578947368422
R_11_7_5_3 Node11_7_5 Node12_7_5 149.8112
C_11_7_5 Node11_7_5 GND 1.714453125e-07
R_11_7_6_1 Node11_7_6 Node11_7_7 101.31578947368422
R_11_7_6_2 Node11_7_6 Node11_8_6 101.31578947368422
R_11_7_6_3 Node11_7_6 Node12_7_6 149.8112
C_11_7_6 Node11_7_6 GND 1.714453125e-07
R_11_7_7_1 Node11_7_7 Node11_7_8 101.31578947368422
R_11_7_7_2 Node11_7_7 Node11_8_7 101.31578947368422
R_11_7_7_3 Node11_7_7 Node12_7_7 149.8112
C_11_7_7 Node11_7_7 GND 1.714453125e-07
R_11_7_8_1 Node11_7_8 Node11_7_9 101.31578947368418
R_11_7_8_2 Node11_7_8 Node11_8_8 101.31578947368422
R_11_7_8_3 Node11_7_8 Node12_7_8 149.8112
C_11_7_8 Node11_7_8 GND 1.714453125e-07
R_11_7_9_1 Node11_7_9 Node11_7_10 101.31578947368418
R_11_7_9_2 Node11_7_9 Node11_8_9 101.31578947368413
R_11_7_9_3 Node11_7_9 Node12_7_9 149.8111999999999
C_11_7_9 Node11_7_9 GND 1.7144531250000017e-07
R_11_7_10_1 Node11_7_10 Node11_7_11 101.31578947368422
R_11_7_10_2 Node11_7_10 Node11_8_10 101.31578947368422
R_11_7_10_3 Node11_7_10 Node12_7_10 149.8112
C_11_7_10 Node11_7_10 GND 1.714453125e-07
R_11_7_11_1 Node11_7_11 Node11_7_12 101.31578947368422
R_11_7_11_2 Node11_7_11 Node11_8_11 101.31578947368422
R_11_7_11_3 Node11_7_11 Node12_7_11 149.8112
C_11_7_11 Node11_7_11 GND 1.714453125e-07
R_11_7_12_1 Node11_7_12 Node11_7_13 101.31578947368422
R_11_7_12_2 Node11_7_12 Node11_8_12 101.31578947368422
R_11_7_12_3 Node11_7_12 Node12_7_12 149.8112
C_11_7_12 Node11_7_12 GND 1.714453125e-07
R_11_7_13_1 Node11_7_13 Node11_7_14 101.31578947368422
R_11_7_13_2 Node11_7_13 Node11_8_13 101.31578947368422
R_11_7_13_3 Node11_7_13 Node12_7_13 149.8112
C_11_7_13 Node11_7_13 GND 1.714453125e-07
R_11_7_14_1 Node11_7_14 Node11_7_15 101.31578947368418
R_11_7_14_2 Node11_7_14 Node11_8_14 101.31578947368422
R_11_7_14_3 Node11_7_14 Node12_7_14 149.8112
C_11_7_14 Node11_7_14 GND 1.714453125e-07
R_11_7_15_2 Node11_7_15 Node11_8_15 101.31578947368413
R_11_7_15_3 Node11_7_15 Node12_7_15 149.81119999999987
C_11_7_15 Node11_7_15 GND 1.7144531250000017e-07
R_11_8_0_1 Node11_8_0 Node11_8_1 101.31578947368422
R_11_8_0_2 Node11_8_0 Node11_9_0 101.31578947368425
R_11_8_0_3 Node11_8_0 Node12_8_0 149.8112
C_11_8_0 Node11_8_0 GND 1.714453125e-07
R_11_8_1_1 Node11_8_1 Node11_8_2 101.31578947368422
R_11_8_1_2 Node11_8_1 Node11_9_1 101.31578947368425
R_11_8_1_3 Node11_8_1 Node12_8_1 149.8112
C_11_8_1 Node11_8_1 GND 1.714453125e-07
R_11_8_2_1 Node11_8_2 Node11_8_3 101.31578947368422
R_11_8_2_2 Node11_8_2 Node11_9_2 101.31578947368425
R_11_8_2_3 Node11_8_2 Node12_8_2 149.8112
C_11_8_2 Node11_8_2 GND 1.714453125e-07
R_11_8_3_1 Node11_8_3 Node11_8_4 101.31578947368422
R_11_8_3_2 Node11_8_3 Node11_9_3 101.31578947368425
R_11_8_3_3 Node11_8_3 Node12_8_3 149.8112
C_11_8_3 Node11_8_3 GND 1.714453125e-07
R_11_8_4_1 Node11_8_4 Node11_8_5 101.31578947368422
R_11_8_4_2 Node11_8_4 Node11_9_4 101.31578947368425
R_11_8_4_3 Node11_8_4 Node12_8_4 149.8112
C_11_8_4 Node11_8_4 GND 1.714453125e-07
R_11_8_5_1 Node11_8_5 Node11_8_6 101.31578947368422
R_11_8_5_2 Node11_8_5 Node11_9_5 101.31578947368425
R_11_8_5_3 Node11_8_5 Node12_8_5 149.8112
C_11_8_5 Node11_8_5 GND 1.714453125e-07
R_11_8_6_1 Node11_8_6 Node11_8_7 101.31578947368422
R_11_8_6_2 Node11_8_6 Node11_9_6 101.31578947368426
R_11_8_6_3 Node11_8_6 Node12_8_6 149.8112
C_11_8_6 Node11_8_6 GND 1.714453125e-07
R_11_8_7_1 Node11_8_7 Node11_8_8 101.31578947368422
R_11_8_7_2 Node11_8_7 Node11_9_7 101.31578947368425
R_11_8_7_3 Node11_8_7 Node12_8_7 149.8112
C_11_8_7 Node11_8_7 GND 1.714453125e-07
R_11_8_8_1 Node11_8_8 Node11_8_9 101.31578947368418
R_11_8_8_2 Node11_8_8 Node11_9_8 101.31578947368425
R_11_8_8_3 Node11_8_8 Node12_8_8 149.8112
C_11_8_8 Node11_8_8 GND 1.714453125e-07
R_11_8_9_1 Node11_8_9 Node11_8_10 101.31578947368418
R_11_8_9_2 Node11_8_9 Node11_9_9 101.31578947368419
R_11_8_9_3 Node11_8_9 Node12_8_9 149.8111999999999
C_11_8_9 Node11_8_9 GND 1.7144531250000017e-07
R_11_8_10_1 Node11_8_10 Node11_8_11 101.31578947368422
R_11_8_10_2 Node11_8_10 Node11_9_10 101.31578947368425
R_11_8_10_3 Node11_8_10 Node12_8_10 149.8112
C_11_8_10 Node11_8_10 GND 1.714453125e-07
R_11_8_11_1 Node11_8_11 Node11_8_12 101.31578947368422
R_11_8_11_2 Node11_8_11 Node11_9_11 101.31578947368425
R_11_8_11_3 Node11_8_11 Node12_8_11 149.8112
C_11_8_11 Node11_8_11 GND 1.714453125e-07
R_11_8_12_1 Node11_8_12 Node11_8_13 101.31578947368422
R_11_8_12_2 Node11_8_12 Node11_9_12 101.31578947368425
R_11_8_12_3 Node11_8_12 Node12_8_12 149.8112
C_11_8_12 Node11_8_12 GND 1.714453125e-07
R_11_8_13_1 Node11_8_13 Node11_8_14 101.31578947368422
R_11_8_13_2 Node11_8_13 Node11_9_13 101.31578947368425
R_11_8_13_3 Node11_8_13 Node12_8_13 149.8112
C_11_8_13 Node11_8_13 GND 1.714453125e-07
R_11_8_14_1 Node11_8_14 Node11_8_15 101.31578947368418
R_11_8_14_2 Node11_8_14 Node11_9_14 101.31578947368425
R_11_8_14_3 Node11_8_14 Node12_8_14 149.8112
C_11_8_14 Node11_8_14 GND 1.714453125e-07
R_11_8_15_2 Node11_8_15 Node11_9_15 101.31578947368418
R_11_8_15_3 Node11_8_15 Node12_8_15 149.81119999999987
C_11_8_15 Node11_8_15 GND 1.7144531250000017e-07
R_11_9_0_1 Node11_9_0 Node11_9_1 101.31578947368429
R_11_9_0_2 Node11_9_0 Node11_10_0 101.31578947368425
R_11_9_0_3 Node11_9_0 Node12_9_0 149.81120000000013
C_11_9_0 Node11_9_0 GND 1.7144531249999987e-07
R_11_9_1_1 Node11_9_1 Node11_9_2 101.31578947368429
R_11_9_1_2 Node11_9_1 Node11_10_1 101.31578947368425
R_11_9_1_3 Node11_9_1 Node12_9_1 149.81120000000013
C_11_9_1 Node11_9_1 GND 1.7144531249999985e-07
R_11_9_2_1 Node11_9_2 Node11_9_3 101.31578947368429
R_11_9_2_2 Node11_9_2 Node11_10_2 101.31578947368425
R_11_9_2_3 Node11_9_2 Node12_9_2 149.81120000000013
C_11_9_2 Node11_9_2 GND 1.7144531249999985e-07
R_11_9_3_1 Node11_9_3 Node11_9_4 101.31578947368429
R_11_9_3_2 Node11_9_3 Node11_10_3 101.31578947368425
R_11_9_3_3 Node11_9_3 Node12_9_3 149.81120000000013
C_11_9_3 Node11_9_3 GND 1.7144531249999985e-07
R_11_9_4_1 Node11_9_4 Node11_9_5 101.31578947368429
R_11_9_4_2 Node11_9_4 Node11_10_4 101.31578947368425
R_11_9_4_3 Node11_9_4 Node12_9_4 149.81120000000013
C_11_9_4 Node11_9_4 GND 1.7144531249999985e-07
R_11_9_5_1 Node11_9_5 Node11_9_6 101.3157894736843
R_11_9_5_2 Node11_9_5 Node11_10_5 101.31578947368425
R_11_9_5_3 Node11_9_5 Node12_9_5 149.81120000000013
C_11_9_5 Node11_9_5 GND 1.7144531249999985e-07
R_11_9_6_1 Node11_9_6 Node11_9_7 101.3157894736843
R_11_9_6_2 Node11_9_6 Node11_10_6 101.31578947368426
R_11_9_6_3 Node11_9_6 Node12_9_6 149.81120000000013
C_11_9_6 Node11_9_6 GND 1.7144531249999985e-07
R_11_9_7_1 Node11_9_7 Node11_9_8 101.31578947368429
R_11_9_7_2 Node11_9_7 Node11_10_7 101.31578947368425
R_11_9_7_3 Node11_9_7 Node12_9_7 149.81120000000013
C_11_9_7 Node11_9_7 GND 1.7144531249999985e-07
R_11_9_8_1 Node11_9_8 Node11_9_9 101.31578947368426
R_11_9_8_2 Node11_9_8 Node11_10_8 101.31578947368425
R_11_9_8_3 Node11_9_8 Node12_9_8 149.81120000000013
C_11_9_8 Node11_9_8 GND 1.7144531249999985e-07
R_11_9_9_1 Node11_9_9 Node11_9_10 101.31578947368426
R_11_9_9_2 Node11_9_9 Node11_10_9 101.31578947368422
R_11_9_9_3 Node11_9_9 Node12_9_9 149.81120000000004
C_11_9_9 Node11_9_9 GND 1.7144531249999993e-07
R_11_9_10_1 Node11_9_10 Node11_9_11 101.31578947368429
R_11_9_10_2 Node11_9_10 Node11_10_10 101.31578947368425
R_11_9_10_3 Node11_9_10 Node12_9_10 149.81120000000013
C_11_9_10 Node11_9_10 GND 1.7144531249999985e-07
R_11_9_11_1 Node11_9_11 Node11_9_12 101.31578947368429
R_11_9_11_2 Node11_9_11 Node11_10_11 101.31578947368425
R_11_9_11_3 Node11_9_11 Node12_9_11 149.81120000000013
C_11_9_11 Node11_9_11 GND 1.7144531249999985e-07
R_11_9_12_1 Node11_9_12 Node11_9_13 101.31578947368429
R_11_9_12_2 Node11_9_12 Node11_10_12 101.31578947368425
R_11_9_12_3 Node11_9_12 Node12_9_12 149.81120000000013
C_11_9_12 Node11_9_12 GND 1.7144531249999985e-07
R_11_9_13_1 Node11_9_13 Node11_9_14 101.31578947368429
R_11_9_13_2 Node11_9_13 Node11_10_13 101.31578947368425
R_11_9_13_3 Node11_9_13 Node12_9_13 149.81120000000013
C_11_9_13 Node11_9_13 GND 1.7144531249999985e-07
R_11_9_14_1 Node11_9_14 Node11_9_15 101.31578947368425
R_11_9_14_2 Node11_9_14 Node11_10_14 101.31578947368425
R_11_9_14_3 Node11_9_14 Node12_9_14 149.81120000000013
C_11_9_14 Node11_9_14 GND 1.7144531249999985e-07
R_11_9_15_2 Node11_9_15 Node11_10_15 101.31578947368418
R_11_9_15_3 Node11_9_15 Node12_9_15 149.8112
C_11_9_15 Node11_9_15 GND 1.714453125e-07
R_11_10_0_1 Node11_10_0 Node11_10_1 101.31578947368422
R_11_10_0_2 Node11_10_0 Node11_11_0 101.31578947368422
R_11_10_0_3 Node11_10_0 Node12_10_0 149.8112
C_11_10_0 Node11_10_0 GND 1.714453125e-07
R_11_10_1_1 Node11_10_1 Node11_10_2 101.31578947368422
R_11_10_1_2 Node11_10_1 Node11_11_1 101.31578947368422
R_11_10_1_3 Node11_10_1 Node12_10_1 149.8112
C_11_10_1 Node11_10_1 GND 1.714453125e-07
R_11_10_2_1 Node11_10_2 Node11_10_3 101.31578947368422
R_11_10_2_2 Node11_10_2 Node11_11_2 101.31578947368422
R_11_10_2_3 Node11_10_2 Node12_10_2 149.8112
C_11_10_2 Node11_10_2 GND 1.714453125e-07
R_11_10_3_1 Node11_10_3 Node11_10_4 101.31578947368422
R_11_10_3_2 Node11_10_3 Node11_11_3 101.31578947368422
R_11_10_3_3 Node11_10_3 Node12_10_3 149.8112
C_11_10_3 Node11_10_3 GND 1.714453125e-07
R_11_10_4_1 Node11_10_4 Node11_10_5 101.31578947368422
R_11_10_4_2 Node11_10_4 Node11_11_4 101.31578947368422
R_11_10_4_3 Node11_10_4 Node12_10_4 149.8112
C_11_10_4 Node11_10_4 GND 1.714453125e-07
R_11_10_5_1 Node11_10_5 Node11_10_6 101.31578947368422
R_11_10_5_2 Node11_10_5 Node11_11_5 101.31578947368422
R_11_10_5_3 Node11_10_5 Node12_10_5 149.8112
C_11_10_5 Node11_10_5 GND 1.714453125e-07
R_11_10_6_1 Node11_10_6 Node11_10_7 101.31578947368422
R_11_10_6_2 Node11_10_6 Node11_11_6 101.31578947368422
R_11_10_6_3 Node11_10_6 Node12_10_6 149.8112
C_11_10_6 Node11_10_6 GND 1.714453125e-07
R_11_10_7_1 Node11_10_7 Node11_10_8 101.31578947368422
R_11_10_7_2 Node11_10_7 Node11_11_7 101.31578947368422
R_11_10_7_3 Node11_10_7 Node12_10_7 149.8112
C_11_10_7 Node11_10_7 GND 1.714453125e-07
R_11_10_8_1 Node11_10_8 Node11_10_9 101.31578947368422
R_11_10_8_2 Node11_10_8 Node11_11_8 101.31578947368422
R_11_10_8_3 Node11_10_8 Node12_10_8 149.8112
C_11_10_8 Node11_10_8 GND 1.714453125e-07
R_11_10_9_1 Node11_10_9 Node11_10_10 101.31578947368422
R_11_10_9_2 Node11_10_9 Node11_11_9 101.31578947368422
R_11_10_9_3 Node11_10_9 Node12_10_9 149.8112
C_11_10_9 Node11_10_9 GND 1.714453125e-07
R_11_10_10_1 Node11_10_10 Node11_10_11 101.31578947368422
R_11_10_10_2 Node11_10_10 Node11_11_10 101.31578947368422
R_11_10_10_3 Node11_10_10 Node12_10_10 149.8112
C_11_10_10 Node11_10_10 GND 1.714453125e-07
R_11_10_11_1 Node11_10_11 Node11_10_12 101.31578947368422
R_11_10_11_2 Node11_10_11 Node11_11_11 101.31578947368422
R_11_10_11_3 Node11_10_11 Node12_10_11 149.8112
C_11_10_11 Node11_10_11 GND 1.714453125e-07
R_11_10_12_1 Node11_10_12 Node11_10_13 101.31578947368422
R_11_10_12_2 Node11_10_12 Node11_11_12 101.31578947368422
R_11_10_12_3 Node11_10_12 Node12_10_12 149.8112
C_11_10_12 Node11_10_12 GND 1.714453125e-07
R_11_10_13_1 Node11_10_13 Node11_10_14 101.31578947368422
R_11_10_13_2 Node11_10_13 Node11_11_13 101.31578947368422
R_11_10_13_3 Node11_10_13 Node12_10_13 149.8112
C_11_10_13 Node11_10_13 GND 1.714453125e-07
R_11_10_14_1 Node11_10_14 Node11_10_15 101.31578947368418
R_11_10_14_2 Node11_10_14 Node11_11_14 101.31578947368422
R_11_10_14_3 Node11_10_14 Node12_10_14 149.8112
C_11_10_14 Node11_10_14 GND 1.714453125e-07
R_11_10_15_2 Node11_10_15 Node11_11_15 101.31578947368413
R_11_10_15_3 Node11_10_15 Node12_10_15 149.81119999999987
C_11_10_15 Node11_10_15 GND 1.7144531250000017e-07
R_11_11_0_1 Node11_11_0 Node11_11_1 101.31578947368422
R_11_11_0_2 Node11_11_0 Node11_12_0 101.31578947368422
R_11_11_0_3 Node11_11_0 Node12_11_0 149.8112
C_11_11_0 Node11_11_0 GND 1.714453125e-07
R_11_11_1_1 Node11_11_1 Node11_11_2 101.31578947368422
R_11_11_1_2 Node11_11_1 Node11_12_1 101.31578947368422
R_11_11_1_3 Node11_11_1 Node12_11_1 149.8112
C_11_11_1 Node11_11_1 GND 1.714453125e-07
R_11_11_2_1 Node11_11_2 Node11_11_3 101.31578947368422
R_11_11_2_2 Node11_11_2 Node11_12_2 101.31578947368422
R_11_11_2_3 Node11_11_2 Node12_11_2 149.8112
C_11_11_2 Node11_11_2 GND 1.714453125e-07
R_11_11_3_1 Node11_11_3 Node11_11_4 101.31578947368422
R_11_11_3_2 Node11_11_3 Node11_12_3 101.31578947368422
R_11_11_3_3 Node11_11_3 Node12_11_3 149.8112
C_11_11_3 Node11_11_3 GND 1.714453125e-07
R_11_11_4_1 Node11_11_4 Node11_11_5 101.31578947368422
R_11_11_4_2 Node11_11_4 Node11_12_4 101.31578947368422
R_11_11_4_3 Node11_11_4 Node12_11_4 149.8112
C_11_11_4 Node11_11_4 GND 1.714453125e-07
R_11_11_5_1 Node11_11_5 Node11_11_6 101.31578947368422
R_11_11_5_2 Node11_11_5 Node11_12_5 101.31578947368422
R_11_11_5_3 Node11_11_5 Node12_11_5 149.8112
C_11_11_5 Node11_11_5 GND 1.714453125e-07
R_11_11_6_1 Node11_11_6 Node11_11_7 101.31578947368422
R_11_11_6_2 Node11_11_6 Node11_12_6 101.31578947368422
R_11_11_6_3 Node11_11_6 Node12_11_6 149.8112
C_11_11_6 Node11_11_6 GND 1.714453125e-07
R_11_11_7_1 Node11_11_7 Node11_11_8 101.31578947368422
R_11_11_7_2 Node11_11_7 Node11_12_7 101.31578947368422
R_11_11_7_3 Node11_11_7 Node12_11_7 149.8112
C_11_11_7 Node11_11_7 GND 1.714453125e-07
R_11_11_8_1 Node11_11_8 Node11_11_9 101.31578947368422
R_11_11_8_2 Node11_11_8 Node11_12_8 101.31578947368422
R_11_11_8_3 Node11_11_8 Node12_11_8 149.8112
C_11_11_8 Node11_11_8 GND 1.714453125e-07
R_11_11_9_1 Node11_11_9 Node11_11_10 101.31578947368422
R_11_11_9_2 Node11_11_9 Node11_12_9 101.31578947368422
R_11_11_9_3 Node11_11_9 Node12_11_9 149.8112
C_11_11_9 Node11_11_9 GND 1.714453125e-07
R_11_11_10_1 Node11_11_10 Node11_11_11 101.31578947368422
R_11_11_10_2 Node11_11_10 Node11_12_10 101.31578947368422
R_11_11_10_3 Node11_11_10 Node12_11_10 149.8112
C_11_11_10 Node11_11_10 GND 1.714453125e-07
R_11_11_11_1 Node11_11_11 Node11_11_12 101.31578947368422
R_11_11_11_2 Node11_11_11 Node11_12_11 101.31578947368422
R_11_11_11_3 Node11_11_11 Node12_11_11 149.8112
C_11_11_11 Node11_11_11 GND 1.714453125e-07
R_11_11_12_1 Node11_11_12 Node11_11_13 101.31578947368422
R_11_11_12_2 Node11_11_12 Node11_12_12 101.31578947368422
R_11_11_12_3 Node11_11_12 Node12_11_12 149.8112
C_11_11_12 Node11_11_12 GND 1.714453125e-07
R_11_11_13_1 Node11_11_13 Node11_11_14 101.31578947368422
R_11_11_13_2 Node11_11_13 Node11_12_13 101.31578947368422
R_11_11_13_3 Node11_11_13 Node12_11_13 149.8112
C_11_11_13 Node11_11_13 GND 1.714453125e-07
R_11_11_14_1 Node11_11_14 Node11_11_15 101.31578947368418
R_11_11_14_2 Node11_11_14 Node11_12_14 101.31578947368422
R_11_11_14_3 Node11_11_14 Node12_11_14 149.8112
C_11_11_14 Node11_11_14 GND 1.714453125e-07
R_11_11_15_2 Node11_11_15 Node11_12_15 101.31578947368413
R_11_11_15_3 Node11_11_15 Node12_11_15 149.81119999999987
C_11_11_15 Node11_11_15 GND 1.7144531250000017e-07
R_11_12_0_1 Node11_12_0 Node11_12_1 101.31578947368422
R_11_12_0_2 Node11_12_0 Node11_13_0 101.31578947368422
R_11_12_0_3 Node11_12_0 Node12_12_0 149.8112
C_11_12_0 Node11_12_0 GND 1.714453125e-07
R_11_12_1_1 Node11_12_1 Node11_12_2 101.31578947368422
R_11_12_1_2 Node11_12_1 Node11_13_1 101.31578947368422
R_11_12_1_3 Node11_12_1 Node12_12_1 149.8112
C_11_12_1 Node11_12_1 GND 1.714453125e-07
R_11_12_2_1 Node11_12_2 Node11_12_3 101.31578947368422
R_11_12_2_2 Node11_12_2 Node11_13_2 101.31578947368422
R_11_12_2_3 Node11_12_2 Node12_12_2 149.8112
C_11_12_2 Node11_12_2 GND 1.714453125e-07
R_11_12_3_1 Node11_12_3 Node11_12_4 101.31578947368422
R_11_12_3_2 Node11_12_3 Node11_13_3 101.31578947368422
R_11_12_3_3 Node11_12_3 Node12_12_3 149.8112
C_11_12_3 Node11_12_3 GND 1.714453125e-07
R_11_12_4_1 Node11_12_4 Node11_12_5 101.31578947368422
R_11_12_4_2 Node11_12_4 Node11_13_4 101.31578947368422
R_11_12_4_3 Node11_12_4 Node12_12_4 149.8112
C_11_12_4 Node11_12_4 GND 1.714453125e-07
R_11_12_5_1 Node11_12_5 Node11_12_6 101.31578947368422
R_11_12_5_2 Node11_12_5 Node11_13_5 101.31578947368422
R_11_12_5_3 Node11_12_5 Node12_12_5 149.8112
C_11_12_5 Node11_12_5 GND 1.714453125e-07
R_11_12_6_1 Node11_12_6 Node11_12_7 101.31578947368422
R_11_12_6_2 Node11_12_6 Node11_13_6 101.31578947368422
R_11_12_6_3 Node11_12_6 Node12_12_6 149.8112
C_11_12_6 Node11_12_6 GND 1.714453125e-07
R_11_12_7_1 Node11_12_7 Node11_12_8 101.31578947368422
R_11_12_7_2 Node11_12_7 Node11_13_7 101.31578947368422
R_11_12_7_3 Node11_12_7 Node12_12_7 149.8112
C_11_12_7 Node11_12_7 GND 1.714453125e-07
R_11_12_8_1 Node11_12_8 Node11_12_9 101.31578947368422
R_11_12_8_2 Node11_12_8 Node11_13_8 101.31578947368422
R_11_12_8_3 Node11_12_8 Node12_12_8 149.8112
C_11_12_8 Node11_12_8 GND 1.714453125e-07
R_11_12_9_1 Node11_12_9 Node11_12_10 101.31578947368422
R_11_12_9_2 Node11_12_9 Node11_13_9 101.31578947368422
R_11_12_9_3 Node11_12_9 Node12_12_9 149.8112
C_11_12_9 Node11_12_9 GND 1.714453125e-07
R_11_12_10_1 Node11_12_10 Node11_12_11 101.31578947368422
R_11_12_10_2 Node11_12_10 Node11_13_10 101.31578947368422
R_11_12_10_3 Node11_12_10 Node12_12_10 149.8112
C_11_12_10 Node11_12_10 GND 1.714453125e-07
R_11_12_11_1 Node11_12_11 Node11_12_12 101.31578947368422
R_11_12_11_2 Node11_12_11 Node11_13_11 101.31578947368422
R_11_12_11_3 Node11_12_11 Node12_12_11 149.8112
C_11_12_11 Node11_12_11 GND 1.714453125e-07
R_11_12_12_1 Node11_12_12 Node11_12_13 101.31578947368422
R_11_12_12_2 Node11_12_12 Node11_13_12 101.31578947368422
R_11_12_12_3 Node11_12_12 Node12_12_12 149.8112
C_11_12_12 Node11_12_12 GND 1.714453125e-07
R_11_12_13_1 Node11_12_13 Node11_12_14 101.31578947368422
R_11_12_13_2 Node11_12_13 Node11_13_13 101.31578947368422
R_11_12_13_3 Node11_12_13 Node12_12_13 149.8112
C_11_12_13 Node11_12_13 GND 1.714453125e-07
R_11_12_14_1 Node11_12_14 Node11_12_15 101.31578947368418
R_11_12_14_2 Node11_12_14 Node11_13_14 101.31578947368422
R_11_12_14_3 Node11_12_14 Node12_12_14 149.8112
C_11_12_14 Node11_12_14 GND 1.714453125e-07
R_11_12_15_2 Node11_12_15 Node11_13_15 101.31578947368413
R_11_12_15_3 Node11_12_15 Node12_12_15 149.81119999999987
C_11_12_15 Node11_12_15 GND 1.7144531250000017e-07
R_11_13_0_1 Node11_13_0 Node11_13_1 101.31578947368422
R_11_13_0_2 Node11_13_0 Node11_14_0 101.31578947368422
R_11_13_0_3 Node11_13_0 Node12_13_0 149.8112
C_11_13_0 Node11_13_0 GND 1.714453125e-07
R_11_13_1_1 Node11_13_1 Node11_13_2 101.31578947368422
R_11_13_1_2 Node11_13_1 Node11_14_1 101.31578947368422
R_11_13_1_3 Node11_13_1 Node12_13_1 149.8112
C_11_13_1 Node11_13_1 GND 1.714453125e-07
R_11_13_2_1 Node11_13_2 Node11_13_3 101.31578947368422
R_11_13_2_2 Node11_13_2 Node11_14_2 101.31578947368422
R_11_13_2_3 Node11_13_2 Node12_13_2 149.8112
C_11_13_2 Node11_13_2 GND 1.714453125e-07
R_11_13_3_1 Node11_13_3 Node11_13_4 101.31578947368422
R_11_13_3_2 Node11_13_3 Node11_14_3 101.31578947368422
R_11_13_3_3 Node11_13_3 Node12_13_3 149.8112
C_11_13_3 Node11_13_3 GND 1.714453125e-07
R_11_13_4_1 Node11_13_4 Node11_13_5 101.31578947368422
R_11_13_4_2 Node11_13_4 Node11_14_4 101.31578947368422
R_11_13_4_3 Node11_13_4 Node12_13_4 149.8112
C_11_13_4 Node11_13_4 GND 1.714453125e-07
R_11_13_5_1 Node11_13_5 Node11_13_6 101.31578947368422
R_11_13_5_2 Node11_13_5 Node11_14_5 101.31578947368422
R_11_13_5_3 Node11_13_5 Node12_13_5 149.8112
C_11_13_5 Node11_13_5 GND 1.714453125e-07
R_11_13_6_1 Node11_13_6 Node11_13_7 101.31578947368422
R_11_13_6_2 Node11_13_6 Node11_14_6 101.31578947368422
R_11_13_6_3 Node11_13_6 Node12_13_6 149.8112
C_11_13_6 Node11_13_6 GND 1.714453125e-07
R_11_13_7_1 Node11_13_7 Node11_13_8 101.31578947368422
R_11_13_7_2 Node11_13_7 Node11_14_7 101.31578947368422
R_11_13_7_3 Node11_13_7 Node12_13_7 149.8112
C_11_13_7 Node11_13_7 GND 1.714453125e-07
R_11_13_8_1 Node11_13_8 Node11_13_9 101.31578947368422
R_11_13_8_2 Node11_13_8 Node11_14_8 101.31578947368422
R_11_13_8_3 Node11_13_8 Node12_13_8 149.8112
C_11_13_8 Node11_13_8 GND 1.714453125e-07
R_11_13_9_1 Node11_13_9 Node11_13_10 101.31578947368422
R_11_13_9_2 Node11_13_9 Node11_14_9 101.31578947368422
R_11_13_9_3 Node11_13_9 Node12_13_9 149.8112
C_11_13_9 Node11_13_9 GND 1.714453125e-07
R_11_13_10_1 Node11_13_10 Node11_13_11 101.31578947368422
R_11_13_10_2 Node11_13_10 Node11_14_10 101.31578947368422
R_11_13_10_3 Node11_13_10 Node12_13_10 149.8112
C_11_13_10 Node11_13_10 GND 1.714453125e-07
R_11_13_11_1 Node11_13_11 Node11_13_12 101.31578947368422
R_11_13_11_2 Node11_13_11 Node11_14_11 101.31578947368422
R_11_13_11_3 Node11_13_11 Node12_13_11 149.8112
C_11_13_11 Node11_13_11 GND 1.714453125e-07
R_11_13_12_1 Node11_13_12 Node11_13_13 101.31578947368422
R_11_13_12_2 Node11_13_12 Node11_14_12 101.31578947368422
R_11_13_12_3 Node11_13_12 Node12_13_12 149.8112
C_11_13_12 Node11_13_12 GND 1.714453125e-07
R_11_13_13_1 Node11_13_13 Node11_13_14 101.31578947368422
R_11_13_13_2 Node11_13_13 Node11_14_13 101.31578947368422
R_11_13_13_3 Node11_13_13 Node12_13_13 149.8112
C_11_13_13 Node11_13_13 GND 1.714453125e-07
R_11_13_14_1 Node11_13_14 Node11_13_15 101.31578947368418
R_11_13_14_2 Node11_13_14 Node11_14_14 101.31578947368422
R_11_13_14_3 Node11_13_14 Node12_13_14 149.8112
C_11_13_14 Node11_13_14 GND 1.714453125e-07
R_11_13_15_2 Node11_13_15 Node11_14_15 101.31578947368413
R_11_13_15_3 Node11_13_15 Node12_13_15 149.81119999999987
C_11_13_15 Node11_13_15 GND 1.7144531250000017e-07
R_11_14_0_1 Node11_14_0 Node11_14_1 101.31578947368422
R_11_14_0_2 Node11_14_0 Node11_15_0 101.31578947368422
R_11_14_0_3 Node11_14_0 Node12_14_0 149.8112
C_11_14_0 Node11_14_0 GND 1.714453125e-07
R_11_14_1_1 Node11_14_1 Node11_14_2 101.31578947368422
R_11_14_1_2 Node11_14_1 Node11_15_1 101.31578947368422
R_11_14_1_3 Node11_14_1 Node12_14_1 149.8112
C_11_14_1 Node11_14_1 GND 1.714453125e-07
R_11_14_2_1 Node11_14_2 Node11_14_3 101.31578947368422
R_11_14_2_2 Node11_14_2 Node11_15_2 101.31578947368422
R_11_14_2_3 Node11_14_2 Node12_14_2 149.8112
C_11_14_2 Node11_14_2 GND 1.714453125e-07
R_11_14_3_1 Node11_14_3 Node11_14_4 101.31578947368422
R_11_14_3_2 Node11_14_3 Node11_15_3 101.31578947368422
R_11_14_3_3 Node11_14_3 Node12_14_3 149.8112
C_11_14_3 Node11_14_3 GND 1.714453125e-07
R_11_14_4_1 Node11_14_4 Node11_14_5 101.31578947368422
R_11_14_4_2 Node11_14_4 Node11_15_4 101.31578947368422
R_11_14_4_3 Node11_14_4 Node12_14_4 149.8112
C_11_14_4 Node11_14_4 GND 1.714453125e-07
R_11_14_5_1 Node11_14_5 Node11_14_6 101.31578947368422
R_11_14_5_2 Node11_14_5 Node11_15_5 101.31578947368422
R_11_14_5_3 Node11_14_5 Node12_14_5 149.8112
C_11_14_5 Node11_14_5 GND 1.714453125e-07
R_11_14_6_1 Node11_14_6 Node11_14_7 101.31578947368422
R_11_14_6_2 Node11_14_6 Node11_15_6 101.31578947368422
R_11_14_6_3 Node11_14_6 Node12_14_6 149.8112
C_11_14_6 Node11_14_6 GND 1.714453125e-07
R_11_14_7_1 Node11_14_7 Node11_14_8 101.31578947368422
R_11_14_7_2 Node11_14_7 Node11_15_7 101.31578947368422
R_11_14_7_3 Node11_14_7 Node12_14_7 149.8112
C_11_14_7 Node11_14_7 GND 1.714453125e-07
R_11_14_8_1 Node11_14_8 Node11_14_9 101.31578947368422
R_11_14_8_2 Node11_14_8 Node11_15_8 101.31578947368422
R_11_14_8_3 Node11_14_8 Node12_14_8 149.8112
C_11_14_8 Node11_14_8 GND 1.714453125e-07
R_11_14_9_1 Node11_14_9 Node11_14_10 101.31578947368422
R_11_14_9_2 Node11_14_9 Node11_15_9 101.31578947368422
R_11_14_9_3 Node11_14_9 Node12_14_9 149.8112
C_11_14_9 Node11_14_9 GND 1.714453125e-07
R_11_14_10_1 Node11_14_10 Node11_14_11 101.31578947368422
R_11_14_10_2 Node11_14_10 Node11_15_10 101.31578947368422
R_11_14_10_3 Node11_14_10 Node12_14_10 149.8112
C_11_14_10 Node11_14_10 GND 1.714453125e-07
R_11_14_11_1 Node11_14_11 Node11_14_12 101.31578947368422
R_11_14_11_2 Node11_14_11 Node11_15_11 101.31578947368422
R_11_14_11_3 Node11_14_11 Node12_14_11 149.8112
C_11_14_11 Node11_14_11 GND 1.714453125e-07
R_11_14_12_1 Node11_14_12 Node11_14_13 101.31578947368422
R_11_14_12_2 Node11_14_12 Node11_15_12 101.31578947368422
R_11_14_12_3 Node11_14_12 Node12_14_12 149.8112
C_11_14_12 Node11_14_12 GND 1.714453125e-07
R_11_14_13_1 Node11_14_13 Node11_14_14 101.31578947368422
R_11_14_13_2 Node11_14_13 Node11_15_13 101.31578947368422
R_11_14_13_3 Node11_14_13 Node12_14_13 149.8112
C_11_14_13 Node11_14_13 GND 1.714453125e-07
R_11_14_14_1 Node11_14_14 Node11_14_15 101.31578947368418
R_11_14_14_2 Node11_14_14 Node11_15_14 101.31578947368422
R_11_14_14_3 Node11_14_14 Node12_14_14 149.8112
C_11_14_14 Node11_14_14 GND 1.714453125e-07
R_11_14_15_2 Node11_14_15 Node11_15_15 101.31578947368412
R_11_14_15_3 Node11_14_15 Node12_14_15 149.81119999999987
C_11_14_15 Node11_14_15 GND 1.7144531250000017e-07
R_11_15_0_1 Node11_15_0 Node11_15_1 101.31578947368422
R_11_15_0_3 Node11_15_0 Node12_15_0 149.8112
C_11_15_0 Node11_15_0 GND 1.714453125e-07
R_11_15_1_1 Node11_15_1 Node11_15_2 101.31578947368422
R_11_15_1_3 Node11_15_1 Node12_15_1 149.8112
C_11_15_1 Node11_15_1 GND 1.714453125e-07
R_11_15_2_1 Node11_15_2 Node11_15_3 101.31578947368422
R_11_15_2_3 Node11_15_2 Node12_15_2 149.8112
C_11_15_2 Node11_15_2 GND 1.714453125e-07
R_11_15_3_1 Node11_15_3 Node11_15_4 101.31578947368422
R_11_15_3_3 Node11_15_3 Node12_15_3 149.8112
C_11_15_3 Node11_15_3 GND 1.714453125e-07
R_11_15_4_1 Node11_15_4 Node11_15_5 101.31578947368422
R_11_15_4_3 Node11_15_4 Node12_15_4 149.8112
C_11_15_4 Node11_15_4 GND 1.714453125e-07
R_11_15_5_1 Node11_15_5 Node11_15_6 101.31578947368422
R_11_15_5_3 Node11_15_5 Node12_15_5 149.8112
C_11_15_5 Node11_15_5 GND 1.714453125e-07
R_11_15_6_1 Node11_15_6 Node11_15_7 101.31578947368422
R_11_15_6_3 Node11_15_6 Node12_15_6 149.8112
C_11_15_6 Node11_15_6 GND 1.714453125e-07
R_11_15_7_1 Node11_15_7 Node11_15_8 101.31578947368422
R_11_15_7_3 Node11_15_7 Node12_15_7 149.8112
C_11_15_7 Node11_15_7 GND 1.714453125e-07
R_11_15_8_1 Node11_15_8 Node11_15_9 101.31578947368422
R_11_15_8_3 Node11_15_8 Node12_15_8 149.8112
C_11_15_8 Node11_15_8 GND 1.714453125e-07
R_11_15_9_1 Node11_15_9 Node11_15_10 101.31578947368422
R_11_15_9_3 Node11_15_9 Node12_15_9 149.8112
C_11_15_9 Node11_15_9 GND 1.714453125e-07
R_11_15_10_1 Node11_15_10 Node11_15_11 101.31578947368422
R_11_15_10_3 Node11_15_10 Node12_15_10 149.8112
C_11_15_10 Node11_15_10 GND 1.714453125e-07
R_11_15_11_1 Node11_15_11 Node11_15_12 101.31578947368422
R_11_15_11_3 Node11_15_11 Node12_15_11 149.8112
C_11_15_11 Node11_15_11 GND 1.714453125e-07
R_11_15_12_1 Node11_15_12 Node11_15_13 101.31578947368422
R_11_15_12_3 Node11_15_12 Node12_15_12 149.8112
C_11_15_12 Node11_15_12 GND 1.714453125e-07
R_11_15_13_1 Node11_15_13 Node11_15_14 101.31578947368422
R_11_15_13_3 Node11_15_13 Node12_15_13 149.8112
C_11_15_13 Node11_15_13 GND 1.714453125e-07
R_11_15_14_1 Node11_15_14 Node11_15_15 101.31578947368416
R_11_15_14_3 Node11_15_14 Node12_15_14 149.8112
C_11_15_14 Node11_15_14 GND 1.714453125e-07
R_11_15_15_3 Node11_15_15 Node12_15_15 149.81119999999984
C_11_15_15 Node11_15_15 GND 1.714453125000002e-07
R_12_0_0_1 Node12_0_0 Node12_0_1 2499999.9999999995
R_12_0_0_2 Node12_0_0 Node12_1_0 2499999.9999999995
R_12_0_0_3 Node12_0_0 GND 2560.0
C_12_0_0 Node12_0_0 GND 2.255859375e-12
R_12_0_1_1 Node12_0_1 Node12_0_2 2499999.9999999995
R_12_0_1_2 Node12_0_1 Node12_1_1 2499999.9999999995
R_12_0_1_3 Node12_0_1 GND 2560.0
C_12_0_1 Node12_0_1 GND 2.255859375e-12
R_12_0_2_1 Node12_0_2 Node12_0_3 2499999.9999999995
R_12_0_2_2 Node12_0_2 Node12_1_2 2499999.9999999995
R_12_0_2_3 Node12_0_2 GND 2560.0
C_12_0_2 Node12_0_2 GND 2.255859375e-12
R_12_0_3_1 Node12_0_3 Node12_0_4 2499999.9999999995
R_12_0_3_2 Node12_0_3 Node12_1_3 2499999.9999999995
R_12_0_3_3 Node12_0_3 GND 2560.0
C_12_0_3 Node12_0_3 GND 2.255859375e-12
R_12_0_4_1 Node12_0_4 Node12_0_5 2499999.9999999995
R_12_0_4_2 Node12_0_4 Node12_1_4 2499999.9999999995
R_12_0_4_3 Node12_0_4 GND 2560.0
C_12_0_4 Node12_0_4 GND 2.255859375e-12
R_12_0_5_1 Node12_0_5 Node12_0_6 2499999.9999999995
R_12_0_5_2 Node12_0_5 Node12_1_5 2499999.9999999995
R_12_0_5_3 Node12_0_5 GND 2560.0
C_12_0_5 Node12_0_5 GND 2.255859375e-12
R_12_0_6_1 Node12_0_6 Node12_0_7 2499999.9999999995
R_12_0_6_2 Node12_0_6 Node12_1_6 2499999.9999999995
R_12_0_6_3 Node12_0_6 GND 2560.0
C_12_0_6 Node12_0_6 GND 2.255859375e-12
R_12_0_7_1 Node12_0_7 Node12_0_8 2499999.9999999995
R_12_0_7_2 Node12_0_7 Node12_1_7 2499999.9999999995
R_12_0_7_3 Node12_0_7 GND 2560.0
C_12_0_7 Node12_0_7 GND 2.255859375e-12
R_12_0_8_1 Node12_0_8 Node12_0_9 2499999.9999999995
R_12_0_8_2 Node12_0_8 Node12_1_8 2499999.9999999995
R_12_0_8_3 Node12_0_8 GND 2560.0
C_12_0_8 Node12_0_8 GND 2.255859375e-12
R_12_0_9_1 Node12_0_9 Node12_0_10 2499999.9999999995
R_12_0_9_2 Node12_0_9 Node12_1_9 2499999.9999999995
R_12_0_9_3 Node12_0_9 GND 2560.0
C_12_0_9 Node12_0_9 GND 2.255859375e-12
R_12_0_10_1 Node12_0_10 Node12_0_11 2499999.9999999995
R_12_0_10_2 Node12_0_10 Node12_1_10 2499999.9999999995
R_12_0_10_3 Node12_0_10 GND 2560.0
C_12_0_10 Node12_0_10 GND 2.255859375e-12
R_12_0_11_1 Node12_0_11 Node12_0_12 2499999.9999999995
R_12_0_11_2 Node12_0_11 Node12_1_11 2499999.9999999995
R_12_0_11_3 Node12_0_11 GND 2560.0
C_12_0_11 Node12_0_11 GND 2.255859375e-12
R_12_0_12_1 Node12_0_12 Node12_0_13 2499999.9999999995
R_12_0_12_2 Node12_0_12 Node12_1_12 2499999.9999999995
R_12_0_12_3 Node12_0_12 GND 2560.0
C_12_0_12 Node12_0_12 GND 2.255859375e-12
R_12_0_13_1 Node12_0_13 Node12_0_14 2499999.9999999995
R_12_0_13_2 Node12_0_13 Node12_1_13 2499999.9999999995
R_12_0_13_3 Node12_0_13 GND 2560.0
C_12_0_13 Node12_0_13 GND 2.255859375e-12
R_12_0_14_1 Node12_0_14 Node12_0_15 2499999.9999999995
R_12_0_14_2 Node12_0_14 Node12_1_14 2499999.9999999995
R_12_0_14_3 Node12_0_14 GND 2560.0
C_12_0_14 Node12_0_14 GND 2.255859375e-12
R_12_0_15_2 Node12_0_15 Node12_1_15 2499999.9999999995
R_12_0_15_3 Node12_0_15 GND 2560.0
C_12_0_15 Node12_0_15 GND 2.255859375e-12
R_12_1_0_1 Node12_1_0 Node12_1_1 2499999.9999999995
R_12_1_0_2 Node12_1_0 Node12_2_0 2499999.9999999995
R_12_1_0_3 Node12_1_0 GND 2560.0
C_12_1_0 Node12_1_0 GND 2.255859375e-12
R_12_1_1_1 Node12_1_1 Node12_1_2 2499999.9999999995
R_12_1_1_2 Node12_1_1 Node12_2_1 2499999.9999999995
R_12_1_1_3 Node12_1_1 GND 2560.0
C_12_1_1 Node12_1_1 GND 2.255859375e-12
R_12_1_2_1 Node12_1_2 Node12_1_3 2499999.9999999995
R_12_1_2_2 Node12_1_2 Node12_2_2 2499999.9999999995
R_12_1_2_3 Node12_1_2 GND 2560.0
C_12_1_2 Node12_1_2 GND 2.255859375e-12
R_12_1_3_1 Node12_1_3 Node12_1_4 2499999.9999999995
R_12_1_3_2 Node12_1_3 Node12_2_3 2499999.9999999995
R_12_1_3_3 Node12_1_3 GND 2560.0
C_12_1_3 Node12_1_3 GND 2.255859375e-12
R_12_1_4_1 Node12_1_4 Node12_1_5 2499999.9999999995
R_12_1_4_2 Node12_1_4 Node12_2_4 2499999.9999999995
R_12_1_4_3 Node12_1_4 GND 2560.0
C_12_1_4 Node12_1_4 GND 2.255859375e-12
R_12_1_5_1 Node12_1_5 Node12_1_6 2499999.9999999995
R_12_1_5_2 Node12_1_5 Node12_2_5 2499999.9999999995
R_12_1_5_3 Node12_1_5 GND 2560.0
C_12_1_5 Node12_1_5 GND 2.255859375e-12
R_12_1_6_1 Node12_1_6 Node12_1_7 2499999.9999999995
R_12_1_6_2 Node12_1_6 Node12_2_6 2499999.9999999995
R_12_1_6_3 Node12_1_6 GND 2560.0
C_12_1_6 Node12_1_6 GND 2.255859375e-12
R_12_1_7_1 Node12_1_7 Node12_1_8 2499999.9999999995
R_12_1_7_2 Node12_1_7 Node12_2_7 2499999.9999999995
R_12_1_7_3 Node12_1_7 GND 2560.0
C_12_1_7 Node12_1_7 GND 2.255859375e-12
R_12_1_8_1 Node12_1_8 Node12_1_9 2499999.9999999995
R_12_1_8_2 Node12_1_8 Node12_2_8 2499999.9999999995
R_12_1_8_3 Node12_1_8 GND 2560.0
C_12_1_8 Node12_1_8 GND 2.255859375e-12
R_12_1_9_1 Node12_1_9 Node12_1_10 2499999.9999999995
R_12_1_9_2 Node12_1_9 Node12_2_9 2499999.9999999995
R_12_1_9_3 Node12_1_9 GND 2560.0
C_12_1_9 Node12_1_9 GND 2.255859375e-12
R_12_1_10_1 Node12_1_10 Node12_1_11 2499999.9999999995
R_12_1_10_2 Node12_1_10 Node12_2_10 2499999.9999999995
R_12_1_10_3 Node12_1_10 GND 2560.0
C_12_1_10 Node12_1_10 GND 2.255859375e-12
R_12_1_11_1 Node12_1_11 Node12_1_12 2499999.9999999995
R_12_1_11_2 Node12_1_11 Node12_2_11 2499999.9999999995
R_12_1_11_3 Node12_1_11 GND 2560.0
C_12_1_11 Node12_1_11 GND 2.255859375e-12
R_12_1_12_1 Node12_1_12 Node12_1_13 2499999.9999999995
R_12_1_12_2 Node12_1_12 Node12_2_12 2499999.9999999995
R_12_1_12_3 Node12_1_12 GND 2560.0
C_12_1_12 Node12_1_12 GND 2.255859375e-12
R_12_1_13_1 Node12_1_13 Node12_1_14 2499999.9999999995
R_12_1_13_2 Node12_1_13 Node12_2_13 2499999.9999999995
R_12_1_13_3 Node12_1_13 GND 2560.0
C_12_1_13 Node12_1_13 GND 2.255859375e-12
R_12_1_14_1 Node12_1_14 Node12_1_15 2499999.9999999995
R_12_1_14_2 Node12_1_14 Node12_2_14 2499999.9999999995
R_12_1_14_3 Node12_1_14 GND 2560.0
C_12_1_14 Node12_1_14 GND 2.255859375e-12
R_12_1_15_2 Node12_1_15 Node12_2_15 2499999.9999999995
R_12_1_15_3 Node12_1_15 GND 2560.0
C_12_1_15 Node12_1_15 GND 2.255859375e-12
R_12_2_0_1 Node12_2_0 Node12_2_1 2499999.9999999995
R_12_2_0_2 Node12_2_0 Node12_3_0 2499999.9999999995
R_12_2_0_3 Node12_2_0 GND 2560.0
C_12_2_0 Node12_2_0 GND 2.255859375e-12
R_12_2_1_1 Node12_2_1 Node12_2_2 2499999.9999999995
R_12_2_1_2 Node12_2_1 Node12_3_1 2499999.9999999995
R_12_2_1_3 Node12_2_1 GND 2560.0
C_12_2_1 Node12_2_1 GND 2.255859375e-12
R_12_2_2_1 Node12_2_2 Node12_2_3 2499999.9999999995
R_12_2_2_2 Node12_2_2 Node12_3_2 2499999.9999999995
R_12_2_2_3 Node12_2_2 GND 2560.0
C_12_2_2 Node12_2_2 GND 2.255859375e-12
R_12_2_3_1 Node12_2_3 Node12_2_4 2499999.9999999995
R_12_2_3_2 Node12_2_3 Node12_3_3 2499999.9999999995
R_12_2_3_3 Node12_2_3 GND 2560.0
C_12_2_3 Node12_2_3 GND 2.255859375e-12
R_12_2_4_1 Node12_2_4 Node12_2_5 2499999.9999999995
R_12_2_4_2 Node12_2_4 Node12_3_4 2499999.9999999995
R_12_2_4_3 Node12_2_4 GND 2560.0
C_12_2_4 Node12_2_4 GND 2.255859375e-12
R_12_2_5_1 Node12_2_5 Node12_2_6 2499999.9999999995
R_12_2_5_2 Node12_2_5 Node12_3_5 2499999.9999999995
R_12_2_5_3 Node12_2_5 GND 2560.0
C_12_2_5 Node12_2_5 GND 2.255859375e-12
R_12_2_6_1 Node12_2_6 Node12_2_7 2499999.9999999995
R_12_2_6_2 Node12_2_6 Node12_3_6 2499999.9999999995
R_12_2_6_3 Node12_2_6 GND 2560.0
C_12_2_6 Node12_2_6 GND 2.255859375e-12
R_12_2_7_1 Node12_2_7 Node12_2_8 2499999.9999999995
R_12_2_7_2 Node12_2_7 Node12_3_7 2499999.9999999995
R_12_2_7_3 Node12_2_7 GND 2560.0
C_12_2_7 Node12_2_7 GND 2.255859375e-12
R_12_2_8_1 Node12_2_8 Node12_2_9 2499999.9999999995
R_12_2_8_2 Node12_2_8 Node12_3_8 2499999.9999999995
R_12_2_8_3 Node12_2_8 GND 2560.0
C_12_2_8 Node12_2_8 GND 2.255859375e-12
R_12_2_9_1 Node12_2_9 Node12_2_10 2499999.9999999995
R_12_2_9_2 Node12_2_9 Node12_3_9 2499999.9999999995
R_12_2_9_3 Node12_2_9 GND 2560.0
C_12_2_9 Node12_2_9 GND 2.255859375e-12
R_12_2_10_1 Node12_2_10 Node12_2_11 2499999.9999999995
R_12_2_10_2 Node12_2_10 Node12_3_10 2499999.9999999995
R_12_2_10_3 Node12_2_10 GND 2560.0
C_12_2_10 Node12_2_10 GND 2.255859375e-12
R_12_2_11_1 Node12_2_11 Node12_2_12 2499999.9999999995
R_12_2_11_2 Node12_2_11 Node12_3_11 2499999.9999999995
R_12_2_11_3 Node12_2_11 GND 2560.0
C_12_2_11 Node12_2_11 GND 2.255859375e-12
R_12_2_12_1 Node12_2_12 Node12_2_13 2499999.9999999995
R_12_2_12_2 Node12_2_12 Node12_3_12 2499999.9999999995
R_12_2_12_3 Node12_2_12 GND 2560.0
C_12_2_12 Node12_2_12 GND 2.255859375e-12
R_12_2_13_1 Node12_2_13 Node12_2_14 2499999.9999999995
R_12_2_13_2 Node12_2_13 Node12_3_13 2499999.9999999995
R_12_2_13_3 Node12_2_13 GND 2560.0
C_12_2_13 Node12_2_13 GND 2.255859375e-12
R_12_2_14_1 Node12_2_14 Node12_2_15 2499999.9999999995
R_12_2_14_2 Node12_2_14 Node12_3_14 2499999.9999999995
R_12_2_14_3 Node12_2_14 GND 2560.0
C_12_2_14 Node12_2_14 GND 2.255859375e-12
R_12_2_15_2 Node12_2_15 Node12_3_15 2499999.9999999995
R_12_2_15_3 Node12_2_15 GND 2560.0
C_12_2_15 Node12_2_15 GND 2.255859375e-12
R_12_3_0_1 Node12_3_0 Node12_3_1 2499999.9999999995
R_12_3_0_2 Node12_3_0 Node12_4_0 2499999.9999999995
R_12_3_0_3 Node12_3_0 GND 2560.0
C_12_3_0 Node12_3_0 GND 2.255859375e-12
R_12_3_1_1 Node12_3_1 Node12_3_2 2499999.9999999995
R_12_3_1_2 Node12_3_1 Node12_4_1 2499999.9999999995
R_12_3_1_3 Node12_3_1 GND 2560.0
C_12_3_1 Node12_3_1 GND 2.255859375e-12
R_12_3_2_1 Node12_3_2 Node12_3_3 2499999.9999999995
R_12_3_2_2 Node12_3_2 Node12_4_2 2499999.9999999995
R_12_3_2_3 Node12_3_2 GND 2560.0
C_12_3_2 Node12_3_2 GND 2.255859375e-12
R_12_3_3_1 Node12_3_3 Node12_3_4 2499999.9999999995
R_12_3_3_2 Node12_3_3 Node12_4_3 2499999.9999999995
R_12_3_3_3 Node12_3_3 GND 2560.0
C_12_3_3 Node12_3_3 GND 2.255859375e-12
R_12_3_4_1 Node12_3_4 Node12_3_5 2499999.9999999995
R_12_3_4_2 Node12_3_4 Node12_4_4 2499999.9999999995
R_12_3_4_3 Node12_3_4 GND 2560.0
C_12_3_4 Node12_3_4 GND 2.255859375e-12
R_12_3_5_1 Node12_3_5 Node12_3_6 2499999.9999999995
R_12_3_5_2 Node12_3_5 Node12_4_5 2499999.9999999995
R_12_3_5_3 Node12_3_5 GND 2560.0
C_12_3_5 Node12_3_5 GND 2.255859375e-12
R_12_3_6_1 Node12_3_6 Node12_3_7 2499999.9999999995
R_12_3_6_2 Node12_3_6 Node12_4_6 2499999.9999999995
R_12_3_6_3 Node12_3_6 GND 2560.0
C_12_3_6 Node12_3_6 GND 2.255859375e-12
R_12_3_7_1 Node12_3_7 Node12_3_8 2499999.9999999995
R_12_3_7_2 Node12_3_7 Node12_4_7 2499999.9999999995
R_12_3_7_3 Node12_3_7 GND 2560.0
C_12_3_7 Node12_3_7 GND 2.255859375e-12
R_12_3_8_1 Node12_3_8 Node12_3_9 2499999.9999999995
R_12_3_8_2 Node12_3_8 Node12_4_8 2499999.9999999995
R_12_3_8_3 Node12_3_8 GND 2560.0
C_12_3_8 Node12_3_8 GND 2.255859375e-12
R_12_3_9_1 Node12_3_9 Node12_3_10 2499999.9999999995
R_12_3_9_2 Node12_3_9 Node12_4_9 2499999.9999999995
R_12_3_9_3 Node12_3_9 GND 2560.0
C_12_3_9 Node12_3_9 GND 2.255859375e-12
R_12_3_10_1 Node12_3_10 Node12_3_11 2499999.9999999995
R_12_3_10_2 Node12_3_10 Node12_4_10 2499999.9999999995
R_12_3_10_3 Node12_3_10 GND 2560.0
C_12_3_10 Node12_3_10 GND 2.255859375e-12
R_12_3_11_1 Node12_3_11 Node12_3_12 2499999.9999999995
R_12_3_11_2 Node12_3_11 Node12_4_11 2499999.9999999995
R_12_3_11_3 Node12_3_11 GND 2560.0
C_12_3_11 Node12_3_11 GND 2.255859375e-12
R_12_3_12_1 Node12_3_12 Node12_3_13 2499999.9999999995
R_12_3_12_2 Node12_3_12 Node12_4_12 2499999.9999999995
R_12_3_12_3 Node12_3_12 GND 2560.0
C_12_3_12 Node12_3_12 GND 2.255859375e-12
R_12_3_13_1 Node12_3_13 Node12_3_14 2499999.9999999995
R_12_3_13_2 Node12_3_13 Node12_4_13 2499999.9999999995
R_12_3_13_3 Node12_3_13 GND 2560.0
C_12_3_13 Node12_3_13 GND 2.255859375e-12
R_12_3_14_1 Node12_3_14 Node12_3_15 2499999.9999999995
R_12_3_14_2 Node12_3_14 Node12_4_14 2499999.9999999995
R_12_3_14_3 Node12_3_14 GND 2560.0
C_12_3_14 Node12_3_14 GND 2.255859375e-12
R_12_3_15_2 Node12_3_15 Node12_4_15 2499999.9999999995
R_12_3_15_3 Node12_3_15 GND 2560.0
C_12_3_15 Node12_3_15 GND 2.255859375e-12
R_12_4_0_1 Node12_4_0 Node12_4_1 2499999.9999999995
R_12_4_0_2 Node12_4_0 Node12_5_0 2499999.9999999995
R_12_4_0_3 Node12_4_0 GND 2560.0
C_12_4_0 Node12_4_0 GND 2.255859375e-12
R_12_4_1_1 Node12_4_1 Node12_4_2 2499999.9999999995
R_12_4_1_2 Node12_4_1 Node12_5_1 2499999.9999999995
R_12_4_1_3 Node12_4_1 GND 2560.0
C_12_4_1 Node12_4_1 GND 2.255859375e-12
R_12_4_2_1 Node12_4_2 Node12_4_3 2499999.9999999995
R_12_4_2_2 Node12_4_2 Node12_5_2 2499999.9999999995
R_12_4_2_3 Node12_4_2 GND 2560.0
C_12_4_2 Node12_4_2 GND 2.255859375e-12
R_12_4_3_1 Node12_4_3 Node12_4_4 2499999.9999999995
R_12_4_3_2 Node12_4_3 Node12_5_3 2499999.9999999995
R_12_4_3_3 Node12_4_3 GND 2560.0
C_12_4_3 Node12_4_3 GND 2.255859375e-12
R_12_4_4_1 Node12_4_4 Node12_4_5 2499999.9999999995
R_12_4_4_2 Node12_4_4 Node12_5_4 2499999.9999999995
R_12_4_4_3 Node12_4_4 GND 2560.0
C_12_4_4 Node12_4_4 GND 2.255859375e-12
R_12_4_5_1 Node12_4_5 Node12_4_6 2499999.9999999995
R_12_4_5_2 Node12_4_5 Node12_5_5 2499999.9999999995
R_12_4_5_3 Node12_4_5 GND 2560.0
C_12_4_5 Node12_4_5 GND 2.255859375e-12
R_12_4_6_1 Node12_4_6 Node12_4_7 2499999.9999999995
R_12_4_6_2 Node12_4_6 Node12_5_6 2499999.9999999995
R_12_4_6_3 Node12_4_6 GND 2560.0
C_12_4_6 Node12_4_6 GND 2.255859375e-12
R_12_4_7_1 Node12_4_7 Node12_4_8 2499999.9999999995
R_12_4_7_2 Node12_4_7 Node12_5_7 2499999.9999999995
R_12_4_7_3 Node12_4_7 GND 2560.0
C_12_4_7 Node12_4_7 GND 2.255859375e-12
R_12_4_8_1 Node12_4_8 Node12_4_9 2499999.9999999995
R_12_4_8_2 Node12_4_8 Node12_5_8 2499999.9999999995
R_12_4_8_3 Node12_4_8 GND 2560.0
C_12_4_8 Node12_4_8 GND 2.255859375e-12
R_12_4_9_1 Node12_4_9 Node12_4_10 2499999.9999999995
R_12_4_9_2 Node12_4_9 Node12_5_9 2499999.9999999995
R_12_4_9_3 Node12_4_9 GND 2560.0
C_12_4_9 Node12_4_9 GND 2.255859375e-12
R_12_4_10_1 Node12_4_10 Node12_4_11 2499999.9999999995
R_12_4_10_2 Node12_4_10 Node12_5_10 2499999.9999999995
R_12_4_10_3 Node12_4_10 GND 2560.0
C_12_4_10 Node12_4_10 GND 2.255859375e-12
R_12_4_11_1 Node12_4_11 Node12_4_12 2499999.9999999995
R_12_4_11_2 Node12_4_11 Node12_5_11 2499999.9999999995
R_12_4_11_3 Node12_4_11 GND 2560.0
C_12_4_11 Node12_4_11 GND 2.255859375e-12
R_12_4_12_1 Node12_4_12 Node12_4_13 2499999.9999999995
R_12_4_12_2 Node12_4_12 Node12_5_12 2499999.9999999995
R_12_4_12_3 Node12_4_12 GND 2560.0
C_12_4_12 Node12_4_12 GND 2.255859375e-12
R_12_4_13_1 Node12_4_13 Node12_4_14 2499999.9999999995
R_12_4_13_2 Node12_4_13 Node12_5_13 2499999.9999999995
R_12_4_13_3 Node12_4_13 GND 2560.0
C_12_4_13 Node12_4_13 GND 2.255859375e-12
R_12_4_14_1 Node12_4_14 Node12_4_15 2499999.9999999995
R_12_4_14_2 Node12_4_14 Node12_5_14 2499999.9999999995
R_12_4_14_3 Node12_4_14 GND 2560.0
C_12_4_14 Node12_4_14 GND 2.255859375e-12
R_12_4_15_2 Node12_4_15 Node12_5_15 2499999.9999999995
R_12_4_15_3 Node12_4_15 GND 2560.0
C_12_4_15 Node12_4_15 GND 2.255859375e-12
R_12_5_0_1 Node12_5_0 Node12_5_1 2499999.9999999995
R_12_5_0_2 Node12_5_0 Node12_6_0 2499999.9999999995
R_12_5_0_3 Node12_5_0 GND 2560.0
C_12_5_0 Node12_5_0 GND 2.255859375e-12
R_12_5_1_1 Node12_5_1 Node12_5_2 2499999.9999999995
R_12_5_1_2 Node12_5_1 Node12_6_1 2499999.9999999995
R_12_5_1_3 Node12_5_1 GND 2560.0
C_12_5_1 Node12_5_1 GND 2.255859375e-12
R_12_5_2_1 Node12_5_2 Node12_5_3 2499999.9999999995
R_12_5_2_2 Node12_5_2 Node12_6_2 2499999.9999999995
R_12_5_2_3 Node12_5_2 GND 2560.0
C_12_5_2 Node12_5_2 GND 2.255859375e-12
R_12_5_3_1 Node12_5_3 Node12_5_4 2499999.9999999995
R_12_5_3_2 Node12_5_3 Node12_6_3 2499999.9999999995
R_12_5_3_3 Node12_5_3 GND 2560.0
C_12_5_3 Node12_5_3 GND 2.255859375e-12
R_12_5_4_1 Node12_5_4 Node12_5_5 2499999.9999999995
R_12_5_4_2 Node12_5_4 Node12_6_4 2499999.9999999995
R_12_5_4_3 Node12_5_4 GND 2560.0
C_12_5_4 Node12_5_4 GND 2.255859375e-12
R_12_5_5_1 Node12_5_5 Node12_5_6 2499999.9999999995
R_12_5_5_2 Node12_5_5 Node12_6_5 2499999.9999999995
R_12_5_5_3 Node12_5_5 GND 2560.0
C_12_5_5 Node12_5_5 GND 2.255859375e-12
R_12_5_6_1 Node12_5_6 Node12_5_7 2499999.9999999995
R_12_5_6_2 Node12_5_6 Node12_6_6 2499999.9999999995
R_12_5_6_3 Node12_5_6 GND 2560.0
C_12_5_6 Node12_5_6 GND 2.255859375e-12
R_12_5_7_1 Node12_5_7 Node12_5_8 2499999.9999999995
R_12_5_7_2 Node12_5_7 Node12_6_7 2499999.9999999995
R_12_5_7_3 Node12_5_7 GND 2560.0
C_12_5_7 Node12_5_7 GND 2.255859375e-12
R_12_5_8_1 Node12_5_8 Node12_5_9 2499999.9999999995
R_12_5_8_2 Node12_5_8 Node12_6_8 2499999.9999999995
R_12_5_8_3 Node12_5_8 GND 2560.0
C_12_5_8 Node12_5_8 GND 2.255859375e-12
R_12_5_9_1 Node12_5_9 Node12_5_10 2499999.9999999995
R_12_5_9_2 Node12_5_9 Node12_6_9 2499999.9999999995
R_12_5_9_3 Node12_5_9 GND 2560.0
C_12_5_9 Node12_5_9 GND 2.255859375e-12
R_12_5_10_1 Node12_5_10 Node12_5_11 2499999.9999999995
R_12_5_10_2 Node12_5_10 Node12_6_10 2499999.9999999995
R_12_5_10_3 Node12_5_10 GND 2560.0
C_12_5_10 Node12_5_10 GND 2.255859375e-12
R_12_5_11_1 Node12_5_11 Node12_5_12 2499999.9999999995
R_12_5_11_2 Node12_5_11 Node12_6_11 2499999.9999999995
R_12_5_11_3 Node12_5_11 GND 2560.0
C_12_5_11 Node12_5_11 GND 2.255859375e-12
R_12_5_12_1 Node12_5_12 Node12_5_13 2499999.9999999995
R_12_5_12_2 Node12_5_12 Node12_6_12 2499999.9999999995
R_12_5_12_3 Node12_5_12 GND 2560.0
C_12_5_12 Node12_5_12 GND 2.255859375e-12
R_12_5_13_1 Node12_5_13 Node12_5_14 2499999.9999999995
R_12_5_13_2 Node12_5_13 Node12_6_13 2499999.9999999995
R_12_5_13_3 Node12_5_13 GND 2560.0
C_12_5_13 Node12_5_13 GND 2.255859375e-12
R_12_5_14_1 Node12_5_14 Node12_5_15 2499999.9999999995
R_12_5_14_2 Node12_5_14 Node12_6_14 2499999.9999999995
R_12_5_14_3 Node12_5_14 GND 2560.0
C_12_5_14 Node12_5_14 GND 2.255859375e-12
R_12_5_15_2 Node12_5_15 Node12_6_15 2499999.9999999995
R_12_5_15_3 Node12_5_15 GND 2560.0
C_12_5_15 Node12_5_15 GND 2.255859375e-12
R_12_6_0_1 Node12_6_0 Node12_6_1 2499999.9999999995
R_12_6_0_2 Node12_6_0 Node12_7_0 2499999.9999999995
R_12_6_0_3 Node12_6_0 GND 2560.0
C_12_6_0 Node12_6_0 GND 2.255859375e-12
R_12_6_1_1 Node12_6_1 Node12_6_2 2499999.9999999995
R_12_6_1_2 Node12_6_1 Node12_7_1 2499999.9999999995
R_12_6_1_3 Node12_6_1 GND 2560.0
C_12_6_1 Node12_6_1 GND 2.255859375e-12
R_12_6_2_1 Node12_6_2 Node12_6_3 2499999.9999999995
R_12_6_2_2 Node12_6_2 Node12_7_2 2499999.9999999995
R_12_6_2_3 Node12_6_2 GND 2560.0
C_12_6_2 Node12_6_2 GND 2.255859375e-12
R_12_6_3_1 Node12_6_3 Node12_6_4 2499999.9999999995
R_12_6_3_2 Node12_6_3 Node12_7_3 2499999.9999999995
R_12_6_3_3 Node12_6_3 GND 2560.0
C_12_6_3 Node12_6_3 GND 2.255859375e-12
R_12_6_4_1 Node12_6_4 Node12_6_5 2499999.9999999995
R_12_6_4_2 Node12_6_4 Node12_7_4 2499999.9999999995
R_12_6_4_3 Node12_6_4 GND 2560.0
C_12_6_4 Node12_6_4 GND 2.255859375e-12
R_12_6_5_1 Node12_6_5 Node12_6_6 2499999.9999999995
R_12_6_5_2 Node12_6_5 Node12_7_5 2499999.9999999995
R_12_6_5_3 Node12_6_5 GND 2560.0
C_12_6_5 Node12_6_5 GND 2.255859375e-12
R_12_6_6_1 Node12_6_6 Node12_6_7 2499999.9999999995
R_12_6_6_2 Node12_6_6 Node12_7_6 2499999.9999999995
R_12_6_6_3 Node12_6_6 GND 2560.0
C_12_6_6 Node12_6_6 GND 2.255859375e-12
R_12_6_7_1 Node12_6_7 Node12_6_8 2499999.9999999995
R_12_6_7_2 Node12_6_7 Node12_7_7 2499999.9999999995
R_12_6_7_3 Node12_6_7 GND 2560.0
C_12_6_7 Node12_6_7 GND 2.255859375e-12
R_12_6_8_1 Node12_6_8 Node12_6_9 2499999.9999999995
R_12_6_8_2 Node12_6_8 Node12_7_8 2499999.9999999995
R_12_6_8_3 Node12_6_8 GND 2560.0
C_12_6_8 Node12_6_8 GND 2.255859375e-12
R_12_6_9_1 Node12_6_9 Node12_6_10 2499999.9999999995
R_12_6_9_2 Node12_6_9 Node12_7_9 2499999.9999999995
R_12_6_9_3 Node12_6_9 GND 2560.0
C_12_6_9 Node12_6_9 GND 2.255859375e-12
R_12_6_10_1 Node12_6_10 Node12_6_11 2499999.9999999995
R_12_6_10_2 Node12_6_10 Node12_7_10 2499999.9999999995
R_12_6_10_3 Node12_6_10 GND 2560.0
C_12_6_10 Node12_6_10 GND 2.255859375e-12
R_12_6_11_1 Node12_6_11 Node12_6_12 2499999.9999999995
R_12_6_11_2 Node12_6_11 Node12_7_11 2499999.9999999995
R_12_6_11_3 Node12_6_11 GND 2560.0
C_12_6_11 Node12_6_11 GND 2.255859375e-12
R_12_6_12_1 Node12_6_12 Node12_6_13 2499999.9999999995
R_12_6_12_2 Node12_6_12 Node12_7_12 2499999.9999999995
R_12_6_12_3 Node12_6_12 GND 2560.0
C_12_6_12 Node12_6_12 GND 2.255859375e-12
R_12_6_13_1 Node12_6_13 Node12_6_14 2499999.9999999995
R_12_6_13_2 Node12_6_13 Node12_7_13 2499999.9999999995
R_12_6_13_3 Node12_6_13 GND 2560.0
C_12_6_13 Node12_6_13 GND 2.255859375e-12
R_12_6_14_1 Node12_6_14 Node12_6_15 2499999.9999999995
R_12_6_14_2 Node12_6_14 Node12_7_14 2499999.9999999995
R_12_6_14_3 Node12_6_14 GND 2560.0
C_12_6_14 Node12_6_14 GND 2.255859375e-12
R_12_6_15_2 Node12_6_15 Node12_7_15 2499999.9999999995
R_12_6_15_3 Node12_6_15 GND 2560.0
C_12_6_15 Node12_6_15 GND 2.255859375e-12
R_12_7_0_1 Node12_7_0 Node12_7_1 2499999.9999999995
R_12_7_0_2 Node12_7_0 Node12_8_0 2499999.9999999995
R_12_7_0_3 Node12_7_0 GND 2560.0
C_12_7_0 Node12_7_0 GND 2.255859375e-12
R_12_7_1_1 Node12_7_1 Node12_7_2 2499999.9999999995
R_12_7_1_2 Node12_7_1 Node12_8_1 2499999.9999999995
R_12_7_1_3 Node12_7_1 GND 2560.0
C_12_7_1 Node12_7_1 GND 2.255859375e-12
R_12_7_2_1 Node12_7_2 Node12_7_3 2499999.9999999995
R_12_7_2_2 Node12_7_2 Node12_8_2 2499999.9999999995
R_12_7_2_3 Node12_7_2 GND 2560.0
C_12_7_2 Node12_7_2 GND 2.255859375e-12
R_12_7_3_1 Node12_7_3 Node12_7_4 2499999.9999999995
R_12_7_3_2 Node12_7_3 Node12_8_3 2499999.9999999995
R_12_7_3_3 Node12_7_3 GND 2560.0
C_12_7_3 Node12_7_3 GND 2.255859375e-12
R_12_7_4_1 Node12_7_4 Node12_7_5 2499999.9999999995
R_12_7_4_2 Node12_7_4 Node12_8_4 2499999.9999999995
R_12_7_4_3 Node12_7_4 GND 2560.0
C_12_7_4 Node12_7_4 GND 2.255859375e-12
R_12_7_5_1 Node12_7_5 Node12_7_6 2499999.9999999995
R_12_7_5_2 Node12_7_5 Node12_8_5 2499999.9999999995
R_12_7_5_3 Node12_7_5 GND 2560.0
C_12_7_5 Node12_7_5 GND 2.255859375e-12
R_12_7_6_1 Node12_7_6 Node12_7_7 2499999.9999999995
R_12_7_6_2 Node12_7_6 Node12_8_6 2499999.9999999995
R_12_7_6_3 Node12_7_6 GND 2560.0
C_12_7_6 Node12_7_6 GND 2.255859375e-12
R_12_7_7_1 Node12_7_7 Node12_7_8 2499999.9999999995
R_12_7_7_2 Node12_7_7 Node12_8_7 2499999.9999999995
R_12_7_7_3 Node12_7_7 GND 2560.0
C_12_7_7 Node12_7_7 GND 2.255859375e-12
R_12_7_8_1 Node12_7_8 Node12_7_9 2499999.9999999995
R_12_7_8_2 Node12_7_8 Node12_8_8 2499999.9999999995
R_12_7_8_3 Node12_7_8 GND 2560.0
C_12_7_8 Node12_7_8 GND 2.255859375e-12
R_12_7_9_1 Node12_7_9 Node12_7_10 2499999.9999999995
R_12_7_9_2 Node12_7_9 Node12_8_9 2499999.9999999995
R_12_7_9_3 Node12_7_9 GND 2560.0
C_12_7_9 Node12_7_9 GND 2.255859375e-12
R_12_7_10_1 Node12_7_10 Node12_7_11 2499999.9999999995
R_12_7_10_2 Node12_7_10 Node12_8_10 2499999.9999999995
R_12_7_10_3 Node12_7_10 GND 2560.0
C_12_7_10 Node12_7_10 GND 2.255859375e-12
R_12_7_11_1 Node12_7_11 Node12_7_12 2499999.9999999995
R_12_7_11_2 Node12_7_11 Node12_8_11 2499999.9999999995
R_12_7_11_3 Node12_7_11 GND 2560.0
C_12_7_11 Node12_7_11 GND 2.255859375e-12
R_12_7_12_1 Node12_7_12 Node12_7_13 2499999.9999999995
R_12_7_12_2 Node12_7_12 Node12_8_12 2499999.9999999995
R_12_7_12_3 Node12_7_12 GND 2560.0
C_12_7_12 Node12_7_12 GND 2.255859375e-12
R_12_7_13_1 Node12_7_13 Node12_7_14 2499999.9999999995
R_12_7_13_2 Node12_7_13 Node12_8_13 2499999.9999999995
R_12_7_13_3 Node12_7_13 GND 2560.0
C_12_7_13 Node12_7_13 GND 2.255859375e-12
R_12_7_14_1 Node12_7_14 Node12_7_15 2499999.9999999995
R_12_7_14_2 Node12_7_14 Node12_8_14 2499999.9999999995
R_12_7_14_3 Node12_7_14 GND 2560.0
C_12_7_14 Node12_7_14 GND 2.255859375e-12
R_12_7_15_2 Node12_7_15 Node12_8_15 2499999.9999999995
R_12_7_15_3 Node12_7_15 GND 2560.0
C_12_7_15 Node12_7_15 GND 2.255859375e-12
R_12_8_0_1 Node12_8_0 Node12_8_1 2499999.9999999995
R_12_8_0_2 Node12_8_0 Node12_9_0 2499999.9999999995
R_12_8_0_3 Node12_8_0 GND 2560.0
C_12_8_0 Node12_8_0 GND 2.255859375e-12
R_12_8_1_1 Node12_8_1 Node12_8_2 2499999.9999999995
R_12_8_1_2 Node12_8_1 Node12_9_1 2499999.9999999995
R_12_8_1_3 Node12_8_1 GND 2560.0
C_12_8_1 Node12_8_1 GND 2.255859375e-12
R_12_8_2_1 Node12_8_2 Node12_8_3 2499999.9999999995
R_12_8_2_2 Node12_8_2 Node12_9_2 2499999.9999999995
R_12_8_2_3 Node12_8_2 GND 2560.0
C_12_8_2 Node12_8_2 GND 2.255859375e-12
R_12_8_3_1 Node12_8_3 Node12_8_4 2499999.9999999995
R_12_8_3_2 Node12_8_3 Node12_9_3 2499999.9999999995
R_12_8_3_3 Node12_8_3 GND 2560.0
C_12_8_3 Node12_8_3 GND 2.255859375e-12
R_12_8_4_1 Node12_8_4 Node12_8_5 2499999.9999999995
R_12_8_4_2 Node12_8_4 Node12_9_4 2499999.9999999995
R_12_8_4_3 Node12_8_4 GND 2560.0
C_12_8_4 Node12_8_4 GND 2.255859375e-12
R_12_8_5_1 Node12_8_5 Node12_8_6 2499999.9999999995
R_12_8_5_2 Node12_8_5 Node12_9_5 2499999.9999999995
R_12_8_5_3 Node12_8_5 GND 2560.0
C_12_8_5 Node12_8_5 GND 2.255859375e-12
R_12_8_6_1 Node12_8_6 Node12_8_7 2499999.9999999995
R_12_8_6_2 Node12_8_6 Node12_9_6 2499999.9999999995
R_12_8_6_3 Node12_8_6 GND 2560.0
C_12_8_6 Node12_8_6 GND 2.255859375e-12
R_12_8_7_1 Node12_8_7 Node12_8_8 2499999.9999999995
R_12_8_7_2 Node12_8_7 Node12_9_7 2499999.9999999995
R_12_8_7_3 Node12_8_7 GND 2560.0
C_12_8_7 Node12_8_7 GND 2.255859375e-12
R_12_8_8_1 Node12_8_8 Node12_8_9 2499999.9999999995
R_12_8_8_2 Node12_8_8 Node12_9_8 2499999.9999999995
R_12_8_8_3 Node12_8_8 GND 2560.0
C_12_8_8 Node12_8_8 GND 2.255859375e-12
R_12_8_9_1 Node12_8_9 Node12_8_10 2499999.9999999995
R_12_8_9_2 Node12_8_9 Node12_9_9 2499999.9999999995
R_12_8_9_3 Node12_8_9 GND 2560.0
C_12_8_9 Node12_8_9 GND 2.255859375e-12
R_12_8_10_1 Node12_8_10 Node12_8_11 2499999.9999999995
R_12_8_10_2 Node12_8_10 Node12_9_10 2499999.9999999995
R_12_8_10_3 Node12_8_10 GND 2560.0
C_12_8_10 Node12_8_10 GND 2.255859375e-12
R_12_8_11_1 Node12_8_11 Node12_8_12 2499999.9999999995
R_12_8_11_2 Node12_8_11 Node12_9_11 2499999.9999999995
R_12_8_11_3 Node12_8_11 GND 2560.0
C_12_8_11 Node12_8_11 GND 2.255859375e-12
R_12_8_12_1 Node12_8_12 Node12_8_13 2499999.9999999995
R_12_8_12_2 Node12_8_12 Node12_9_12 2499999.9999999995
R_12_8_12_3 Node12_8_12 GND 2560.0
C_12_8_12 Node12_8_12 GND 2.255859375e-12
R_12_8_13_1 Node12_8_13 Node12_8_14 2499999.9999999995
R_12_8_13_2 Node12_8_13 Node12_9_13 2499999.9999999995
R_12_8_13_3 Node12_8_13 GND 2560.0
C_12_8_13 Node12_8_13 GND 2.255859375e-12
R_12_8_14_1 Node12_8_14 Node12_8_15 2499999.9999999995
R_12_8_14_2 Node12_8_14 Node12_9_14 2499999.9999999995
R_12_8_14_3 Node12_8_14 GND 2560.0
C_12_8_14 Node12_8_14 GND 2.255859375e-12
R_12_8_15_2 Node12_8_15 Node12_9_15 2499999.9999999995
R_12_8_15_3 Node12_8_15 GND 2560.0
C_12_8_15 Node12_8_15 GND 2.255859375e-12
R_12_9_0_1 Node12_9_0 Node12_9_1 2499999.9999999995
R_12_9_0_2 Node12_9_0 Node12_10_0 2499999.9999999995
R_12_9_0_3 Node12_9_0 GND 2560.0
C_12_9_0 Node12_9_0 GND 2.255859375e-12
R_12_9_1_1 Node12_9_1 Node12_9_2 2499999.9999999995
R_12_9_1_2 Node12_9_1 Node12_10_1 2499999.9999999995
R_12_9_1_3 Node12_9_1 GND 2560.0
C_12_9_1 Node12_9_1 GND 2.255859375e-12
R_12_9_2_1 Node12_9_2 Node12_9_3 2499999.9999999995
R_12_9_2_2 Node12_9_2 Node12_10_2 2499999.9999999995
R_12_9_2_3 Node12_9_2 GND 2560.0
C_12_9_2 Node12_9_2 GND 2.255859375e-12
R_12_9_3_1 Node12_9_3 Node12_9_4 2499999.9999999995
R_12_9_3_2 Node12_9_3 Node12_10_3 2499999.9999999995
R_12_9_3_3 Node12_9_3 GND 2560.0
C_12_9_3 Node12_9_3 GND 2.255859375e-12
R_12_9_4_1 Node12_9_4 Node12_9_5 2499999.9999999995
R_12_9_4_2 Node12_9_4 Node12_10_4 2499999.9999999995
R_12_9_4_3 Node12_9_4 GND 2560.0
C_12_9_4 Node12_9_4 GND 2.255859375e-12
R_12_9_5_1 Node12_9_5 Node12_9_6 2499999.9999999995
R_12_9_5_2 Node12_9_5 Node12_10_5 2499999.9999999995
R_12_9_5_3 Node12_9_5 GND 2560.0
C_12_9_5 Node12_9_5 GND 2.255859375e-12
R_12_9_6_1 Node12_9_6 Node12_9_7 2499999.9999999995
R_12_9_6_2 Node12_9_6 Node12_10_6 2499999.9999999995
R_12_9_6_3 Node12_9_6 GND 2560.0
C_12_9_6 Node12_9_6 GND 2.255859375e-12
R_12_9_7_1 Node12_9_7 Node12_9_8 2499999.9999999995
R_12_9_7_2 Node12_9_7 Node12_10_7 2499999.9999999995
R_12_9_7_3 Node12_9_7 GND 2560.0
C_12_9_7 Node12_9_7 GND 2.255859375e-12
R_12_9_8_1 Node12_9_8 Node12_9_9 2499999.9999999995
R_12_9_8_2 Node12_9_8 Node12_10_8 2499999.9999999995
R_12_9_8_3 Node12_9_8 GND 2560.0
C_12_9_8 Node12_9_8 GND 2.255859375e-12
R_12_9_9_1 Node12_9_9 Node12_9_10 2499999.9999999995
R_12_9_9_2 Node12_9_9 Node12_10_9 2499999.9999999995
R_12_9_9_3 Node12_9_9 GND 2560.0
C_12_9_9 Node12_9_9 GND 2.255859375e-12
R_12_9_10_1 Node12_9_10 Node12_9_11 2499999.9999999995
R_12_9_10_2 Node12_9_10 Node12_10_10 2499999.9999999995
R_12_9_10_3 Node12_9_10 GND 2560.0
C_12_9_10 Node12_9_10 GND 2.255859375e-12
R_12_9_11_1 Node12_9_11 Node12_9_12 2499999.9999999995
R_12_9_11_2 Node12_9_11 Node12_10_11 2499999.9999999995
R_12_9_11_3 Node12_9_11 GND 2560.0
C_12_9_11 Node12_9_11 GND 2.255859375e-12
R_12_9_12_1 Node12_9_12 Node12_9_13 2499999.9999999995
R_12_9_12_2 Node12_9_12 Node12_10_12 2499999.9999999995
R_12_9_12_3 Node12_9_12 GND 2560.0
C_12_9_12 Node12_9_12 GND 2.255859375e-12
R_12_9_13_1 Node12_9_13 Node12_9_14 2499999.9999999995
R_12_9_13_2 Node12_9_13 Node12_10_13 2499999.9999999995
R_12_9_13_3 Node12_9_13 GND 2560.0
C_12_9_13 Node12_9_13 GND 2.255859375e-12
R_12_9_14_1 Node12_9_14 Node12_9_15 2499999.9999999995
R_12_9_14_2 Node12_9_14 Node12_10_14 2499999.9999999995
R_12_9_14_3 Node12_9_14 GND 2560.0
C_12_9_14 Node12_9_14 GND 2.255859375e-12
R_12_9_15_2 Node12_9_15 Node12_10_15 2499999.9999999995
R_12_9_15_3 Node12_9_15 GND 2560.0
C_12_9_15 Node12_9_15 GND 2.255859375e-12
R_12_10_0_1 Node12_10_0 Node12_10_1 2499999.9999999995
R_12_10_0_2 Node12_10_0 Node12_11_0 2499999.9999999995
R_12_10_0_3 Node12_10_0 GND 2560.0
C_12_10_0 Node12_10_0 GND 2.255859375e-12
R_12_10_1_1 Node12_10_1 Node12_10_2 2499999.9999999995
R_12_10_1_2 Node12_10_1 Node12_11_1 2499999.9999999995
R_12_10_1_3 Node12_10_1 GND 2560.0
C_12_10_1 Node12_10_1 GND 2.255859375e-12
R_12_10_2_1 Node12_10_2 Node12_10_3 2499999.9999999995
R_12_10_2_2 Node12_10_2 Node12_11_2 2499999.9999999995
R_12_10_2_3 Node12_10_2 GND 2560.0
C_12_10_2 Node12_10_2 GND 2.255859375e-12
R_12_10_3_1 Node12_10_3 Node12_10_4 2499999.9999999995
R_12_10_3_2 Node12_10_3 Node12_11_3 2499999.9999999995
R_12_10_3_3 Node12_10_3 GND 2560.0
C_12_10_3 Node12_10_3 GND 2.255859375e-12
R_12_10_4_1 Node12_10_4 Node12_10_5 2499999.9999999995
R_12_10_4_2 Node12_10_4 Node12_11_4 2499999.9999999995
R_12_10_4_3 Node12_10_4 GND 2560.0
C_12_10_4 Node12_10_4 GND 2.255859375e-12
R_12_10_5_1 Node12_10_5 Node12_10_6 2499999.9999999995
R_12_10_5_2 Node12_10_5 Node12_11_5 2499999.9999999995
R_12_10_5_3 Node12_10_5 GND 2560.0
C_12_10_5 Node12_10_5 GND 2.255859375e-12
R_12_10_6_1 Node12_10_6 Node12_10_7 2499999.9999999995
R_12_10_6_2 Node12_10_6 Node12_11_6 2499999.9999999995
R_12_10_6_3 Node12_10_6 GND 2560.0
C_12_10_6 Node12_10_6 GND 2.255859375e-12
R_12_10_7_1 Node12_10_7 Node12_10_8 2499999.9999999995
R_12_10_7_2 Node12_10_7 Node12_11_7 2499999.9999999995
R_12_10_7_3 Node12_10_7 GND 2560.0
C_12_10_7 Node12_10_7 GND 2.255859375e-12
R_12_10_8_1 Node12_10_8 Node12_10_9 2499999.9999999995
R_12_10_8_2 Node12_10_8 Node12_11_8 2499999.9999999995
R_12_10_8_3 Node12_10_8 GND 2560.0
C_12_10_8 Node12_10_8 GND 2.255859375e-12
R_12_10_9_1 Node12_10_9 Node12_10_10 2499999.9999999995
R_12_10_9_2 Node12_10_9 Node12_11_9 2499999.9999999995
R_12_10_9_3 Node12_10_9 GND 2560.0
C_12_10_9 Node12_10_9 GND 2.255859375e-12
R_12_10_10_1 Node12_10_10 Node12_10_11 2499999.9999999995
R_12_10_10_2 Node12_10_10 Node12_11_10 2499999.9999999995
R_12_10_10_3 Node12_10_10 GND 2560.0
C_12_10_10 Node12_10_10 GND 2.255859375e-12
R_12_10_11_1 Node12_10_11 Node12_10_12 2499999.9999999995
R_12_10_11_2 Node12_10_11 Node12_11_11 2499999.9999999995
R_12_10_11_3 Node12_10_11 GND 2560.0
C_12_10_11 Node12_10_11 GND 2.255859375e-12
R_12_10_12_1 Node12_10_12 Node12_10_13 2499999.9999999995
R_12_10_12_2 Node12_10_12 Node12_11_12 2499999.9999999995
R_12_10_12_3 Node12_10_12 GND 2560.0
C_12_10_12 Node12_10_12 GND 2.255859375e-12
R_12_10_13_1 Node12_10_13 Node12_10_14 2499999.9999999995
R_12_10_13_2 Node12_10_13 Node12_11_13 2499999.9999999995
R_12_10_13_3 Node12_10_13 GND 2560.0
C_12_10_13 Node12_10_13 GND 2.255859375e-12
R_12_10_14_1 Node12_10_14 Node12_10_15 2499999.9999999995
R_12_10_14_2 Node12_10_14 Node12_11_14 2499999.9999999995
R_12_10_14_3 Node12_10_14 GND 2560.0
C_12_10_14 Node12_10_14 GND 2.255859375e-12
R_12_10_15_2 Node12_10_15 Node12_11_15 2499999.9999999995
R_12_10_15_3 Node12_10_15 GND 2560.0
C_12_10_15 Node12_10_15 GND 2.255859375e-12
R_12_11_0_1 Node12_11_0 Node12_11_1 2499999.9999999995
R_12_11_0_2 Node12_11_0 Node12_12_0 2499999.9999999995
R_12_11_0_3 Node12_11_0 GND 2560.0
C_12_11_0 Node12_11_0 GND 2.255859375e-12
R_12_11_1_1 Node12_11_1 Node12_11_2 2499999.9999999995
R_12_11_1_2 Node12_11_1 Node12_12_1 2499999.9999999995
R_12_11_1_3 Node12_11_1 GND 2560.0
C_12_11_1 Node12_11_1 GND 2.255859375e-12
R_12_11_2_1 Node12_11_2 Node12_11_3 2499999.9999999995
R_12_11_2_2 Node12_11_2 Node12_12_2 2499999.9999999995
R_12_11_2_3 Node12_11_2 GND 2560.0
C_12_11_2 Node12_11_2 GND 2.255859375e-12
R_12_11_3_1 Node12_11_3 Node12_11_4 2499999.9999999995
R_12_11_3_2 Node12_11_3 Node12_12_3 2499999.9999999995
R_12_11_3_3 Node12_11_3 GND 2560.0
C_12_11_3 Node12_11_3 GND 2.255859375e-12
R_12_11_4_1 Node12_11_4 Node12_11_5 2499999.9999999995
R_12_11_4_2 Node12_11_4 Node12_12_4 2499999.9999999995
R_12_11_4_3 Node12_11_4 GND 2560.0
C_12_11_4 Node12_11_4 GND 2.255859375e-12
R_12_11_5_1 Node12_11_5 Node12_11_6 2499999.9999999995
R_12_11_5_2 Node12_11_5 Node12_12_5 2499999.9999999995
R_12_11_5_3 Node12_11_5 GND 2560.0
C_12_11_5 Node12_11_5 GND 2.255859375e-12
R_12_11_6_1 Node12_11_6 Node12_11_7 2499999.9999999995
R_12_11_6_2 Node12_11_6 Node12_12_6 2499999.9999999995
R_12_11_6_3 Node12_11_6 GND 2560.0
C_12_11_6 Node12_11_6 GND 2.255859375e-12
R_12_11_7_1 Node12_11_7 Node12_11_8 2499999.9999999995
R_12_11_7_2 Node12_11_7 Node12_12_7 2499999.9999999995
R_12_11_7_3 Node12_11_7 GND 2560.0
C_12_11_7 Node12_11_7 GND 2.255859375e-12
R_12_11_8_1 Node12_11_8 Node12_11_9 2499999.9999999995
R_12_11_8_2 Node12_11_8 Node12_12_8 2499999.9999999995
R_12_11_8_3 Node12_11_8 GND 2560.0
C_12_11_8 Node12_11_8 GND 2.255859375e-12
R_12_11_9_1 Node12_11_9 Node12_11_10 2499999.9999999995
R_12_11_9_2 Node12_11_9 Node12_12_9 2499999.9999999995
R_12_11_9_3 Node12_11_9 GND 2560.0
C_12_11_9 Node12_11_9 GND 2.255859375e-12
R_12_11_10_1 Node12_11_10 Node12_11_11 2499999.9999999995
R_12_11_10_2 Node12_11_10 Node12_12_10 2499999.9999999995
R_12_11_10_3 Node12_11_10 GND 2560.0
C_12_11_10 Node12_11_10 GND 2.255859375e-12
R_12_11_11_1 Node12_11_11 Node12_11_12 2499999.9999999995
R_12_11_11_2 Node12_11_11 Node12_12_11 2499999.9999999995
R_12_11_11_3 Node12_11_11 GND 2560.0
C_12_11_11 Node12_11_11 GND 2.255859375e-12
R_12_11_12_1 Node12_11_12 Node12_11_13 2499999.9999999995
R_12_11_12_2 Node12_11_12 Node12_12_12 2499999.9999999995
R_12_11_12_3 Node12_11_12 GND 2560.0
C_12_11_12 Node12_11_12 GND 2.255859375e-12
R_12_11_13_1 Node12_11_13 Node12_11_14 2499999.9999999995
R_12_11_13_2 Node12_11_13 Node12_12_13 2499999.9999999995
R_12_11_13_3 Node12_11_13 GND 2560.0
C_12_11_13 Node12_11_13 GND 2.255859375e-12
R_12_11_14_1 Node12_11_14 Node12_11_15 2499999.9999999995
R_12_11_14_2 Node12_11_14 Node12_12_14 2499999.9999999995
R_12_11_14_3 Node12_11_14 GND 2560.0
C_12_11_14 Node12_11_14 GND 2.255859375e-12
R_12_11_15_2 Node12_11_15 Node12_12_15 2499999.9999999995
R_12_11_15_3 Node12_11_15 GND 2560.0
C_12_11_15 Node12_11_15 GND 2.255859375e-12
R_12_12_0_1 Node12_12_0 Node12_12_1 2499999.9999999995
R_12_12_0_2 Node12_12_0 Node12_13_0 2499999.9999999995
R_12_12_0_3 Node12_12_0 GND 2560.0
C_12_12_0 Node12_12_0 GND 2.255859375e-12
R_12_12_1_1 Node12_12_1 Node12_12_2 2499999.9999999995
R_12_12_1_2 Node12_12_1 Node12_13_1 2499999.9999999995
R_12_12_1_3 Node12_12_1 GND 2560.0
C_12_12_1 Node12_12_1 GND 2.255859375e-12
R_12_12_2_1 Node12_12_2 Node12_12_3 2499999.9999999995
R_12_12_2_2 Node12_12_2 Node12_13_2 2499999.9999999995
R_12_12_2_3 Node12_12_2 GND 2560.0
C_12_12_2 Node12_12_2 GND 2.255859375e-12
R_12_12_3_1 Node12_12_3 Node12_12_4 2499999.9999999995
R_12_12_3_2 Node12_12_3 Node12_13_3 2499999.9999999995
R_12_12_3_3 Node12_12_3 GND 2560.0
C_12_12_3 Node12_12_3 GND 2.255859375e-12
R_12_12_4_1 Node12_12_4 Node12_12_5 2499999.9999999995
R_12_12_4_2 Node12_12_4 Node12_13_4 2499999.9999999995
R_12_12_4_3 Node12_12_4 GND 2560.0
C_12_12_4 Node12_12_4 GND 2.255859375e-12
R_12_12_5_1 Node12_12_5 Node12_12_6 2499999.9999999995
R_12_12_5_2 Node12_12_5 Node12_13_5 2499999.9999999995
R_12_12_5_3 Node12_12_5 GND 2560.0
C_12_12_5 Node12_12_5 GND 2.255859375e-12
R_12_12_6_1 Node12_12_6 Node12_12_7 2499999.9999999995
R_12_12_6_2 Node12_12_6 Node12_13_6 2499999.9999999995
R_12_12_6_3 Node12_12_6 GND 2560.0
C_12_12_6 Node12_12_6 GND 2.255859375e-12
R_12_12_7_1 Node12_12_7 Node12_12_8 2499999.9999999995
R_12_12_7_2 Node12_12_7 Node12_13_7 2499999.9999999995
R_12_12_7_3 Node12_12_7 GND 2560.0
C_12_12_7 Node12_12_7 GND 2.255859375e-12
R_12_12_8_1 Node12_12_8 Node12_12_9 2499999.9999999995
R_12_12_8_2 Node12_12_8 Node12_13_8 2499999.9999999995
R_12_12_8_3 Node12_12_8 GND 2560.0
C_12_12_8 Node12_12_8 GND 2.255859375e-12
R_12_12_9_1 Node12_12_9 Node12_12_10 2499999.9999999995
R_12_12_9_2 Node12_12_9 Node12_13_9 2499999.9999999995
R_12_12_9_3 Node12_12_9 GND 2560.0
C_12_12_9 Node12_12_9 GND 2.255859375e-12
R_12_12_10_1 Node12_12_10 Node12_12_11 2499999.9999999995
R_12_12_10_2 Node12_12_10 Node12_13_10 2499999.9999999995
R_12_12_10_3 Node12_12_10 GND 2560.0
C_12_12_10 Node12_12_10 GND 2.255859375e-12
R_12_12_11_1 Node12_12_11 Node12_12_12 2499999.9999999995
R_12_12_11_2 Node12_12_11 Node12_13_11 2499999.9999999995
R_12_12_11_3 Node12_12_11 GND 2560.0
C_12_12_11 Node12_12_11 GND 2.255859375e-12
R_12_12_12_1 Node12_12_12 Node12_12_13 2499999.9999999995
R_12_12_12_2 Node12_12_12 Node12_13_12 2499999.9999999995
R_12_12_12_3 Node12_12_12 GND 2560.0
C_12_12_12 Node12_12_12 GND 2.255859375e-12
R_12_12_13_1 Node12_12_13 Node12_12_14 2499999.9999999995
R_12_12_13_2 Node12_12_13 Node12_13_13 2499999.9999999995
R_12_12_13_3 Node12_12_13 GND 2560.0
C_12_12_13 Node12_12_13 GND 2.255859375e-12
R_12_12_14_1 Node12_12_14 Node12_12_15 2499999.9999999995
R_12_12_14_2 Node12_12_14 Node12_13_14 2499999.9999999995
R_12_12_14_3 Node12_12_14 GND 2560.0
C_12_12_14 Node12_12_14 GND 2.255859375e-12
R_12_12_15_2 Node12_12_15 Node12_13_15 2499999.9999999995
R_12_12_15_3 Node12_12_15 GND 2560.0
C_12_12_15 Node12_12_15 GND 2.255859375e-12
R_12_13_0_1 Node12_13_0 Node12_13_1 2499999.9999999995
R_12_13_0_2 Node12_13_0 Node12_14_0 2499999.9999999995
R_12_13_0_3 Node12_13_0 GND 2560.0
C_12_13_0 Node12_13_0 GND 2.255859375e-12
R_12_13_1_1 Node12_13_1 Node12_13_2 2499999.9999999995
R_12_13_1_2 Node12_13_1 Node12_14_1 2499999.9999999995
R_12_13_1_3 Node12_13_1 GND 2560.0
C_12_13_1 Node12_13_1 GND 2.255859375e-12
R_12_13_2_1 Node12_13_2 Node12_13_3 2499999.9999999995
R_12_13_2_2 Node12_13_2 Node12_14_2 2499999.9999999995
R_12_13_2_3 Node12_13_2 GND 2560.0
C_12_13_2 Node12_13_2 GND 2.255859375e-12
R_12_13_3_1 Node12_13_3 Node12_13_4 2499999.9999999995
R_12_13_3_2 Node12_13_3 Node12_14_3 2499999.9999999995
R_12_13_3_3 Node12_13_3 GND 2560.0
C_12_13_3 Node12_13_3 GND 2.255859375e-12
R_12_13_4_1 Node12_13_4 Node12_13_5 2499999.9999999995
R_12_13_4_2 Node12_13_4 Node12_14_4 2499999.9999999995
R_12_13_4_3 Node12_13_4 GND 2560.0
C_12_13_4 Node12_13_4 GND 2.255859375e-12
R_12_13_5_1 Node12_13_5 Node12_13_6 2499999.9999999995
R_12_13_5_2 Node12_13_5 Node12_14_5 2499999.9999999995
R_12_13_5_3 Node12_13_5 GND 2560.0
C_12_13_5 Node12_13_5 GND 2.255859375e-12
R_12_13_6_1 Node12_13_6 Node12_13_7 2499999.9999999995
R_12_13_6_2 Node12_13_6 Node12_14_6 2499999.9999999995
R_12_13_6_3 Node12_13_6 GND 2560.0
C_12_13_6 Node12_13_6 GND 2.255859375e-12
R_12_13_7_1 Node12_13_7 Node12_13_8 2499999.9999999995
R_12_13_7_2 Node12_13_7 Node12_14_7 2499999.9999999995
R_12_13_7_3 Node12_13_7 GND 2560.0
C_12_13_7 Node12_13_7 GND 2.255859375e-12
R_12_13_8_1 Node12_13_8 Node12_13_9 2499999.9999999995
R_12_13_8_2 Node12_13_8 Node12_14_8 2499999.9999999995
R_12_13_8_3 Node12_13_8 GND 2560.0
C_12_13_8 Node12_13_8 GND 2.255859375e-12
R_12_13_9_1 Node12_13_9 Node12_13_10 2499999.9999999995
R_12_13_9_2 Node12_13_9 Node12_14_9 2499999.9999999995
R_12_13_9_3 Node12_13_9 GND 2560.0
C_12_13_9 Node12_13_9 GND 2.255859375e-12
R_12_13_10_1 Node12_13_10 Node12_13_11 2499999.9999999995
R_12_13_10_2 Node12_13_10 Node12_14_10 2499999.9999999995
R_12_13_10_3 Node12_13_10 GND 2560.0
C_12_13_10 Node12_13_10 GND 2.255859375e-12
R_12_13_11_1 Node12_13_11 Node12_13_12 2499999.9999999995
R_12_13_11_2 Node12_13_11 Node12_14_11 2499999.9999999995
R_12_13_11_3 Node12_13_11 GND 2560.0
C_12_13_11 Node12_13_11 GND 2.255859375e-12
R_12_13_12_1 Node12_13_12 Node12_13_13 2499999.9999999995
R_12_13_12_2 Node12_13_12 Node12_14_12 2499999.9999999995
R_12_13_12_3 Node12_13_12 GND 2560.0
C_12_13_12 Node12_13_12 GND 2.255859375e-12
R_12_13_13_1 Node12_13_13 Node12_13_14 2499999.9999999995
R_12_13_13_2 Node12_13_13 Node12_14_13 2499999.9999999995
R_12_13_13_3 Node12_13_13 GND 2560.0
C_12_13_13 Node12_13_13 GND 2.255859375e-12
R_12_13_14_1 Node12_13_14 Node12_13_15 2499999.9999999995
R_12_13_14_2 Node12_13_14 Node12_14_14 2499999.9999999995
R_12_13_14_3 Node12_13_14 GND 2560.0
C_12_13_14 Node12_13_14 GND 2.255859375e-12
R_12_13_15_2 Node12_13_15 Node12_14_15 2499999.9999999995
R_12_13_15_3 Node12_13_15 GND 2560.0
C_12_13_15 Node12_13_15 GND 2.255859375e-12
R_12_14_0_1 Node12_14_0 Node12_14_1 2499999.9999999995
R_12_14_0_2 Node12_14_0 Node12_15_0 2499999.9999999995
R_12_14_0_3 Node12_14_0 GND 2560.0
C_12_14_0 Node12_14_0 GND 2.255859375e-12
R_12_14_1_1 Node12_14_1 Node12_14_2 2499999.9999999995
R_12_14_1_2 Node12_14_1 Node12_15_1 2499999.9999999995
R_12_14_1_3 Node12_14_1 GND 2560.0
C_12_14_1 Node12_14_1 GND 2.255859375e-12
R_12_14_2_1 Node12_14_2 Node12_14_3 2499999.9999999995
R_12_14_2_2 Node12_14_2 Node12_15_2 2499999.9999999995
R_12_14_2_3 Node12_14_2 GND 2560.0
C_12_14_2 Node12_14_2 GND 2.255859375e-12
R_12_14_3_1 Node12_14_3 Node12_14_4 2499999.9999999995
R_12_14_3_2 Node12_14_3 Node12_15_3 2499999.9999999995
R_12_14_3_3 Node12_14_3 GND 2560.0
C_12_14_3 Node12_14_3 GND 2.255859375e-12
R_12_14_4_1 Node12_14_4 Node12_14_5 2499999.9999999995
R_12_14_4_2 Node12_14_4 Node12_15_4 2499999.9999999995
R_12_14_4_3 Node12_14_4 GND 2560.0
C_12_14_4 Node12_14_4 GND 2.255859375e-12
R_12_14_5_1 Node12_14_5 Node12_14_6 2499999.9999999995
R_12_14_5_2 Node12_14_5 Node12_15_5 2499999.9999999995
R_12_14_5_3 Node12_14_5 GND 2560.0
C_12_14_5 Node12_14_5 GND 2.255859375e-12
R_12_14_6_1 Node12_14_6 Node12_14_7 2499999.9999999995
R_12_14_6_2 Node12_14_6 Node12_15_6 2499999.9999999995
R_12_14_6_3 Node12_14_6 GND 2560.0
C_12_14_6 Node12_14_6 GND 2.255859375e-12
R_12_14_7_1 Node12_14_7 Node12_14_8 2499999.9999999995
R_12_14_7_2 Node12_14_7 Node12_15_7 2499999.9999999995
R_12_14_7_3 Node12_14_7 GND 2560.0
C_12_14_7 Node12_14_7 GND 2.255859375e-12
R_12_14_8_1 Node12_14_8 Node12_14_9 2499999.9999999995
R_12_14_8_2 Node12_14_8 Node12_15_8 2499999.9999999995
R_12_14_8_3 Node12_14_8 GND 2560.0
C_12_14_8 Node12_14_8 GND 2.255859375e-12
R_12_14_9_1 Node12_14_9 Node12_14_10 2499999.9999999995
R_12_14_9_2 Node12_14_9 Node12_15_9 2499999.9999999995
R_12_14_9_3 Node12_14_9 GND 2560.0
C_12_14_9 Node12_14_9 GND 2.255859375e-12
R_12_14_10_1 Node12_14_10 Node12_14_11 2499999.9999999995
R_12_14_10_2 Node12_14_10 Node12_15_10 2499999.9999999995
R_12_14_10_3 Node12_14_10 GND 2560.0
C_12_14_10 Node12_14_10 GND 2.255859375e-12
R_12_14_11_1 Node12_14_11 Node12_14_12 2499999.9999999995
R_12_14_11_2 Node12_14_11 Node12_15_11 2499999.9999999995
R_12_14_11_3 Node12_14_11 GND 2560.0
C_12_14_11 Node12_14_11 GND 2.255859375e-12
R_12_14_12_1 Node12_14_12 Node12_14_13 2499999.9999999995
R_12_14_12_2 Node12_14_12 Node12_15_12 2499999.9999999995
R_12_14_12_3 Node12_14_12 GND 2560.0
C_12_14_12 Node12_14_12 GND 2.255859375e-12
R_12_14_13_1 Node12_14_13 Node12_14_14 2499999.9999999995
R_12_14_13_2 Node12_14_13 Node12_15_13 2499999.9999999995
R_12_14_13_3 Node12_14_13 GND 2560.0
C_12_14_13 Node12_14_13 GND 2.255859375e-12
R_12_14_14_1 Node12_14_14 Node12_14_15 2499999.9999999995
R_12_14_14_2 Node12_14_14 Node12_15_14 2499999.9999999995
R_12_14_14_3 Node12_14_14 GND 2560.0
C_12_14_14 Node12_14_14 GND 2.255859375e-12
R_12_14_15_2 Node12_14_15 Node12_15_15 2499999.9999999995
R_12_14_15_3 Node12_14_15 GND 2560.0
C_12_14_15 Node12_14_15 GND 2.255859375e-12
R_12_15_0_1 Node12_15_0 Node12_15_1 2499999.9999999995
R_12_15_0_3 Node12_15_0 GND 2560.0
C_12_15_0 Node12_15_0 GND 2.255859375e-12
R_12_15_1_1 Node12_15_1 Node12_15_2 2499999.9999999995
R_12_15_1_3 Node12_15_1 GND 2560.0
C_12_15_1 Node12_15_1 GND 2.255859375e-12
R_12_15_2_1 Node12_15_2 Node12_15_3 2499999.9999999995
R_12_15_2_3 Node12_15_2 GND 2560.0
C_12_15_2 Node12_15_2 GND 2.255859375e-12
R_12_15_3_1 Node12_15_3 Node12_15_4 2499999.9999999995
R_12_15_3_3 Node12_15_3 GND 2560.0
C_12_15_3 Node12_15_3 GND 2.255859375e-12
R_12_15_4_1 Node12_15_4 Node12_15_5 2499999.9999999995
R_12_15_4_3 Node12_15_4 GND 2560.0
C_12_15_4 Node12_15_4 GND 2.255859375e-12
R_12_15_5_1 Node12_15_5 Node12_15_6 2499999.9999999995
R_12_15_5_3 Node12_15_5 GND 2560.0
C_12_15_5 Node12_15_5 GND 2.255859375e-12
R_12_15_6_1 Node12_15_6 Node12_15_7 2499999.9999999995
R_12_15_6_3 Node12_15_6 GND 2560.0
C_12_15_6 Node12_15_6 GND 2.255859375e-12
R_12_15_7_1 Node12_15_7 Node12_15_8 2499999.9999999995
R_12_15_7_3 Node12_15_7 GND 2560.0
C_12_15_7 Node12_15_7 GND 2.255859375e-12
R_12_15_8_1 Node12_15_8 Node12_15_9 2499999.9999999995
R_12_15_8_3 Node12_15_8 GND 2560.0
C_12_15_8 Node12_15_8 GND 2.255859375e-12
R_12_15_9_1 Node12_15_9 Node12_15_10 2499999.9999999995
R_12_15_9_3 Node12_15_9 GND 2560.0
C_12_15_9 Node12_15_9 GND 2.255859375e-12
R_12_15_10_1 Node12_15_10 Node12_15_11 2499999.9999999995
R_12_15_10_3 Node12_15_10 GND 2560.0
C_12_15_10 Node12_15_10 GND 2.255859375e-12
R_12_15_11_1 Node12_15_11 Node12_15_12 2499999.9999999995
R_12_15_11_3 Node12_15_11 GND 2560.0
C_12_15_11 Node12_15_11 GND 2.255859375e-12
R_12_15_12_1 Node12_15_12 Node12_15_13 2499999.9999999995
R_12_15_12_3 Node12_15_12 GND 2560.0
C_12_15_12 Node12_15_12 GND 2.255859375e-12
R_12_15_13_1 Node12_15_13 Node12_15_14 2499999.9999999995
R_12_15_13_3 Node12_15_13 GND 2560.0
C_12_15_13 Node12_15_13 GND 2.255859375e-12
R_12_15_14_1 Node12_15_14 Node12_15_15 2499999.9999999995
R_12_15_14_3 Node12_15_14 GND 2560.0
C_12_15_14 Node12_15_14 GND 2.255859375e-12
R_12_15_15_3 Node12_15_15 GND 2560.0
C_12_15_15 Node12_15_15 GND 2.255859375e-12
.TRAN 3.33us 99.9us
.OPTIONS TIMEINT METHOD=TRAP
.OPTIONS OUTPUT INITIAL_INTERVAL=3.33us 99.9us
.PRINT TRAN FORMAT=CSV PRECISION=4 V(Node0_0_0) V(Node0_0_1) V(Node0_0_2) V(Node0_0_3) V(Node0_0_4) V(Node0_0_5) V(Node0_0_6) V(Node0_0_7) V(Node0_0_8) V(Node0_0_9) V(Node0_0_10) V(Node0_0_11) V(Node0_0_12) V(Node0_0_13) V(Node0_0_14) V(Node0_0_15) V(Node0_1_0) V(Node0_1_1) V(Node0_1_2) V(Node0_1_3) V(Node0_1_4) V(Node0_1_5) V(Node0_1_6) V(Node0_1_7) V(Node0_1_8) V(Node0_1_9) V(Node0_1_10) V(Node0_1_11) V(Node0_1_12) V(Node0_1_13) V(Node0_1_14) V(Node0_1_15) V(Node0_2_0) V(Node0_2_1) V(Node0_2_2) V(Node0_2_3) V(Node0_2_4) V(Node0_2_5) V(Node0_2_6) V(Node0_2_7) V(Node0_2_8) V(Node0_2_9) V(Node0_2_10) V(Node0_2_11) V(Node0_2_12) V(Node0_2_13) V(Node0_2_14) V(Node0_2_15) V(Node0_3_0) V(Node0_3_1) V(Node0_3_2) V(Node0_3_3) V(Node0_3_4) V(Node0_3_5) V(Node0_3_6) V(Node0_3_7) V(Node0_3_8) V(Node0_3_9) V(Node0_3_10) V(Node0_3_11) V(Node0_3_12) V(Node0_3_13) V(Node0_3_14) V(Node0_3_15) V(Node0_4_0) V(Node0_4_1) V(Node0_4_2) V(Node0_4_3) V(Node0_4_4) V(Node0_4_5) V(Node0_4_6) V(Node0_4_7) V(Node0_4_8) V(Node0_4_9) V(Node0_4_10) V(Node0_4_11) V(Node0_4_12) V(Node0_4_13) V(Node0_4_14) V(Node0_4_15) V(Node0_5_0) V(Node0_5_1) V(Node0_5_2) V(Node0_5_3) V(Node0_5_4) V(Node0_5_5) V(Node0_5_6) V(Node0_5_7) V(Node0_5_8) V(Node0_5_9) V(Node0_5_10) V(Node0_5_11) V(Node0_5_12) V(Node0_5_13) V(Node0_5_14) V(Node0_5_15) V(Node0_6_0) V(Node0_6_1) V(Node0_6_2) V(Node0_6_3) V(Node0_6_4) V(Node0_6_5) V(Node0_6_6) V(Node0_6_7) V(Node0_6_8) V(Node0_6_9) V(Node0_6_10) V(Node0_6_11) V(Node0_6_12) V(Node0_6_13) V(Node0_6_14) V(Node0_6_15) V(Node0_7_0) V(Node0_7_1) V(Node0_7_2) V(Node0_7_3) V(Node0_7_4) V(Node0_7_5) V(Node0_7_6) V(Node0_7_7) V(Node0_7_8) V(Node0_7_9) V(Node0_7_10) V(Node0_7_11) V(Node0_7_12) V(Node0_7_13) V(Node0_7_14) V(Node0_7_15) V(Node0_8_0) V(Node0_8_1) V(Node0_8_2) V(Node0_8_3) V(Node0_8_4) V(Node0_8_5) V(Node0_8_6) V(Node0_8_7) V(Node0_8_8) V(Node0_8_9) V(Node0_8_10) V(Node0_8_11) V(Node0_8_12) V(Node0_8_13) V(Node0_8_14) V(Node0_8_15) V(Node0_9_0) V(Node0_9_1) V(Node0_9_2) V(Node0_9_3) V(Node0_9_4) V(Node0_9_5) V(Node0_9_6) V(Node0_9_7) V(Node0_9_8) V(Node0_9_9) V(Node0_9_10) V(Node0_9_11) V(Node0_9_12) V(Node0_9_13) V(Node0_9_14) V(Node0_9_15) V(Node0_10_0) V(Node0_10_1) V(Node0_10_2) V(Node0_10_3) V(Node0_10_4) V(Node0_10_5) V(Node0_10_6) V(Node0_10_7) V(Node0_10_8) V(Node0_10_9) V(Node0_10_10) V(Node0_10_11) V(Node0_10_12) V(Node0_10_13) V(Node0_10_14) V(Node0_10_15) V(Node0_11_0) V(Node0_11_1) V(Node0_11_2) V(Node0_11_3) V(Node0_11_4) V(Node0_11_5) V(Node0_11_6) V(Node0_11_7) V(Node0_11_8) V(Node0_11_9) V(Node0_11_10) V(Node0_11_11) V(Node0_11_12) V(Node0_11_13) V(Node0_11_14) V(Node0_11_15) V(Node0_12_0) V(Node0_12_1) V(Node0_12_2) V(Node0_12_3) V(Node0_12_4) V(Node0_12_5) V(Node0_12_6) V(Node0_12_7) V(Node0_12_8) V(Node0_12_9) V(Node0_12_10) V(Node0_12_11) V(Node0_12_12) V(Node0_12_13) V(Node0_12_14) V(Node0_12_15) V(Node0_13_0) V(Node0_13_1) V(Node0_13_2) V(Node0_13_3) V(Node0_13_4) V(Node0_13_5) V(Node0_13_6) V(Node0_13_7) V(Node0_13_8) V(Node0_13_9) V(Node0_13_10) V(Node0_13_11) V(Node0_13_12) V(Node0_13_13) V(Node0_13_14) V(Node0_13_15) V(Node0_14_0) V(Node0_14_1) V(Node0_14_2) V(Node0_14_3) V(Node0_14_4) V(Node0_14_5) V(Node0_14_6) V(Node0_14_7) V(Node0_14_8) V(Node0_14_9) V(Node0_14_10) V(Node0_14_11) V(Node0_14_12) V(Node0_14_13) V(Node0_14_14) V(Node0_14_15) V(Node0_15_0) V(Node0_15_1) V(Node0_15_2) V(Node0_15_3) V(Node0_15_4) V(Node0_15_5) V(Node0_15_6) V(Node0_15_7) V(Node0_15_8) V(Node0_15_9) V(Node0_15_10) V(Node0_15_11) V(Node0_15_12) V(Node0_15_13) V(Node0_15_14) V(Node0_15_15) V(Node1_0_0) V(Node1_0_1) V(Node1_0_2) V(Node1_0_3) V(Node1_0_4) V(Node1_0_5) V(Node1_0_6) V(Node1_0_7) V(Node1_0_8) V(Node1_0_9) V(Node1_0_10) V(Node1_0_11) V(Node1_0_12) V(Node1_0_13) V(Node1_0_14) V(Node1_0_15) V(Node1_1_0) V(Node1_1_1) V(Node1_1_2) V(Node1_1_3) V(Node1_1_4) V(Node1_1_5) V(Node1_1_6) V(Node1_1_7) V(Node1_1_8) V(Node1_1_9) V(Node1_1_10) V(Node1_1_11) V(Node1_1_12) V(Node1_1_13) V(Node1_1_14) V(Node1_1_15) V(Node1_2_0) V(Node1_2_1) V(Node1_2_2) V(Node1_2_3) V(Node1_2_4) V(Node1_2_5) V(Node1_2_6) V(Node1_2_7) V(Node1_2_8) V(Node1_2_9) V(Node1_2_10) V(Node1_2_11) V(Node1_2_12) V(Node1_2_13) V(Node1_2_14) V(Node1_2_15) V(Node1_3_0) V(Node1_3_1) V(Node1_3_2) V(Node1_3_3) V(Node1_3_4) V(Node1_3_5) V(Node1_3_6) V(Node1_3_7) V(Node1_3_8) V(Node1_3_9) V(Node1_3_10) V(Node1_3_11) V(Node1_3_12) V(Node1_3_13) V(Node1_3_14) V(Node1_3_15) V(Node1_4_0) V(Node1_4_1) V(Node1_4_2) V(Node1_4_3) V(Node1_4_4) V(Node1_4_5) V(Node1_4_6) V(Node1_4_7) V(Node1_4_8) V(Node1_4_9) V(Node1_4_10) V(Node1_4_11) V(Node1_4_12) V(Node1_4_13) V(Node1_4_14) V(Node1_4_15) V(Node1_5_0) V(Node1_5_1) V(Node1_5_2) V(Node1_5_3) V(Node1_5_4) V(Node1_5_5) V(Node1_5_6) V(Node1_5_7) V(Node1_5_8) V(Node1_5_9) V(Node1_5_10) V(Node1_5_11) V(Node1_5_12) V(Node1_5_13) V(Node1_5_14) V(Node1_5_15) V(Node1_6_0) V(Node1_6_1) V(Node1_6_2) V(Node1_6_3) V(Node1_6_4) V(Node1_6_5) V(Node1_6_6) V(Node1_6_7) V(Node1_6_8) V(Node1_6_9) V(Node1_6_10) V(Node1_6_11) V(Node1_6_12) V(Node1_6_13) V(Node1_6_14) V(Node1_6_15) V(Node1_7_0) V(Node1_7_1) V(Node1_7_2) V(Node1_7_3) V(Node1_7_4) V(Node1_7_5) V(Node1_7_6) V(Node1_7_7) V(Node1_7_8) V(Node1_7_9) V(Node1_7_10) V(Node1_7_11) V(Node1_7_12) V(Node1_7_13) V(Node1_7_14) V(Node1_7_15) V(Node1_8_0) V(Node1_8_1) V(Node1_8_2) V(Node1_8_3) V(Node1_8_4) V(Node1_8_5) V(Node1_8_6) V(Node1_8_7) V(Node1_8_8) V(Node1_8_9) V(Node1_8_10) V(Node1_8_11) V(Node1_8_12) V(Node1_8_13) V(Node1_8_14) V(Node1_8_15) V(Node1_9_0) V(Node1_9_1) V(Node1_9_2) V(Node1_9_3) V(Node1_9_4) V(Node1_9_5) V(Node1_9_6) V(Node1_9_7) V(Node1_9_8) V(Node1_9_9) V(Node1_9_10) V(Node1_9_11) V(Node1_9_12) V(Node1_9_13) V(Node1_9_14) V(Node1_9_15) V(Node1_10_0) V(Node1_10_1) V(Node1_10_2) V(Node1_10_3) V(Node1_10_4) V(Node1_10_5) V(Node1_10_6) V(Node1_10_7) V(Node1_10_8) V(Node1_10_9) V(Node1_10_10) V(Node1_10_11) V(Node1_10_12) V(Node1_10_13) V(Node1_10_14) V(Node1_10_15) V(Node1_11_0) V(Node1_11_1) V(Node1_11_2) V(Node1_11_3) V(Node1_11_4) V(Node1_11_5) V(Node1_11_6) V(Node1_11_7) V(Node1_11_8) V(Node1_11_9) V(Node1_11_10) V(Node1_11_11) V(Node1_11_12) V(Node1_11_13) V(Node1_11_14) V(Node1_11_15) V(Node1_12_0) V(Node1_12_1) V(Node1_12_2) V(Node1_12_3) V(Node1_12_4) V(Node1_12_5) V(Node1_12_6) V(Node1_12_7) V(Node1_12_8) V(Node1_12_9) V(Node1_12_10) V(Node1_12_11) V(Node1_12_12) V(Node1_12_13) V(Node1_12_14) V(Node1_12_15) V(Node1_13_0) V(Node1_13_1) V(Node1_13_2) V(Node1_13_3) V(Node1_13_4) V(Node1_13_5) V(Node1_13_6) V(Node1_13_7) V(Node1_13_8) V(Node1_13_9) V(Node1_13_10) V(Node1_13_11) V(Node1_13_12) V(Node1_13_13) V(Node1_13_14) V(Node1_13_15) V(Node1_14_0) V(Node1_14_1) V(Node1_14_2) V(Node1_14_3) V(Node1_14_4) V(Node1_14_5) V(Node1_14_6) V(Node1_14_7) V(Node1_14_8) V(Node1_14_9) V(Node1_14_10) V(Node1_14_11) V(Node1_14_12) V(Node1_14_13) V(Node1_14_14) V(Node1_14_15) V(Node1_15_0) V(Node1_15_1) V(Node1_15_2) V(Node1_15_3) V(Node1_15_4) V(Node1_15_5) V(Node1_15_6) V(Node1_15_7) V(Node1_15_8) V(Node1_15_9) V(Node1_15_10) V(Node1_15_11) V(Node1_15_12) V(Node1_15_13) V(Node1_15_14) V(Node1_15_15) V(Node2_0_0) V(Node2_0_1) V(Node2_0_2) V(Node2_0_3) V(Node2_0_4) V(Node2_0_5) V(Node2_0_6) V(Node2_0_7) V(Node2_0_8) V(Node2_0_9) V(Node2_0_10) V(Node2_0_11) V(Node2_0_12) V(Node2_0_13) V(Node2_0_14) V(Node2_0_15) V(Node2_1_0) V(Node2_1_1) V(Node2_1_2) V(Node2_1_3) V(Node2_1_4) V(Node2_1_5) V(Node2_1_6) V(Node2_1_7) V(Node2_1_8) V(Node2_1_9) V(Node2_1_10) V(Node2_1_11) V(Node2_1_12) V(Node2_1_13) V(Node2_1_14) V(Node2_1_15) V(Node2_2_0) V(Node2_2_1) V(Node2_2_2) V(Node2_2_3) V(Node2_2_4) V(Node2_2_5) V(Node2_2_6) V(Node2_2_7) V(Node2_2_8) V(Node2_2_9) V(Node2_2_10) V(Node2_2_11) V(Node2_2_12) V(Node2_2_13) V(Node2_2_14) V(Node2_2_15) V(Node2_3_0) V(Node2_3_1) V(Node2_3_2) V(Node2_3_3) V(Node2_3_4) V(Node2_3_5) V(Node2_3_6) V(Node2_3_7) V(Node2_3_8) V(Node2_3_9) V(Node2_3_10) V(Node2_3_11) V(Node2_3_12) V(Node2_3_13) V(Node2_3_14) V(Node2_3_15) V(Node2_4_0) V(Node2_4_1) V(Node2_4_2) V(Node2_4_3) V(Node2_4_4) V(Node2_4_5) V(Node2_4_6) V(Node2_4_7) V(Node2_4_8) V(Node2_4_9) V(Node2_4_10) V(Node2_4_11) V(Node2_4_12) V(Node2_4_13) V(Node2_4_14) V(Node2_4_15) V(Node2_5_0) V(Node2_5_1) V(Node2_5_2) V(Node2_5_3) V(Node2_5_4) V(Node2_5_5) V(Node2_5_6) V(Node2_5_7) V(Node2_5_8) V(Node2_5_9) V(Node2_5_10) V(Node2_5_11) V(Node2_5_12) V(Node2_5_13) V(Node2_5_14) V(Node2_5_15) V(Node2_6_0) V(Node2_6_1) V(Node2_6_2) V(Node2_6_3) V(Node2_6_4) V(Node2_6_5) V(Node2_6_6) V(Node2_6_7) V(Node2_6_8) V(Node2_6_9) V(Node2_6_10) V(Node2_6_11) V(Node2_6_12) V(Node2_6_13) V(Node2_6_14) V(Node2_6_15) V(Node2_7_0) V(Node2_7_1) V(Node2_7_2) V(Node2_7_3) V(Node2_7_4) V(Node2_7_5) V(Node2_7_6) V(Node2_7_7) V(Node2_7_8) V(Node2_7_9) V(Node2_7_10) V(Node2_7_11) V(Node2_7_12) V(Node2_7_13) V(Node2_7_14) V(Node2_7_15) V(Node2_8_0) V(Node2_8_1) V(Node2_8_2) V(Node2_8_3) V(Node2_8_4) V(Node2_8_5) V(Node2_8_6) V(Node2_8_7) V(Node2_8_8) V(Node2_8_9) V(Node2_8_10) V(Node2_8_11) V(Node2_8_12) V(Node2_8_13) V(Node2_8_14) V(Node2_8_15) V(Node2_9_0) V(Node2_9_1) V(Node2_9_2) V(Node2_9_3) V(Node2_9_4) V(Node2_9_5) V(Node2_9_6) V(Node2_9_7) V(Node2_9_8) V(Node2_9_9) V(Node2_9_10) V(Node2_9_11) V(Node2_9_12) V(Node2_9_13) V(Node2_9_14) V(Node2_9_15) V(Node2_10_0) V(Node2_10_1) V(Node2_10_2) V(Node2_10_3) V(Node2_10_4) V(Node2_10_5) V(Node2_10_6) V(Node2_10_7) V(Node2_10_8) V(Node2_10_9) V(Node2_10_10) V(Node2_10_11) V(Node2_10_12) V(Node2_10_13) V(Node2_10_14) V(Node2_10_15) V(Node2_11_0) V(Node2_11_1) V(Node2_11_2) V(Node2_11_3) V(Node2_11_4) V(Node2_11_5) V(Node2_11_6) V(Node2_11_7) V(Node2_11_8) V(Node2_11_9) V(Node2_11_10) V(Node2_11_11) V(Node2_11_12) V(Node2_11_13) V(Node2_11_14) V(Node2_11_15) V(Node2_12_0) V(Node2_12_1) V(Node2_12_2) V(Node2_12_3) V(Node2_12_4) V(Node2_12_5) V(Node2_12_6) V(Node2_12_7) V(Node2_12_8) V(Node2_12_9) V(Node2_12_10) V(Node2_12_11) V(Node2_12_12) V(Node2_12_13) V(Node2_12_14) V(Node2_12_15) V(Node2_13_0) V(Node2_13_1) V(Node2_13_2) V(Node2_13_3) V(Node2_13_4) V(Node2_13_5) V(Node2_13_6) V(Node2_13_7) V(Node2_13_8) V(Node2_13_9) V(Node2_13_10) V(Node2_13_11) V(Node2_13_12) V(Node2_13_13) V(Node2_13_14) V(Node2_13_15) V(Node2_14_0) V(Node2_14_1) V(Node2_14_2) V(Node2_14_3) V(Node2_14_4) V(Node2_14_5) V(Node2_14_6) V(Node2_14_7) V(Node2_14_8) V(Node2_14_9) V(Node2_14_10) V(Node2_14_11) V(Node2_14_12) V(Node2_14_13) V(Node2_14_14) V(Node2_14_15) V(Node2_15_0) V(Node2_15_1) V(Node2_15_2) V(Node2_15_3) V(Node2_15_4) V(Node2_15_5) V(Node2_15_6) V(Node2_15_7) V(Node2_15_8) V(Node2_15_9) V(Node2_15_10) V(Node2_15_11) V(Node2_15_12) V(Node2_15_13) V(Node2_15_14) V(Node2_15_15) V(Node3_0_0) V(Node3_0_1) V(Node3_0_2) V(Node3_0_3) V(Node3_0_4) V(Node3_0_5) V(Node3_0_6) V(Node3_0_7) V(Node3_0_8) V(Node3_0_9) V(Node3_0_10) V(Node3_0_11) V(Node3_0_12) V(Node3_0_13) V(Node3_0_14) V(Node3_0_15) V(Node3_1_0) V(Node3_1_1) V(Node3_1_2) V(Node3_1_3) V(Node3_1_4) V(Node3_1_5) V(Node3_1_6) V(Node3_1_7) V(Node3_1_8) V(Node3_1_9) V(Node3_1_10) V(Node3_1_11) V(Node3_1_12) V(Node3_1_13) V(Node3_1_14) V(Node3_1_15) V(Node3_2_0) V(Node3_2_1) V(Node3_2_2) V(Node3_2_3) V(Node3_2_4) V(Node3_2_5) V(Node3_2_6) V(Node3_2_7) V(Node3_2_8) V(Node3_2_9) V(Node3_2_10) V(Node3_2_11) V(Node3_2_12) V(Node3_2_13) V(Node3_2_14) V(Node3_2_15) V(Node3_3_0) V(Node3_3_1) V(Node3_3_2) V(Node3_3_3) V(Node3_3_4) V(Node3_3_5) V(Node3_3_6) V(Node3_3_7) V(Node3_3_8) V(Node3_3_9) V(Node3_3_10) V(Node3_3_11) V(Node3_3_12) V(Node3_3_13) V(Node3_3_14) V(Node3_3_15) V(Node3_4_0) V(Node3_4_1) V(Node3_4_2) V(Node3_4_3) V(Node3_4_4) V(Node3_4_5) V(Node3_4_6) V(Node3_4_7) V(Node3_4_8) V(Node3_4_9) V(Node3_4_10) V(Node3_4_11) V(Node3_4_12) V(Node3_4_13) V(Node3_4_14) V(Node3_4_15) V(Node3_5_0) V(Node3_5_1) V(Node3_5_2) V(Node3_5_3) V(Node3_5_4) V(Node3_5_5) V(Node3_5_6) V(Node3_5_7) V(Node3_5_8) V(Node3_5_9) V(Node3_5_10) V(Node3_5_11) V(Node3_5_12) V(Node3_5_13) V(Node3_5_14) V(Node3_5_15) V(Node3_6_0) V(Node3_6_1) V(Node3_6_2) V(Node3_6_3) V(Node3_6_4) V(Node3_6_5) V(Node3_6_6) V(Node3_6_7) V(Node3_6_8) V(Node3_6_9) V(Node3_6_10) V(Node3_6_11) V(Node3_6_12) V(Node3_6_13) V(Node3_6_14) V(Node3_6_15) V(Node3_7_0) V(Node3_7_1) V(Node3_7_2) V(Node3_7_3) V(Node3_7_4) V(Node3_7_5) V(Node3_7_6) V(Node3_7_7) V(Node3_7_8) V(Node3_7_9) V(Node3_7_10) V(Node3_7_11) V(Node3_7_12) V(Node3_7_13) V(Node3_7_14) V(Node3_7_15) V(Node3_8_0) V(Node3_8_1) V(Node3_8_2) V(Node3_8_3) V(Node3_8_4) V(Node3_8_5) V(Node3_8_6) V(Node3_8_7) V(Node3_8_8) V(Node3_8_9) V(Node3_8_10) V(Node3_8_11) V(Node3_8_12) V(Node3_8_13) V(Node3_8_14) V(Node3_8_15) V(Node3_9_0) V(Node3_9_1) V(Node3_9_2) V(Node3_9_3) V(Node3_9_4) V(Node3_9_5) V(Node3_9_6) V(Node3_9_7) V(Node3_9_8) V(Node3_9_9) V(Node3_9_10) V(Node3_9_11) V(Node3_9_12) V(Node3_9_13) V(Node3_9_14) V(Node3_9_15) V(Node3_10_0) V(Node3_10_1) V(Node3_10_2) V(Node3_10_3) V(Node3_10_4) V(Node3_10_5) V(Node3_10_6) V(Node3_10_7) V(Node3_10_8) V(Node3_10_9) V(Node3_10_10) V(Node3_10_11) V(Node3_10_12) V(Node3_10_13) V(Node3_10_14) V(Node3_10_15) V(Node3_11_0) V(Node3_11_1) V(Node3_11_2) V(Node3_11_3) V(Node3_11_4) V(Node3_11_5) V(Node3_11_6) V(Node3_11_7) V(Node3_11_8) V(Node3_11_9) V(Node3_11_10) V(Node3_11_11) V(Node3_11_12) V(Node3_11_13) V(Node3_11_14) V(Node3_11_15) V(Node3_12_0) V(Node3_12_1) V(Node3_12_2) V(Node3_12_3) V(Node3_12_4) V(Node3_12_5) V(Node3_12_6) V(Node3_12_7) V(Node3_12_8) V(Node3_12_9) V(Node3_12_10) V(Node3_12_11) V(Node3_12_12) V(Node3_12_13) V(Node3_12_14) V(Node3_12_15) V(Node3_13_0) V(Node3_13_1) V(Node3_13_2) V(Node3_13_3) V(Node3_13_4) V(Node3_13_5) V(Node3_13_6) V(Node3_13_7) V(Node3_13_8) V(Node3_13_9) V(Node3_13_10) V(Node3_13_11) V(Node3_13_12) V(Node3_13_13) V(Node3_13_14) V(Node3_13_15) V(Node3_14_0) V(Node3_14_1) V(Node3_14_2) V(Node3_14_3) V(Node3_14_4) V(Node3_14_5) V(Node3_14_6) V(Node3_14_7) V(Node3_14_8) V(Node3_14_9) V(Node3_14_10) V(Node3_14_11) V(Node3_14_12) V(Node3_14_13) V(Node3_14_14) V(Node3_14_15) V(Node3_15_0) V(Node3_15_1) V(Node3_15_2) V(Node3_15_3) V(Node3_15_4) V(Node3_15_5) V(Node3_15_6) V(Node3_15_7) V(Node3_15_8) V(Node3_15_9) V(Node3_15_10) V(Node3_15_11) V(Node3_15_12) V(Node3_15_13) V(Node3_15_14) V(Node3_15_15) V(Node4_0_0) V(Node4_0_1) V(Node4_0_2) V(Node4_0_3) V(Node4_0_4) V(Node4_0_5) V(Node4_0_6) V(Node4_0_7) V(Node4_0_8) V(Node4_0_9) V(Node4_0_10) V(Node4_0_11) V(Node4_0_12) V(Node4_0_13) V(Node4_0_14) V(Node4_0_15) V(Node4_1_0) V(Node4_1_1) V(Node4_1_2) V(Node4_1_3) V(Node4_1_4) V(Node4_1_5) V(Node4_1_6) V(Node4_1_7) V(Node4_1_8) V(Node4_1_9) V(Node4_1_10) V(Node4_1_11) V(Node4_1_12) V(Node4_1_13) V(Node4_1_14) V(Node4_1_15) V(Node4_2_0) V(Node4_2_1) V(Node4_2_2) V(Node4_2_3) V(Node4_2_4) V(Node4_2_5) V(Node4_2_6) V(Node4_2_7) V(Node4_2_8) V(Node4_2_9) V(Node4_2_10) V(Node4_2_11) V(Node4_2_12) V(Node4_2_13) V(Node4_2_14) V(Node4_2_15) V(Node4_3_0) V(Node4_3_1) V(Node4_3_2) V(Node4_3_3) V(Node4_3_4) V(Node4_3_5) V(Node4_3_6) V(Node4_3_7) V(Node4_3_8) V(Node4_3_9) V(Node4_3_10) V(Node4_3_11) V(Node4_3_12) V(Node4_3_13) V(Node4_3_14) V(Node4_3_15) V(Node4_4_0) V(Node4_4_1) V(Node4_4_2) V(Node4_4_3) V(Node4_4_4) V(Node4_4_5) V(Node4_4_6) V(Node4_4_7) V(Node4_4_8) V(Node4_4_9) V(Node4_4_10) V(Node4_4_11) V(Node4_4_12) V(Node4_4_13) V(Node4_4_14) V(Node4_4_15) V(Node4_5_0) V(Node4_5_1) V(Node4_5_2) V(Node4_5_3) V(Node4_5_4) V(Node4_5_5) V(Node4_5_6) V(Node4_5_7) V(Node4_5_8) V(Node4_5_9) V(Node4_5_10) V(Node4_5_11) V(Node4_5_12) V(Node4_5_13) V(Node4_5_14) V(Node4_5_15) V(Node4_6_0) V(Node4_6_1) V(Node4_6_2) V(Node4_6_3) V(Node4_6_4) V(Node4_6_5) V(Node4_6_6) V(Node4_6_7) V(Node4_6_8) V(Node4_6_9) V(Node4_6_10) V(Node4_6_11) V(Node4_6_12) V(Node4_6_13) V(Node4_6_14) V(Node4_6_15) V(Node4_7_0) V(Node4_7_1) V(Node4_7_2) V(Node4_7_3) V(Node4_7_4) V(Node4_7_5) V(Node4_7_6) V(Node4_7_7) V(Node4_7_8) V(Node4_7_9) V(Node4_7_10) V(Node4_7_11) V(Node4_7_12) V(Node4_7_13) V(Node4_7_14) V(Node4_7_15) V(Node4_8_0) V(Node4_8_1) V(Node4_8_2) V(Node4_8_3) V(Node4_8_4) V(Node4_8_5) V(Node4_8_6) V(Node4_8_7) V(Node4_8_8) V(Node4_8_9) V(Node4_8_10) V(Node4_8_11) V(Node4_8_12) V(Node4_8_13) V(Node4_8_14) V(Node4_8_15) V(Node4_9_0) V(Node4_9_1) V(Node4_9_2) V(Node4_9_3) V(Node4_9_4) V(Node4_9_5) V(Node4_9_6) V(Node4_9_7) V(Node4_9_8) V(Node4_9_9) V(Node4_9_10) V(Node4_9_11) V(Node4_9_12) V(Node4_9_13) V(Node4_9_14) V(Node4_9_15) V(Node4_10_0) V(Node4_10_1) V(Node4_10_2) V(Node4_10_3) V(Node4_10_4) V(Node4_10_5) V(Node4_10_6) V(Node4_10_7) V(Node4_10_8) V(Node4_10_9) V(Node4_10_10) V(Node4_10_11) V(Node4_10_12) V(Node4_10_13) V(Node4_10_14) V(Node4_10_15) V(Node4_11_0) V(Node4_11_1) V(Node4_11_2) V(Node4_11_3) V(Node4_11_4) V(Node4_11_5) V(Node4_11_6) V(Node4_11_7) V(Node4_11_8) V(Node4_11_9) V(Node4_11_10) V(Node4_11_11) V(Node4_11_12) V(Node4_11_13) V(Node4_11_14) V(Node4_11_15) V(Node4_12_0) V(Node4_12_1) V(Node4_12_2) V(Node4_12_3) V(Node4_12_4) V(Node4_12_5) V(Node4_12_6) V(Node4_12_7) V(Node4_12_8) V(Node4_12_9) V(Node4_12_10) V(Node4_12_11) V(Node4_12_12) V(Node4_12_13) V(Node4_12_14) V(Node4_12_15) V(Node4_13_0) V(Node4_13_1) V(Node4_13_2) V(Node4_13_3) V(Node4_13_4) V(Node4_13_5) V(Node4_13_6) V(Node4_13_7) V(Node4_13_8) V(Node4_13_9) V(Node4_13_10) V(Node4_13_11) V(Node4_13_12) V(Node4_13_13) V(Node4_13_14) V(Node4_13_15) V(Node4_14_0) V(Node4_14_1) V(Node4_14_2) V(Node4_14_3) V(Node4_14_4) V(Node4_14_5) V(Node4_14_6) V(Node4_14_7) V(Node4_14_8) V(Node4_14_9) V(Node4_14_10) V(Node4_14_11) V(Node4_14_12) V(Node4_14_13) V(Node4_14_14) V(Node4_14_15) V(Node4_15_0) V(Node4_15_1) V(Node4_15_2) V(Node4_15_3) V(Node4_15_4) V(Node4_15_5) V(Node4_15_6) V(Node4_15_7) V(Node4_15_8) V(Node4_15_9) V(Node4_15_10) V(Node4_15_11) V(Node4_15_12) V(Node4_15_13) V(Node4_15_14) V(Node4_15_15) V(Node5_0_0) V(Node5_0_1) V(Node5_0_2) V(Node5_0_3) V(Node5_0_4) V(Node5_0_5) V(Node5_0_6) V(Node5_0_7) V(Node5_0_8) V(Node5_0_9) V(Node5_0_10) V(Node5_0_11) V(Node5_0_12) V(Node5_0_13) V(Node5_0_14) V(Node5_0_15) V(Node5_1_0) V(Node5_1_1) V(Node5_1_2) V(Node5_1_3) V(Node5_1_4) V(Node5_1_5) V(Node5_1_6) V(Node5_1_7) V(Node5_1_8) V(Node5_1_9) V(Node5_1_10) V(Node5_1_11) V(Node5_1_12) V(Node5_1_13) V(Node5_1_14) V(Node5_1_15) V(Node5_2_0) V(Node5_2_1) V(Node5_2_2) V(Node5_2_3) V(Node5_2_4) V(Node5_2_5) V(Node5_2_6) V(Node5_2_7) V(Node5_2_8) V(Node5_2_9) V(Node5_2_10) V(Node5_2_11) V(Node5_2_12) V(Node5_2_13) V(Node5_2_14) V(Node5_2_15) V(Node5_3_0) V(Node5_3_1) V(Node5_3_2) V(Node5_3_3) V(Node5_3_4) V(Node5_3_5) V(Node5_3_6) V(Node5_3_7) V(Node5_3_8) V(Node5_3_9) V(Node5_3_10) V(Node5_3_11) V(Node5_3_12) V(Node5_3_13) V(Node5_3_14) V(Node5_3_15) V(Node5_4_0) V(Node5_4_1) V(Node5_4_2) V(Node5_4_3) V(Node5_4_4) V(Node5_4_5) V(Node5_4_6) V(Node5_4_7) V(Node5_4_8) V(Node5_4_9) V(Node5_4_10) V(Node5_4_11) V(Node5_4_12) V(Node5_4_13) V(Node5_4_14) V(Node5_4_15) V(Node5_5_0) V(Node5_5_1) V(Node5_5_2) V(Node5_5_3) V(Node5_5_4) V(Node5_5_5) V(Node5_5_6) V(Node5_5_7) V(Node5_5_8) V(Node5_5_9) V(Node5_5_10) V(Node5_5_11) V(Node5_5_12) V(Node5_5_13) V(Node5_5_14) V(Node5_5_15) V(Node5_6_0) V(Node5_6_1) V(Node5_6_2) V(Node5_6_3) V(Node5_6_4) V(Node5_6_5) V(Node5_6_6) V(Node5_6_7) V(Node5_6_8) V(Node5_6_9) V(Node5_6_10) V(Node5_6_11) V(Node5_6_12) V(Node5_6_13) V(Node5_6_14) V(Node5_6_15) V(Node5_7_0) V(Node5_7_1) V(Node5_7_2) V(Node5_7_3) V(Node5_7_4) V(Node5_7_5) V(Node5_7_6) V(Node5_7_7) V(Node5_7_8) V(Node5_7_9) V(Node5_7_10) V(Node5_7_11) V(Node5_7_12) V(Node5_7_13) V(Node5_7_14) V(Node5_7_15) V(Node5_8_0) V(Node5_8_1) V(Node5_8_2) V(Node5_8_3) V(Node5_8_4) V(Node5_8_5) V(Node5_8_6) V(Node5_8_7) V(Node5_8_8) V(Node5_8_9) V(Node5_8_10) V(Node5_8_11) V(Node5_8_12) V(Node5_8_13) V(Node5_8_14) V(Node5_8_15) V(Node5_9_0) V(Node5_9_1) V(Node5_9_2) V(Node5_9_3) V(Node5_9_4) V(Node5_9_5) V(Node5_9_6) V(Node5_9_7) V(Node5_9_8) V(Node5_9_9) V(Node5_9_10) V(Node5_9_11) V(Node5_9_12) V(Node5_9_13) V(Node5_9_14) V(Node5_9_15) V(Node5_10_0) V(Node5_10_1) V(Node5_10_2) V(Node5_10_3) V(Node5_10_4) V(Node5_10_5) V(Node5_10_6) V(Node5_10_7) V(Node5_10_8) V(Node5_10_9) V(Node5_10_10) V(Node5_10_11) V(Node5_10_12) V(Node5_10_13) V(Node5_10_14) V(Node5_10_15) V(Node5_11_0) V(Node5_11_1) V(Node5_11_2) V(Node5_11_3) V(Node5_11_4) V(Node5_11_5) V(Node5_11_6) V(Node5_11_7) V(Node5_11_8) V(Node5_11_9) V(Node5_11_10) V(Node5_11_11) V(Node5_11_12) V(Node5_11_13) V(Node5_11_14) V(Node5_11_15) V(Node5_12_0) V(Node5_12_1) V(Node5_12_2) V(Node5_12_3) V(Node5_12_4) V(Node5_12_5) V(Node5_12_6) V(Node5_12_7) V(Node5_12_8) V(Node5_12_9) V(Node5_12_10) V(Node5_12_11) V(Node5_12_12) V(Node5_12_13) V(Node5_12_14) V(Node5_12_15) V(Node5_13_0) V(Node5_13_1) V(Node5_13_2) V(Node5_13_3) V(Node5_13_4) V(Node5_13_5) V(Node5_13_6) V(Node5_13_7) V(Node5_13_8) V(Node5_13_9) V(Node5_13_10) V(Node5_13_11) V(Node5_13_12) V(Node5_13_13) V(Node5_13_14) V(Node5_13_15) V(Node5_14_0) V(Node5_14_1) V(Node5_14_2) V(Node5_14_3) V(Node5_14_4) V(Node5_14_5) V(Node5_14_6) V(Node5_14_7) V(Node5_14_8) V(Node5_14_9) V(Node5_14_10) V(Node5_14_11) V(Node5_14_12) V(Node5_14_13) V(Node5_14_14) V(Node5_14_15) V(Node5_15_0) V(Node5_15_1) V(Node5_15_2) V(Node5_15_3) V(Node5_15_4) V(Node5_15_5) V(Node5_15_6) V(Node5_15_7) V(Node5_15_8) V(Node5_15_9) V(Node5_15_10) V(Node5_15_11) V(Node5_15_12) V(Node5_15_13) V(Node5_15_14) V(Node5_15_15) V(Node6_0_0) V(Node6_0_1) V(Node6_0_2) V(Node6_0_3) V(Node6_0_4) V(Node6_0_5) V(Node6_0_6) V(Node6_0_7) V(Node6_0_8) V(Node6_0_9) V(Node6_0_10) V(Node6_0_11) V(Node6_0_12) V(Node6_0_13) V(Node6_0_14) V(Node6_0_15) V(Node6_1_0) V(Node6_1_1) V(Node6_1_2) V(Node6_1_3) V(Node6_1_4) V(Node6_1_5) V(Node6_1_6) V(Node6_1_7) V(Node6_1_8) V(Node6_1_9) V(Node6_1_10) V(Node6_1_11) V(Node6_1_12) V(Node6_1_13) V(Node6_1_14) V(Node6_1_15) V(Node6_2_0) V(Node6_2_1) V(Node6_2_2) V(Node6_2_3) V(Node6_2_4) V(Node6_2_5) V(Node6_2_6) V(Node6_2_7) V(Node6_2_8) V(Node6_2_9) V(Node6_2_10) V(Node6_2_11) V(Node6_2_12) V(Node6_2_13) V(Node6_2_14) V(Node6_2_15) V(Node6_3_0) V(Node6_3_1) V(Node6_3_2) V(Node6_3_3) V(Node6_3_4) V(Node6_3_5) V(Node6_3_6) V(Node6_3_7) V(Node6_3_8) V(Node6_3_9) V(Node6_3_10) V(Node6_3_11) V(Node6_3_12) V(Node6_3_13) V(Node6_3_14) V(Node6_3_15) V(Node6_4_0) V(Node6_4_1) V(Node6_4_2) V(Node6_4_3) V(Node6_4_4) V(Node6_4_5) V(Node6_4_6) V(Node6_4_7) V(Node6_4_8) V(Node6_4_9) V(Node6_4_10) V(Node6_4_11) V(Node6_4_12) V(Node6_4_13) V(Node6_4_14) V(Node6_4_15) V(Node6_5_0) V(Node6_5_1) V(Node6_5_2) V(Node6_5_3) V(Node6_5_4) V(Node6_5_5) V(Node6_5_6) V(Node6_5_7) V(Node6_5_8) V(Node6_5_9) V(Node6_5_10) V(Node6_5_11) V(Node6_5_12) V(Node6_5_13) V(Node6_5_14) V(Node6_5_15) V(Node6_6_0) V(Node6_6_1) V(Node6_6_2) V(Node6_6_3) V(Node6_6_4) V(Node6_6_5) V(Node6_6_6) V(Node6_6_7) V(Node6_6_8) V(Node6_6_9) V(Node6_6_10) V(Node6_6_11) V(Node6_6_12) V(Node6_6_13) V(Node6_6_14) V(Node6_6_15) V(Node6_7_0) V(Node6_7_1) V(Node6_7_2) V(Node6_7_3) V(Node6_7_4) V(Node6_7_5) V(Node6_7_6) V(Node6_7_7) V(Node6_7_8) V(Node6_7_9) V(Node6_7_10) V(Node6_7_11) V(Node6_7_12) V(Node6_7_13) V(Node6_7_14) V(Node6_7_15) V(Node6_8_0) V(Node6_8_1) V(Node6_8_2) V(Node6_8_3) V(Node6_8_4) V(Node6_8_5) V(Node6_8_6) V(Node6_8_7) V(Node6_8_8) V(Node6_8_9) V(Node6_8_10) V(Node6_8_11) V(Node6_8_12) V(Node6_8_13) V(Node6_8_14) V(Node6_8_15) V(Node6_9_0) V(Node6_9_1) V(Node6_9_2) V(Node6_9_3) V(Node6_9_4) V(Node6_9_5) V(Node6_9_6) V(Node6_9_7) V(Node6_9_8) V(Node6_9_9) V(Node6_9_10) V(Node6_9_11) V(Node6_9_12) V(Node6_9_13) V(Node6_9_14) V(Node6_9_15) V(Node6_10_0) V(Node6_10_1) V(Node6_10_2) V(Node6_10_3) V(Node6_10_4) V(Node6_10_5) V(Node6_10_6) V(Node6_10_7) V(Node6_10_8) V(Node6_10_9) V(Node6_10_10) V(Node6_10_11) V(Node6_10_12) V(Node6_10_13) V(Node6_10_14) V(Node6_10_15) V(Node6_11_0) V(Node6_11_1) V(Node6_11_2) V(Node6_11_3) V(Node6_11_4) V(Node6_11_5) V(Node6_11_6) V(Node6_11_7) V(Node6_11_8) V(Node6_11_9) V(Node6_11_10) V(Node6_11_11) V(Node6_11_12) V(Node6_11_13) V(Node6_11_14) V(Node6_11_15) V(Node6_12_0) V(Node6_12_1) V(Node6_12_2) V(Node6_12_3) V(Node6_12_4) V(Node6_12_5) V(Node6_12_6) V(Node6_12_7) V(Node6_12_8) V(Node6_12_9) V(Node6_12_10) V(Node6_12_11) V(Node6_12_12) V(Node6_12_13) V(Node6_12_14) V(Node6_12_15) V(Node6_13_0) V(Node6_13_1) V(Node6_13_2) V(Node6_13_3) V(Node6_13_4) V(Node6_13_5) V(Node6_13_6) V(Node6_13_7) V(Node6_13_8) V(Node6_13_9) V(Node6_13_10) V(Node6_13_11) V(Node6_13_12) V(Node6_13_13) V(Node6_13_14) V(Node6_13_15) V(Node6_14_0) V(Node6_14_1) V(Node6_14_2) V(Node6_14_3) V(Node6_14_4) V(Node6_14_5) V(Node6_14_6) V(Node6_14_7) V(Node6_14_8) V(Node6_14_9) V(Node6_14_10) V(Node6_14_11) V(Node6_14_12) V(Node6_14_13) V(Node6_14_14) V(Node6_14_15) V(Node6_15_0) V(Node6_15_1) V(Node6_15_2) V(Node6_15_3) V(Node6_15_4) V(Node6_15_5) V(Node6_15_6) V(Node6_15_7) V(Node6_15_8) V(Node6_15_9) V(Node6_15_10) V(Node6_15_11) V(Node6_15_12) V(Node6_15_13) V(Node6_15_14) V(Node6_15_15) V(Node7_0_0) V(Node7_0_1) V(Node7_0_2) V(Node7_0_3) V(Node7_0_4) V(Node7_0_5) V(Node7_0_6) V(Node7_0_7) V(Node7_0_8) V(Node7_0_9) V(Node7_0_10) V(Node7_0_11) V(Node7_0_12) V(Node7_0_13) V(Node7_0_14) V(Node7_0_15) V(Node7_1_0) V(Node7_1_1) V(Node7_1_2) V(Node7_1_3) V(Node7_1_4) V(Node7_1_5) V(Node7_1_6) V(Node7_1_7) V(Node7_1_8) V(Node7_1_9) V(Node7_1_10) V(Node7_1_11) V(Node7_1_12) V(Node7_1_13) V(Node7_1_14) V(Node7_1_15) V(Node7_2_0) V(Node7_2_1) V(Node7_2_2) V(Node7_2_3) V(Node7_2_4) V(Node7_2_5) V(Node7_2_6) V(Node7_2_7) V(Node7_2_8) V(Node7_2_9) V(Node7_2_10) V(Node7_2_11) V(Node7_2_12) V(Node7_2_13) V(Node7_2_14) V(Node7_2_15) V(Node7_3_0) V(Node7_3_1) V(Node7_3_2) V(Node7_3_3) V(Node7_3_4) V(Node7_3_5) V(Node7_3_6) V(Node7_3_7) V(Node7_3_8) V(Node7_3_9) V(Node7_3_10) V(Node7_3_11) V(Node7_3_12) V(Node7_3_13) V(Node7_3_14) V(Node7_3_15) V(Node7_4_0) V(Node7_4_1) V(Node7_4_2) V(Node7_4_3) V(Node7_4_4) V(Node7_4_5) V(Node7_4_6) V(Node7_4_7) V(Node7_4_8) V(Node7_4_9) V(Node7_4_10) V(Node7_4_11) V(Node7_4_12) V(Node7_4_13) V(Node7_4_14) V(Node7_4_15) V(Node7_5_0) V(Node7_5_1) V(Node7_5_2) V(Node7_5_3) V(Node7_5_4) V(Node7_5_5) V(Node7_5_6) V(Node7_5_7) V(Node7_5_8) V(Node7_5_9) V(Node7_5_10) V(Node7_5_11) V(Node7_5_12) V(Node7_5_13) V(Node7_5_14) V(Node7_5_15) V(Node7_6_0) V(Node7_6_1) V(Node7_6_2) V(Node7_6_3) V(Node7_6_4) V(Node7_6_5) V(Node7_6_6) V(Node7_6_7) V(Node7_6_8) V(Node7_6_9) V(Node7_6_10) V(Node7_6_11) V(Node7_6_12) V(Node7_6_13) V(Node7_6_14) V(Node7_6_15) V(Node7_7_0) V(Node7_7_1) V(Node7_7_2) V(Node7_7_3) V(Node7_7_4) V(Node7_7_5) V(Node7_7_6) V(Node7_7_7) V(Node7_7_8) V(Node7_7_9) V(Node7_7_10) V(Node7_7_11) V(Node7_7_12) V(Node7_7_13) V(Node7_7_14) V(Node7_7_15) V(Node7_8_0) V(Node7_8_1) V(Node7_8_2) V(Node7_8_3) V(Node7_8_4) V(Node7_8_5) V(Node7_8_6) V(Node7_8_7) V(Node7_8_8) V(Node7_8_9) V(Node7_8_10) V(Node7_8_11) V(Node7_8_12) V(Node7_8_13) V(Node7_8_14) V(Node7_8_15) V(Node7_9_0) V(Node7_9_1) V(Node7_9_2) V(Node7_9_3) V(Node7_9_4) V(Node7_9_5) V(Node7_9_6) V(Node7_9_7) V(Node7_9_8) V(Node7_9_9) V(Node7_9_10) V(Node7_9_11) V(Node7_9_12) V(Node7_9_13) V(Node7_9_14) V(Node7_9_15) V(Node7_10_0) V(Node7_10_1) V(Node7_10_2) V(Node7_10_3) V(Node7_10_4) V(Node7_10_5) V(Node7_10_6) V(Node7_10_7) V(Node7_10_8) V(Node7_10_9) V(Node7_10_10) V(Node7_10_11) V(Node7_10_12) V(Node7_10_13) V(Node7_10_14) V(Node7_10_15) V(Node7_11_0) V(Node7_11_1) V(Node7_11_2) V(Node7_11_3) V(Node7_11_4) V(Node7_11_5) V(Node7_11_6) V(Node7_11_7) V(Node7_11_8) V(Node7_11_9) V(Node7_11_10) V(Node7_11_11) V(Node7_11_12) V(Node7_11_13) V(Node7_11_14) V(Node7_11_15) V(Node7_12_0) V(Node7_12_1) V(Node7_12_2) V(Node7_12_3) V(Node7_12_4) V(Node7_12_5) V(Node7_12_6) V(Node7_12_7) V(Node7_12_8) V(Node7_12_9) V(Node7_12_10) V(Node7_12_11) V(Node7_12_12) V(Node7_12_13) V(Node7_12_14) V(Node7_12_15) V(Node7_13_0) V(Node7_13_1) V(Node7_13_2) V(Node7_13_3) V(Node7_13_4) V(Node7_13_5) V(Node7_13_6) V(Node7_13_7) V(Node7_13_8) V(Node7_13_9) V(Node7_13_10) V(Node7_13_11) V(Node7_13_12) V(Node7_13_13) V(Node7_13_14) V(Node7_13_15) V(Node7_14_0) V(Node7_14_1) V(Node7_14_2) V(Node7_14_3) V(Node7_14_4) V(Node7_14_5) V(Node7_14_6) V(Node7_14_7) V(Node7_14_8) V(Node7_14_9) V(Node7_14_10) V(Node7_14_11) V(Node7_14_12) V(Node7_14_13) V(Node7_14_14) V(Node7_14_15) V(Node7_15_0) V(Node7_15_1) V(Node7_15_2) V(Node7_15_3) V(Node7_15_4) V(Node7_15_5) V(Node7_15_6) V(Node7_15_7) V(Node7_15_8) V(Node7_15_9) V(Node7_15_10) V(Node7_15_11) V(Node7_15_12) V(Node7_15_13) V(Node7_15_14) V(Node7_15_15) V(Node8_0_0) V(Node8_0_1) V(Node8_0_2) V(Node8_0_3) V(Node8_0_4) V(Node8_0_5) V(Node8_0_6) V(Node8_0_7) V(Node8_0_8) V(Node8_0_9) V(Node8_0_10) V(Node8_0_11) V(Node8_0_12) V(Node8_0_13) V(Node8_0_14) V(Node8_0_15) V(Node8_1_0) V(Node8_1_1) V(Node8_1_2) V(Node8_1_3) V(Node8_1_4) V(Node8_1_5) V(Node8_1_6) V(Node8_1_7) V(Node8_1_8) V(Node8_1_9) V(Node8_1_10) V(Node8_1_11) V(Node8_1_12) V(Node8_1_13) V(Node8_1_14) V(Node8_1_15) V(Node8_2_0) V(Node8_2_1) V(Node8_2_2) V(Node8_2_3) V(Node8_2_4) V(Node8_2_5) V(Node8_2_6) V(Node8_2_7) V(Node8_2_8) V(Node8_2_9) V(Node8_2_10) V(Node8_2_11) V(Node8_2_12) V(Node8_2_13) V(Node8_2_14) V(Node8_2_15) V(Node8_3_0) V(Node8_3_1) V(Node8_3_2) V(Node8_3_3) V(Node8_3_4) V(Node8_3_5) V(Node8_3_6) V(Node8_3_7) V(Node8_3_8) V(Node8_3_9) V(Node8_3_10) V(Node8_3_11) V(Node8_3_12) V(Node8_3_13) V(Node8_3_14) V(Node8_3_15) V(Node8_4_0) V(Node8_4_1) V(Node8_4_2) V(Node8_4_3) V(Node8_4_4) V(Node8_4_5) V(Node8_4_6) V(Node8_4_7) V(Node8_4_8) V(Node8_4_9) V(Node8_4_10) V(Node8_4_11) V(Node8_4_12) V(Node8_4_13) V(Node8_4_14) V(Node8_4_15) V(Node8_5_0) V(Node8_5_1) V(Node8_5_2) V(Node8_5_3) V(Node8_5_4) V(Node8_5_5) V(Node8_5_6) V(Node8_5_7) V(Node8_5_8) V(Node8_5_9) V(Node8_5_10) V(Node8_5_11) V(Node8_5_12) V(Node8_5_13) V(Node8_5_14) V(Node8_5_15) V(Node8_6_0) V(Node8_6_1) V(Node8_6_2) V(Node8_6_3) V(Node8_6_4) V(Node8_6_5) V(Node8_6_6) V(Node8_6_7) V(Node8_6_8) V(Node8_6_9) V(Node8_6_10) V(Node8_6_11) V(Node8_6_12) V(Node8_6_13) V(Node8_6_14) V(Node8_6_15) V(Node8_7_0) V(Node8_7_1) V(Node8_7_2) V(Node8_7_3) V(Node8_7_4) V(Node8_7_5) V(Node8_7_6) V(Node8_7_7) V(Node8_7_8) V(Node8_7_9) V(Node8_7_10) V(Node8_7_11) V(Node8_7_12) V(Node8_7_13) V(Node8_7_14) V(Node8_7_15) V(Node8_8_0) V(Node8_8_1) V(Node8_8_2) V(Node8_8_3) V(Node8_8_4) V(Node8_8_5) V(Node8_8_6) V(Node8_8_7) V(Node8_8_8) V(Node8_8_9) V(Node8_8_10) V(Node8_8_11) V(Node8_8_12) V(Node8_8_13) V(Node8_8_14) V(Node8_8_15) V(Node8_9_0) V(Node8_9_1) V(Node8_9_2) V(Node8_9_3) V(Node8_9_4) V(Node8_9_5) V(Node8_9_6) V(Node8_9_7) V(Node8_9_8) V(Node8_9_9) V(Node8_9_10) V(Node8_9_11) V(Node8_9_12) V(Node8_9_13) V(Node8_9_14) V(Node8_9_15) V(Node8_10_0) V(Node8_10_1) V(Node8_10_2) V(Node8_10_3) V(Node8_10_4) V(Node8_10_5) V(Node8_10_6) V(Node8_10_7) V(Node8_10_8) V(Node8_10_9) V(Node8_10_10) V(Node8_10_11) V(Node8_10_12) V(Node8_10_13) V(Node8_10_14) V(Node8_10_15) V(Node8_11_0) V(Node8_11_1) V(Node8_11_2) V(Node8_11_3) V(Node8_11_4) V(Node8_11_5) V(Node8_11_6) V(Node8_11_7) V(Node8_11_8) V(Node8_11_9) V(Node8_11_10) V(Node8_11_11) V(Node8_11_12) V(Node8_11_13) V(Node8_11_14) V(Node8_11_15) V(Node8_12_0) V(Node8_12_1) V(Node8_12_2) V(Node8_12_3) V(Node8_12_4) V(Node8_12_5) V(Node8_12_6) V(Node8_12_7) V(Node8_12_8) V(Node8_12_9) V(Node8_12_10) V(Node8_12_11) V(Node8_12_12) V(Node8_12_13) V(Node8_12_14) V(Node8_12_15) V(Node8_13_0) V(Node8_13_1) V(Node8_13_2) V(Node8_13_3) V(Node8_13_4) V(Node8_13_5) V(Node8_13_6) V(Node8_13_7) V(Node8_13_8) V(Node8_13_9) V(Node8_13_10) V(Node8_13_11) V(Node8_13_12) V(Node8_13_13) V(Node8_13_14) V(Node8_13_15) V(Node8_14_0) V(Node8_14_1) V(Node8_14_2) V(Node8_14_3) V(Node8_14_4) V(Node8_14_5) V(Node8_14_6) V(Node8_14_7) V(Node8_14_8) V(Node8_14_9) V(Node8_14_10) V(Node8_14_11) V(Node8_14_12) V(Node8_14_13) V(Node8_14_14) V(Node8_14_15) V(Node8_15_0) V(Node8_15_1) V(Node8_15_2) V(Node8_15_3) V(Node8_15_4) V(Node8_15_5) V(Node8_15_6) V(Node8_15_7) V(Node8_15_8) V(Node8_15_9) V(Node8_15_10) V(Node8_15_11) V(Node8_15_12) V(Node8_15_13) V(Node8_15_14) V(Node8_15_15) V(Node9_0_0) V(Node9_0_1) V(Node9_0_2) V(Node9_0_3) V(Node9_0_4) V(Node9_0_5) V(Node9_0_6) V(Node9_0_7) V(Node9_0_8) V(Node9_0_9) V(Node9_0_10) V(Node9_0_11) V(Node9_0_12) V(Node9_0_13) V(Node9_0_14) V(Node9_0_15) V(Node9_1_0) V(Node9_1_1) V(Node9_1_2) V(Node9_1_3) V(Node9_1_4) V(Node9_1_5) V(Node9_1_6) V(Node9_1_7) V(Node9_1_8) V(Node9_1_9) V(Node9_1_10) V(Node9_1_11) V(Node9_1_12) V(Node9_1_13) V(Node9_1_14) V(Node9_1_15) V(Node9_2_0) V(Node9_2_1) V(Node9_2_2) V(Node9_2_3) V(Node9_2_4) V(Node9_2_5) V(Node9_2_6) V(Node9_2_7) V(Node9_2_8) V(Node9_2_9) V(Node9_2_10) V(Node9_2_11) V(Node9_2_12) V(Node9_2_13) V(Node9_2_14) V(Node9_2_15) V(Node9_3_0) V(Node9_3_1) V(Node9_3_2) V(Node9_3_3) V(Node9_3_4) V(Node9_3_5) V(Node9_3_6) V(Node9_3_7) V(Node9_3_8) V(Node9_3_9) V(Node9_3_10) V(Node9_3_11) V(Node9_3_12) V(Node9_3_13) V(Node9_3_14) V(Node9_3_15) V(Node9_4_0) V(Node9_4_1) V(Node9_4_2) V(Node9_4_3) V(Node9_4_4) V(Node9_4_5) V(Node9_4_6) V(Node9_4_7) V(Node9_4_8) V(Node9_4_9) V(Node9_4_10) V(Node9_4_11) V(Node9_4_12) V(Node9_4_13) V(Node9_4_14) V(Node9_4_15) V(Node9_5_0) V(Node9_5_1) V(Node9_5_2) V(Node9_5_3) V(Node9_5_4) V(Node9_5_5) V(Node9_5_6) V(Node9_5_7) V(Node9_5_8) V(Node9_5_9) V(Node9_5_10) V(Node9_5_11) V(Node9_5_12) V(Node9_5_13) V(Node9_5_14) V(Node9_5_15) V(Node9_6_0) V(Node9_6_1) V(Node9_6_2) V(Node9_6_3) V(Node9_6_4) V(Node9_6_5) V(Node9_6_6) V(Node9_6_7) V(Node9_6_8) V(Node9_6_9) V(Node9_6_10) V(Node9_6_11) V(Node9_6_12) V(Node9_6_13) V(Node9_6_14) V(Node9_6_15) V(Node9_7_0) V(Node9_7_1) V(Node9_7_2) V(Node9_7_3) V(Node9_7_4) V(Node9_7_5) V(Node9_7_6) V(Node9_7_7) V(Node9_7_8) V(Node9_7_9) V(Node9_7_10) V(Node9_7_11) V(Node9_7_12) V(Node9_7_13) V(Node9_7_14) V(Node9_7_15) V(Node9_8_0) V(Node9_8_1) V(Node9_8_2) V(Node9_8_3) V(Node9_8_4) V(Node9_8_5) V(Node9_8_6) V(Node9_8_7) V(Node9_8_8) V(Node9_8_9) V(Node9_8_10) V(Node9_8_11) V(Node9_8_12) V(Node9_8_13) V(Node9_8_14) V(Node9_8_15) V(Node9_9_0) V(Node9_9_1) V(Node9_9_2) V(Node9_9_3) V(Node9_9_4) V(Node9_9_5) V(Node9_9_6) V(Node9_9_7) V(Node9_9_8) V(Node9_9_9) V(Node9_9_10) V(Node9_9_11) V(Node9_9_12) V(Node9_9_13) V(Node9_9_14) V(Node9_9_15) V(Node9_10_0) V(Node9_10_1) V(Node9_10_2) V(Node9_10_3) V(Node9_10_4) V(Node9_10_5) V(Node9_10_6) V(Node9_10_7) V(Node9_10_8) V(Node9_10_9) V(Node9_10_10) V(Node9_10_11) V(Node9_10_12) V(Node9_10_13) V(Node9_10_14) V(Node9_10_15) V(Node9_11_0) V(Node9_11_1) V(Node9_11_2) V(Node9_11_3) V(Node9_11_4) V(Node9_11_5) V(Node9_11_6) V(Node9_11_7) V(Node9_11_8) V(Node9_11_9) V(Node9_11_10) V(Node9_11_11) V(Node9_11_12) V(Node9_11_13) V(Node9_11_14) V(Node9_11_15) V(Node9_12_0) V(Node9_12_1) V(Node9_12_2) V(Node9_12_3) V(Node9_12_4) V(Node9_12_5) V(Node9_12_6) V(Node9_12_7) V(Node9_12_8) V(Node9_12_9) V(Node9_12_10) V(Node9_12_11) V(Node9_12_12) V(Node9_12_13) V(Node9_12_14) V(Node9_12_15) V(Node9_13_0) V(Node9_13_1) V(Node9_13_2) V(Node9_13_3) V(Node9_13_4) V(Node9_13_5) V(Node9_13_6) V(Node9_13_7) V(Node9_13_8) V(Node9_13_9) V(Node9_13_10) V(Node9_13_11) V(Node9_13_12) V(Node9_13_13) V(Node9_13_14) V(Node9_13_15) V(Node9_14_0) V(Node9_14_1) V(Node9_14_2) V(Node9_14_3) V(Node9_14_4) V(Node9_14_5) V(Node9_14_6) V(Node9_14_7) V(Node9_14_8) V(Node9_14_9) V(Node9_14_10) V(Node9_14_11) V(Node9_14_12) V(Node9_14_13) V(Node9_14_14) V(Node9_14_15) V(Node9_15_0) V(Node9_15_1) V(Node9_15_2) V(Node9_15_3) V(Node9_15_4) V(Node9_15_5) V(Node9_15_6) V(Node9_15_7) V(Node9_15_8) V(Node9_15_9) V(Node9_15_10) V(Node9_15_11) V(Node9_15_12) V(Node9_15_13) V(Node9_15_14) V(Node9_15_15) V(Node10_0_0) V(Node10_0_1) V(Node10_0_2) V(Node10_0_3) V(Node10_0_4) V(Node10_0_5) V(Node10_0_6) V(Node10_0_7) V(Node10_0_8) V(Node10_0_9) V(Node10_0_10) V(Node10_0_11) V(Node10_0_12) V(Node10_0_13) V(Node10_0_14) V(Node10_0_15) V(Node10_1_0) V(Node10_1_1) V(Node10_1_2) V(Node10_1_3) V(Node10_1_4) V(Node10_1_5) V(Node10_1_6) V(Node10_1_7) V(Node10_1_8) V(Node10_1_9) V(Node10_1_10) V(Node10_1_11) V(Node10_1_12) V(Node10_1_13) V(Node10_1_14) V(Node10_1_15) V(Node10_2_0) V(Node10_2_1) V(Node10_2_2) V(Node10_2_3) V(Node10_2_4) V(Node10_2_5) V(Node10_2_6) V(Node10_2_7) V(Node10_2_8) V(Node10_2_9) V(Node10_2_10) V(Node10_2_11) V(Node10_2_12) V(Node10_2_13) V(Node10_2_14) V(Node10_2_15) V(Node10_3_0) V(Node10_3_1) V(Node10_3_2) V(Node10_3_3) V(Node10_3_4) V(Node10_3_5) V(Node10_3_6) V(Node10_3_7) V(Node10_3_8) V(Node10_3_9) V(Node10_3_10) V(Node10_3_11) V(Node10_3_12) V(Node10_3_13) V(Node10_3_14) V(Node10_3_15) V(Node10_4_0) V(Node10_4_1) V(Node10_4_2) V(Node10_4_3) V(Node10_4_4) V(Node10_4_5) V(Node10_4_6) V(Node10_4_7) V(Node10_4_8) V(Node10_4_9) V(Node10_4_10) V(Node10_4_11) V(Node10_4_12) V(Node10_4_13) V(Node10_4_14) V(Node10_4_15) V(Node10_5_0) V(Node10_5_1) V(Node10_5_2) V(Node10_5_3) V(Node10_5_4) V(Node10_5_5) V(Node10_5_6) V(Node10_5_7) V(Node10_5_8) V(Node10_5_9) V(Node10_5_10) V(Node10_5_11) V(Node10_5_12) V(Node10_5_13) V(Node10_5_14) V(Node10_5_15) V(Node10_6_0) V(Node10_6_1) V(Node10_6_2) V(Node10_6_3) V(Node10_6_4) V(Node10_6_5) V(Node10_6_6) V(Node10_6_7) V(Node10_6_8) V(Node10_6_9) V(Node10_6_10) V(Node10_6_11) V(Node10_6_12) V(Node10_6_13) V(Node10_6_14) V(Node10_6_15) V(Node10_7_0) V(Node10_7_1) V(Node10_7_2) V(Node10_7_3) V(Node10_7_4) V(Node10_7_5) V(Node10_7_6) V(Node10_7_7) V(Node10_7_8) V(Node10_7_9) V(Node10_7_10) V(Node10_7_11) V(Node10_7_12) V(Node10_7_13) V(Node10_7_14) V(Node10_7_15) V(Node10_8_0) V(Node10_8_1) V(Node10_8_2) V(Node10_8_3) V(Node10_8_4) V(Node10_8_5) V(Node10_8_6) V(Node10_8_7) V(Node10_8_8) V(Node10_8_9) V(Node10_8_10) V(Node10_8_11) V(Node10_8_12) V(Node10_8_13) V(Node10_8_14) V(Node10_8_15) V(Node10_9_0) V(Node10_9_1) V(Node10_9_2) V(Node10_9_3) V(Node10_9_4) V(Node10_9_5) V(Node10_9_6) V(Node10_9_7) V(Node10_9_8) V(Node10_9_9) V(Node10_9_10) V(Node10_9_11) V(Node10_9_12) V(Node10_9_13) V(Node10_9_14) V(Node10_9_15) V(Node10_10_0) V(Node10_10_1) V(Node10_10_2) V(Node10_10_3) V(Node10_10_4) V(Node10_10_5) V(Node10_10_6) V(Node10_10_7) V(Node10_10_8) V(Node10_10_9) V(Node10_10_10) V(Node10_10_11) V(Node10_10_12) V(Node10_10_13) V(Node10_10_14) V(Node10_10_15) V(Node10_11_0) V(Node10_11_1) V(Node10_11_2) V(Node10_11_3) V(Node10_11_4) V(Node10_11_5) V(Node10_11_6) V(Node10_11_7) V(Node10_11_8) V(Node10_11_9) V(Node10_11_10) V(Node10_11_11) V(Node10_11_12) V(Node10_11_13) V(Node10_11_14) V(Node10_11_15) V(Node10_12_0) V(Node10_12_1) V(Node10_12_2) V(Node10_12_3) V(Node10_12_4) V(Node10_12_5) V(Node10_12_6) V(Node10_12_7) V(Node10_12_8) V(Node10_12_9) V(Node10_12_10) V(Node10_12_11) V(Node10_12_12) V(Node10_12_13) V(Node10_12_14) V(Node10_12_15) V(Node10_13_0) V(Node10_13_1) V(Node10_13_2) V(Node10_13_3) V(Node10_13_4) V(Node10_13_5) V(Node10_13_6) V(Node10_13_7) V(Node10_13_8) V(Node10_13_9) V(Node10_13_10) V(Node10_13_11) V(Node10_13_12) V(Node10_13_13) V(Node10_13_14) V(Node10_13_15) V(Node10_14_0) V(Node10_14_1) V(Node10_14_2) V(Node10_14_3) V(Node10_14_4) V(Node10_14_5) V(Node10_14_6) V(Node10_14_7) V(Node10_14_8) V(Node10_14_9) V(Node10_14_10) V(Node10_14_11) V(Node10_14_12) V(Node10_14_13) V(Node10_14_14) V(Node10_14_15) V(Node10_15_0) V(Node10_15_1) V(Node10_15_2) V(Node10_15_3) V(Node10_15_4) V(Node10_15_5) V(Node10_15_6) V(Node10_15_7) V(Node10_15_8) V(Node10_15_9) V(Node10_15_10) V(Node10_15_11) V(Node10_15_12) V(Node10_15_13) V(Node10_15_14) V(Node10_15_15) V(Node11_0_0) V(Node11_0_1) V(Node11_0_2) V(Node11_0_3) V(Node11_0_4) V(Node11_0_5) V(Node11_0_6) V(Node11_0_7) V(Node11_0_8) V(Node11_0_9) V(Node11_0_10) V(Node11_0_11) V(Node11_0_12) V(Node11_0_13) V(Node11_0_14) V(Node11_0_15) V(Node11_1_0) V(Node11_1_1) V(Node11_1_2) V(Node11_1_3) V(Node11_1_4) V(Node11_1_5) V(Node11_1_6) V(Node11_1_7) V(Node11_1_8) V(Node11_1_9) V(Node11_1_10) V(Node11_1_11) V(Node11_1_12) V(Node11_1_13) V(Node11_1_14) V(Node11_1_15) V(Node11_2_0) V(Node11_2_1) V(Node11_2_2) V(Node11_2_3) V(Node11_2_4) V(Node11_2_5) V(Node11_2_6) V(Node11_2_7) V(Node11_2_8) V(Node11_2_9) V(Node11_2_10) V(Node11_2_11) V(Node11_2_12) V(Node11_2_13) V(Node11_2_14) V(Node11_2_15) V(Node11_3_0) V(Node11_3_1) V(Node11_3_2) V(Node11_3_3) V(Node11_3_4) V(Node11_3_5) V(Node11_3_6) V(Node11_3_7) V(Node11_3_8) V(Node11_3_9) V(Node11_3_10) V(Node11_3_11) V(Node11_3_12) V(Node11_3_13) V(Node11_3_14) V(Node11_3_15) V(Node11_4_0) V(Node11_4_1) V(Node11_4_2) V(Node11_4_3) V(Node11_4_4) V(Node11_4_5) V(Node11_4_6) V(Node11_4_7) V(Node11_4_8) V(Node11_4_9) V(Node11_4_10) V(Node11_4_11) V(Node11_4_12) V(Node11_4_13) V(Node11_4_14) V(Node11_4_15) V(Node11_5_0) V(Node11_5_1) V(Node11_5_2) V(Node11_5_3) V(Node11_5_4) V(Node11_5_5) V(Node11_5_6) V(Node11_5_7) V(Node11_5_8) V(Node11_5_9) V(Node11_5_10) V(Node11_5_11) V(Node11_5_12) V(Node11_5_13) V(Node11_5_14) V(Node11_5_15) V(Node11_6_0) V(Node11_6_1) V(Node11_6_2) V(Node11_6_3) V(Node11_6_4) V(Node11_6_5) V(Node11_6_6) V(Node11_6_7) V(Node11_6_8) V(Node11_6_9) V(Node11_6_10) V(Node11_6_11) V(Node11_6_12) V(Node11_6_13) V(Node11_6_14) V(Node11_6_15) V(Node11_7_0) V(Node11_7_1) V(Node11_7_2) V(Node11_7_3) V(Node11_7_4) V(Node11_7_5) V(Node11_7_6) V(Node11_7_7) V(Node11_7_8) V(Node11_7_9) V(Node11_7_10) V(Node11_7_11) V(Node11_7_12) V(Node11_7_13) V(Node11_7_14) V(Node11_7_15) V(Node11_8_0) V(Node11_8_1) V(Node11_8_2) V(Node11_8_3) V(Node11_8_4) V(Node11_8_5) V(Node11_8_6) V(Node11_8_7) V(Node11_8_8) V(Node11_8_9) V(Node11_8_10) V(Node11_8_11) V(Node11_8_12) V(Node11_8_13) V(Node11_8_14) V(Node11_8_15) V(Node11_9_0) V(Node11_9_1) V(Node11_9_2) V(Node11_9_3) V(Node11_9_4) V(Node11_9_5) V(Node11_9_6) V(Node11_9_7) V(Node11_9_8) V(Node11_9_9) V(Node11_9_10) V(Node11_9_11) V(Node11_9_12) V(Node11_9_13) V(Node11_9_14) V(Node11_9_15) V(Node11_10_0) V(Node11_10_1) V(Node11_10_2) V(Node11_10_3) V(Node11_10_4) V(Node11_10_5) V(Node11_10_6) V(Node11_10_7) V(Node11_10_8) V(Node11_10_9) V(Node11_10_10) V(Node11_10_11) V(Node11_10_12) V(Node11_10_13) V(Node11_10_14) V(Node11_10_15) V(Node11_11_0) V(Node11_11_1) V(Node11_11_2) V(Node11_11_3) V(Node11_11_4) V(Node11_11_5) V(Node11_11_6) V(Node11_11_7) V(Node11_11_8) V(Node11_11_9) V(Node11_11_10) V(Node11_11_11) V(Node11_11_12) V(Node11_11_13) V(Node11_11_14) V(Node11_11_15) V(Node11_12_0) V(Node11_12_1) V(Node11_12_2) V(Node11_12_3) V(Node11_12_4) V(Node11_12_5) V(Node11_12_6) V(Node11_12_7) V(Node11_12_8) V(Node11_12_9) V(Node11_12_10) V(Node11_12_11) V(Node11_12_12) V(Node11_12_13) V(Node11_12_14) V(Node11_12_15) V(Node11_13_0) V(Node11_13_1) V(Node11_13_2) V(Node11_13_3) V(Node11_13_4) V(Node11_13_5) V(Node11_13_6) V(Node11_13_7) V(Node11_13_8) V(Node11_13_9) V(Node11_13_10) V(Node11_13_11) V(Node11_13_12) V(Node11_13_13) V(Node11_13_14) V(Node11_13_15) V(Node11_14_0) V(Node11_14_1) V(Node11_14_2) V(Node11_14_3) V(Node11_14_4) V(Node11_14_5) V(Node11_14_6) V(Node11_14_7) V(Node11_14_8) V(Node11_14_9) V(Node11_14_10) V(Node11_14_11) V(Node11_14_12) V(Node11_14_13) V(Node11_14_14) V(Node11_14_15) V(Node11_15_0) V(Node11_15_1) V(Node11_15_2) V(Node11_15_3) V(Node11_15_4) V(Node11_15_5) V(Node11_15_6) V(Node11_15_7) V(Node11_15_8) V(Node11_15_9) V(Node11_15_10) V(Node11_15_11) V(Node11_15_12) V(Node11_15_13) V(Node11_15_14) V(Node11_15_15) V(Node12_0_0) V(Node12_0_1) V(Node12_0_2) V(Node12_0_3) V(Node12_0_4) V(Node12_0_5) V(Node12_0_6) V(Node12_0_7) V(Node12_0_8) V(Node12_0_9) V(Node12_0_10) V(Node12_0_11) V(Node12_0_12) V(Node12_0_13) V(Node12_0_14) V(Node12_0_15) V(Node12_1_0) V(Node12_1_1) V(Node12_1_2) V(Node12_1_3) V(Node12_1_4) V(Node12_1_5) V(Node12_1_6) V(Node12_1_7) V(Node12_1_8) V(Node12_1_9) V(Node12_1_10) V(Node12_1_11) V(Node12_1_12) V(Node12_1_13) V(Node12_1_14) V(Node12_1_15) V(Node12_2_0) V(Node12_2_1) V(Node12_2_2) V(Node12_2_3) V(Node12_2_4) V(Node12_2_5) V(Node12_2_6) V(Node12_2_7) V(Node12_2_8) V(Node12_2_9) V(Node12_2_10) V(Node12_2_11) V(Node12_2_12) V(Node12_2_13) V(Node12_2_14) V(Node12_2_15) V(Node12_3_0) V(Node12_3_1) V(Node12_3_2) V(Node12_3_3) V(Node12_3_4) V(Node12_3_5) V(Node12_3_6) V(Node12_3_7) V(Node12_3_8) V(Node12_3_9) V(Node12_3_10) V(Node12_3_11) V(Node12_3_12) V(Node12_3_13) V(Node12_3_14) V(Node12_3_15) V(Node12_4_0) V(Node12_4_1) V(Node12_4_2) V(Node12_4_3) V(Node12_4_4) V(Node12_4_5) V(Node12_4_6) V(Node12_4_7) V(Node12_4_8) V(Node12_4_9) V(Node12_4_10) V(Node12_4_11) V(Node12_4_12) V(Node12_4_13) V(Node12_4_14) V(Node12_4_15) V(Node12_5_0) V(Node12_5_1) V(Node12_5_2) V(Node12_5_3) V(Node12_5_4) V(Node12_5_5) V(Node12_5_6) V(Node12_5_7) V(Node12_5_8) V(Node12_5_9) V(Node12_5_10) V(Node12_5_11) V(Node12_5_12) V(Node12_5_13) V(Node12_5_14) V(Node12_5_15) V(Node12_6_0) V(Node12_6_1) V(Node12_6_2) V(Node12_6_3) V(Node12_6_4) V(Node12_6_5) V(Node12_6_6) V(Node12_6_7) V(Node12_6_8) V(Node12_6_9) V(Node12_6_10) V(Node12_6_11) V(Node12_6_12) V(Node12_6_13) V(Node12_6_14) V(Node12_6_15) V(Node12_7_0) V(Node12_7_1) V(Node12_7_2) V(Node12_7_3) V(Node12_7_4) V(Node12_7_5) V(Node12_7_6) V(Node12_7_7) V(Node12_7_8) V(Node12_7_9) V(Node12_7_10) V(Node12_7_11) V(Node12_7_12) V(Node12_7_13) V(Node12_7_14) V(Node12_7_15) V(Node12_8_0) V(Node12_8_1) V(Node12_8_2) V(Node12_8_3) V(Node12_8_4) V(Node12_8_5) V(Node12_8_6) V(Node12_8_7) V(Node12_8_8) V(Node12_8_9) V(Node12_8_10) V(Node12_8_11) V(Node12_8_12) V(Node12_8_13) V(Node12_8_14) V(Node12_8_15) V(Node12_9_0) V(Node12_9_1) V(Node12_9_2) V(Node12_9_3) V(Node12_9_4) V(Node12_9_5) V(Node12_9_6) V(Node12_9_7) V(Node12_9_8) V(Node12_9_9) V(Node12_9_10) V(Node12_9_11) V(Node12_9_12) V(Node12_9_13) V(Node12_9_14) V(Node12_9_15) V(Node12_10_0) V(Node12_10_1) V(Node12_10_2) V(Node12_10_3) V(Node12_10_4) V(Node12_10_5) V(Node12_10_6) V(Node12_10_7) V(Node12_10_8) V(Node12_10_9) V(Node12_10_10) V(Node12_10_11) V(Node12_10_12) V(Node12_10_13) V(Node12_10_14) V(Node12_10_15) V(Node12_11_0) V(Node12_11_1) V(Node12_11_2) V(Node12_11_3) V(Node12_11_4) V(Node12_11_5) V(Node12_11_6) V(Node12_11_7) V(Node12_11_8) V(Node12_11_9) V(Node12_11_10) V(Node12_11_11) V(Node12_11_12) V(Node12_11_13) V(Node12_11_14) V(Node12_11_15) V(Node12_12_0) V(Node12_12_1) V(Node12_12_2) V(Node12_12_3) V(Node12_12_4) V(Node12_12_5) V(Node12_12_6) V(Node12_12_7) V(Node12_12_8) V(Node12_12_9) V(Node12_12_10) V(Node12_12_11) V(Node12_12_12) V(Node12_12_13) V(Node12_12_14) V(Node12_12_15) V(Node12_13_0) V(Node12_13_1) V(Node12_13_2) V(Node12_13_3) V(Node12_13_4) V(Node12_13_5) V(Node12_13_6) V(Node12_13_7) V(Node12_13_8) V(Node12_13_9) V(Node12_13_10) V(Node12_13_11) V(Node12_13_12) V(Node12_13_13) V(Node12_13_14) V(Node12_13_15) V(Node12_14_0) V(Node12_14_1) V(Node12_14_2) V(Node12_14_3) V(Node12_14_4) V(Node12_14_5) V(Node12_14_6) V(Node12_14_7) V(Node12_14_8) V(Node12_14_9) V(Node12_14_10) V(Node12_14_11) V(Node12_14_12) V(Node12_14_13) V(Node12_14_14) V(Node12_14_15) V(Node12_15_0) V(Node12_15_1) V(Node12_15_2) V(Node12_15_3) V(Node12_15_4) V(Node12_15_5) V(Node12_15_6) V(Node12_15_7) V(Node12_15_8) V(Node12_15_9) V(Node12_15_10) V(Node12_15_11) V(Node12_15_12) V(Node12_15_13) V(Node12_15_14) V(Node12_15_15)
.SAVE TYPE=IC
.end
